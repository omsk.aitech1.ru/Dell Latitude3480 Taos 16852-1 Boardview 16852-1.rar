# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_CS#0: length 76.5
  TOP w0.216: v1(84.66,15.96) v2(84.1,15.96)
  L4 w0.102: v1(106.88,67.47) 106.58,67.17 106.58,66.76 107.09,66.25 107.09,62.54 107.59,62.03 107.59,55.23 107.65,55.18
  L4 w0.178: v1(84.66,15.96) 85.6,15.96 86.21,16.57 86.21,18.15 90.96,22.9 93.04,22.9 101.23,31.08 101.23,31.37 100.5,32.1 100.5,32.52 100.8,32.82 101.22,32.82 101.95,32.09 102.31,32.09 102.67,32.45 102.67,32.81 101.91,33.57 101.91,33.92 102.27,34.28 102.63,34.28 103.42,33.49 103.78,33.49 104.14,33.85 104.14,34.21 103.39,34.96 103.39,35.38 103.69,35.68 104.11,35.68 104.56,35.22 104.99,35.22 105.29,35.52 105.29,35.95 104.79,36.44 104.79,36.73 108.08,40.02 108.08,54.75 107.65,55.18
  BOTTOM w0.216: v1(106.88,67.47) 106.61,67.2 CPU1.AU45 ; DM1.149 83.73,16.89 84.17,16.45 84.17,16.44 84.44,16.17 84.45,16.17 v1(84.66,15.96)
M_A_CS#1: length 77.4
  TOP w0.216: v1(87.43,15.15) 87.15,15.15 v2(86.84,15.45)
  L4 w0.102: v1(107.8,67.51) 108.25,67.05 108.25,61.28 108.65,60.88 108.65,57.85 108.84,57.67
  L4 w0.178: v1(87.43,15.15) 86.92,15.66 86.92,17.39 91.36,21.83 93.7,21.83 94.23,22.36 94.52,22.36 94.95,21.93 95.37,21.93 95.67,22.22 95.67,22.65 95.29,23.03 95.29,23.39 95.65,23.75 96.01,23.75 96.47,23.29 96.89,23.29 97.18,23.59 97.18,24.01 96.68,24.52 96.68,24.8 97.11,25.23 97.39,25.23 97.98,24.65 98.4,24.65 98.7,24.95 98.7,25.37 98.11,25.95 98.11,26.24 98.41,26.54 98.7,26.54 99.19,26.04 99.61,26.04 99.91,26.34 99.91,26.76 99.42,27.26 99.42,27.54 109.09,37.22 109.09,53.81 108.84,54.06 108.84,57.67
  BOTTOM w0.216: DM1.157 85.72,18.68 85.79,18.62 85.79,18.5 85.79,18.5 85.79,16.78 v1(87.43,15.15) ; CPU1.AU43 107.48,67.2 107.75,67.47 107.76,67.47 v1(107.8,67.51)
M_A_DIMA_ODT0: length 75.2
  TOP w0.216: v2(87.91,14.51) 87.73,14.34 v1(87.38,14.34)
  L4 w0.102: v1(106.87,68.18) 107.28,67.77 107.28,62.63 107.82,62.09 107.82,61.43 108.45,60.8 108.45,56.79 108.53,56.7
  L4 w0.178: v1(87.38,14.34) 86.61,15.1 86.61,17.77 91.21,22.36 93.37,22.36 106.07,35.06 106.07,37.29 106.35,37.57 106.64,37.57 107.4,36.81 107.82,36.81 108.12,37.11 108.12,37.53 107.36,38.29 107.36,38.56 108.56,39.76 108.56,46.92 108.53,46.95 108.53,56.7
  BOTTOM w0.216: v1(87.38,14.34) 87.22,14.49 87.07,14.49 86.61,14.95 86.61,15.5 85.47,16.65 85.47,17.63 85.48,17.63 85.48,18.36 85.47,18.37 85.47,18.49 85.23,18.73 85.23,19.6 DM1.155 ; v1(106.87,68.18) 106.55,67.85 CPU1.AT45
M_A_DIMA_ODT1: length 76.1
  TOP w0.216: v2(86.89,16.77) 87.18,16.77 87.41,16.55 v1(87.41,16.52)
  L4 w0.102: v1(107.77,68.16) 108.25,67.68 108.25,67.35 108.44,67.16 108.44,61.42 109,60.86 109,60.34
  L4 w0.178: 109,60.34 109,58.34 109.14,58.2 109.14,54.38 109.47,54.05 109.47,47.61 109.6,47.48 109.6,36.99 105.53,32.92 105.53,32.4 106.14,31.78 106.14,31.35 105.61,30.82 105.18,30.82 104.5,31.5 104.21,31.5 103.78,31.07 103.78,30.79 104.44,30.12 104.44,29.7 104.15,29.4 103.73,29.4 103.06,30.07 102.78,30.07 102.35,29.64 102.35,29.35 103.08,28.61 103.08,28.19 102.79,27.89 102.36,27.89 101.63,28.63 101.34,28.63 100.91,28.2 100.91,27.91 101.48,27.33 101.48,27.01 95.59,21.12 91.42,21.12 88.43,18.13 88.43,17.55 v1(87.41,16.52)
  BOTTOM w0.216: CPU1.AT43 107.42,67.85 107.68,68.11 107.73,68.11 v1(107.77,68.16) ; DM1.161 86.72,17.2 v1(87.41,16.52)
M_A_DQ0: length 86.9
  TOP w0.14: v1(45.35,14.49) 45.59,14.49 v2(45.92,14.16)
  L4 w0.114: v1(45.35,14.49) 45.19,14.49 44.9,14.77 44.9,16.43 44.68,16.66 44.68,18.5 52.45,26.27 52.45,27.8 74.36,49.71 74.36,58.47 74.8,58.91 74.8,63.99 82.32,71.51 87.93,71.51 88.38,71.06 v1(88.38,70.69)
  BOTTOM w0.089: CPU1.AL71 91.13,70.91 91.06,70.97 88.67,70.97 v1(88.38,70.69)
  BOTTOM w0.14: v1(45.35,14.49) 46.38,13.47 46.38,12.84 46.48,12.74 46.48,11.4 DM1.8
M_A_DQ1: length 87.7
  TOP w0.14: v1(45.32,16.03) 45.55,16.03 v2(45.82,15.76)
  L4 w0.114: v1(45.32,16.03) 45.63,15.73 45.99,15.73 46.2,15.94 46.2,16.42 45.8,16.83 45.8,18.73 46.81,19.75 47.76,19.75 53.34,25.33 53.34,27.68 75.16,49.5 75.16,58.3 75.51,58.66 75.51,63.69 82.56,70.74 84.03,70.74 v1(84.18,70.6)
  BOTTOM w0.089: CPU1.AL68 92.93,71.18 91.71,71.23 91.58,71.29 91.53,71.31 91.45,71.33 91.4,71.36 90.19,71.33 89.08,71.33 88.93,71.47 85.05,71.47 v1(84.18,70.6)
  BOTTOM w0.14: v1(45.32,16.03) 45.51,16.22 45.51,16.22 45.84,16.54 45.84,17.88 46.22,18.27 DM1.7
M_A_DQ2: length 87.8
  TOP w0.14: v1(48.44,14.46) 48.44,14.59 v2(48.77,14.92)
  L4 w0.114: v1(94.13,70.2) 93.4,70.2 93.13,69.94 86.89,69.94 86.59,69.63 85.24,69.63 84.75,69.15 84.07,69.15 81.23,66.3 80.45,66.3 76.83,62.68 76.83,58.13 76.55,57.85 76.55,48.8 54.73,26.97 54.73,24.79 47.57,17.64 47.57,15.83 47.12,15.38 47.12,14.41 47.4,14.13 48.11,14.13 v1(48.44,14.46)
  BOTTOM w0.14: v1(94.13,70.2) 93.94,70.2 93.42,69.68 CPU1.AN68 ; v1(48.44,14.46) 48.59,14.46 49.48,13.58 49.48,11.4 DM1.20
M_A_DQ3: length 87
  TOP w0.14: v1(49.73,17.94) v2(50.4,17.94)
  L4 w0.114: v1(49.73,17.94) 49.73,18.25 55.79,24.31 55.79,26.53 77.64,48.37 77.64,53.3 78.51,54.18 78.51,54.66 78.64,54.78 78.91,54.78 79.04,54.91 79.04,55.16 78.91,55.29 78.64,55.29 78.51,55.42 78.51,55.67 78.64,55.8 78.95,55.8 79.08,55.93 79.08,56.18 78.95,56.31 78.64,56.31 78.51,56.43 78.51,56.83 77.88,57.46 77.88,62.23 80.87,65.21 81.66,65.21 81.94,65.49 82.12,65.49 83.3,64.31 83.48,64.31 83.66,64.49 83.66,64.67 82.48,65.85 82.48,66.03 82.66,66.21 82.84,66.21 83.94,65.11 84.12,65.11 84.3,65.29 84.3,65.47 83.2,66.57 83.2,66.75 83.38,66.93 83.56,66.93 84.09,66.4 84.27,66.4 84.45,66.58 84.45,66.76 83.92,67.29 83.92,67.47 84.53,68.08 85.67,68.08 86.11,68.51 87.76,68.51 87.88,68.39 89.09,68.39 v1(89.55,68.85)
  BOTTOM w0.089: v1(89.55,68.85) 89.55,69 89.77,69.21 91.01,69.21 91.08,69.14 91.53,69.14 91.61,69.23 91.85,69.23 91.9,69.28 92.13,69.28 92.54,69.68 CPU1.AN69
  BOTTOM w0.14: v1(49.73,17.94) 49.73,18.32 49.73,18.33 49.73,19.6 DM1.21
M_A_DQ4: length 87.2
  TOP w0.14: v1(45.35,13.07) v2(45.35,12.42)
  L4 w0.114: v1(85.12,70.67) 84.91,70.67 84.35,70.11 82.43,70.11 75.86,63.55 75.86,58.53 75.51,58.17 75.51,49.33 53.7,27.52 53.7,25.18 47.79,19.27 46.77,19.27 46.02,18.53 46.02,16.98 46.43,16.57 46.43,15.96 46.79,15.61 46.79,15.18 46.66,15.05 46.38,15.05 46.25,14.93 46.25,14.67 46.38,14.55 46.66,14.55 46.79,14.42 46.79,13.75 46.1,13.07 v1(45.35,13.07)
  BOTTOM w0.089: CPU1.AL70 91.6,71.03 91.5,71.13 91.47,71.14 91.37,71.17 90.34,71.15 90.33,71.15 87.79,71.15 87.79,71.16 85.62,71.16 85.13,70.67 v1(85.12,70.67)
  BOTTOM w0.14: v1(45.35,13.07) 45.48,12.95 45.48,11.4 DM1.4
M_A_DQ5: length 87.9
  TOP w0.14: v1(45.32,17.3) v2(45.89,17.3)
  L4 w0.114: v1(87.71,70.65) 87.71,70.85 87.4,71.16 82.47,71.16 75.15,63.84 75.15,58.78 74.8,58.43 74.8,49.64 52.96,27.8 52.96,25.45 50,22.49 49.82,22.49 49.57,22.73 49.4,22.73 49.21,22.55 49.21,22.37 49.47,22.11 49.47,21.94 49.28,21.76 49.11,21.76 48.85,22.02 48.68,22.02 48.49,21.83 48.49,21.66 48.76,21.38 48.76,21.23 48.55,21.02 48.4,21.02 48.14,21.29 47.96,21.29 47.78,21.11 47.78,20.93 48.02,20.69 48.02,20.51 47.76,20.25 46.91,20.25 44.9,18.24 44.9,17.49 45.09,17.3 v1(45.32,17.3)
  BOTTOM w0.089: v1(87.71,70.65) 87.71,70.41 88.06,70.06 88.54,70.06 88.77,70.29 88.77,70.57 89,70.8 90.99,70.8 91.05,70.73 91.14,70.65 92.35,70.65 CPU1.AL69
  BOTTOM w0.14: DM1.3 45.22,18.58 44.77,18.13 44.77,17.59 45.06,17.3 v1(45.32,17.3)
M_A_DQ6: length 85.8
  TOP w0.14: v1(48.44,13.08) 48.44,12.66 v2(48.59,12.51)
  L4 w0.114: v1(88.25,68.95) 88.25,69.31 87.99,69.58 87.04,69.58 86.73,69.28 85.38,69.28 84.9,68.79 84.23,68.79 81.38,65.95 80.6,65.95 77.19,62.53 77.19,58 76.92,57.73 76.92,48.67 55.08,26.82 55.08,24.6 47.93,17.45 47.93,15.76 47.55,15.38 47.55,14.94 47.73,14.77 48.03,14.77 48.34,15.07 49.28,15.07 49.59,14.75 49.59,13.34 49.22,12.96 48.55,12.96 v1(48.44,13.08)
  BOTTOM w0.089: CPU1.AN70 91.78,69.4 91.54,69.4 91.46,69.32 91.15,69.32 91.08,69.39 89.3,69.39 89.11,69.2 88.69,69.2 88.56,69.07 88.37,69.07 v1(88.25,68.95)
  BOTTOM w0.14: DM1.16 48.48,11.4 48.48,13.04 v1(48.44,13.08)
M_A_DQ7: length 85.4
  TOP w0.14: v2(49.15,16.24) 49.36,16.03 v1(49.73,16.03)
  L4 w0.114: v1(49.73,16.03) 49.51,16.03 48.97,16.57 48.49,16.57 48.36,16.7 48.36,16.95 48.49,17.08 49.19,17.08 49.32,17.21 49.32,18.33 55.44,24.46 55.44,26.68 77.28,48.52 77.28,54.1 77.41,54.22 77.95,54.22 78.08,54.35 78.08,54.6 77.95,54.73 77.41,54.73 77.28,54.86 77.28,55.11 77.41,55.24 77.98,55.24 78.11,55.37 78.11,55.62 77.98,55.75 77.41,55.75 77.28,55.87 77.28,56.13 77.41,56.26 78.03,56.26 78.16,56.38 78.16,56.64 78.03,56.76 77.41,56.76 77.28,56.89 77.28,57.6 77.54,57.87 77.54,62.39 80.75,65.59 81.53,65.59 84.37,68.44 85.47,68.44 85.96,68.92 87.43,68.92 v1(87.57,69.07)
  BOTTOM w0.089: CPU1.AN71 89.21,69.58 89.05,69.42 88.64,69.42 88.56,69.34 87.82,69.34 87.59,69.11 87.59,69.09 v1(87.57,69.07)
  BOTTOM w0.14: DM1.17 48.72,18.57 48.79,18.51 48.79,16.93 49.69,16.03 v1(49.73,16.03)
M_A_DQ8: length 79.9
  TOP w0.14: v2(50.57,15.3) 50.55,15.28 v1(50.55,14.72)
  L4 w0.114: v1(86.44,67.07) 86.44,66.37 86.16,66.09 86.16,62.1 85.04,60.98 85.04,59.04 80.52,54.52 80.52,53.19 80.2,52.86 80.02,52.86 79.66,53.22 79.48,53.22 79.3,53.04 79.3,52.86 79.66,52.5 79.66,52.32 79.48,52.14 79.3,52.14 79.1,52.34 78.83,52.34 78.7,52.21 78.7,47.93 56.86,26.09 56.86,23.75 50.8,17.69 50.8,15.66 50.55,15.4 v1(50.55,14.72)
  BOTTOM w0.089: CPU1.AR70 91.96,68.51 91.78,68.33 91.53,68.33 91.32,68.28 90.54,68.28 90.5,68.24 89.75,68.24 89.61,68.1 86.86,68.1 86.46,67.7 86.46,67.09 v1(86.44,67.07)
  BOTTOM w0.14: DM1.28 51.48,11.4 51.48,13.79 v1(50.55,14.72)
M_A_DQ9: length 79.7
  TOP w0.14: v2(52.78,17.16) 52.6,16.98 v1(52.2,16.98)
  L4 w0.114: v1(52.2,16.98) 52.58,16.59 52.83,16.59 53.09,16.85 53.09,18.47 57.83,23.21 57.83,25.69 79.68,47.54 79.68,50.98 83.03,54.33 83.03,55.67 83.4,56.03 83.58,56.03 84,55.61 84.18,55.61 84.36,55.79 84.36,55.97 83.94,56.39 83.94,56.57 84.12,56.75 84.3,56.75 84.71,56.33 84.89,56.33 85.07,56.51 85.07,56.69 84.66,57.11 84.66,57.29 84.83,57.47 85.01,57.47 85.43,57.05 85.61,57.05 85.79,57.23 85.79,57.41 85.37,57.83 85.37,58.01 86,58.64 86,60.46 87.12,61.58 87.12,65.58 88.43,66.89 90.81,66.89 v1(92.98,69.05)
  BOTTOM w0.14: CPU1.AR68 93.26,68.5 92.98,68.77 v1(92.98,69.05) ; v1(52.2,16.98) 52.07,16.98 51.73,17.32 51.73,19.6 DM1.29
M_A_DQ10: length 78.1
  TOP w0.14: v1(53.87,15.86) 53.27,15.86 v2(53.26,15.86)
  L4 w0.114: v1(87.76,65.64) 88.16,66.05 88.84,66.05 89.13,65.76 89.13,65.63 89.61,65.15 89.61,62.55 87.2,60.13 87.2,56.97 80.77,50.55 80.77,47.13 60.67,27.02 60.67,23.98 54.86,18.17 54.86,16.09 54.89,16.09 55.14,15.83 55.14,15.05 55.02,14.92 54.53,14.92 54.41,15.05 54.41,15.43 53.97,15.86 v1(53.87,15.86)
  BOTTOM w0.089: v1(87.76,65.64) 87.76,65.77 88.81,66.82 90.62,66.82 90.93,67.14 90.95,67.14 91.05,67.23 CPU1.AU71
  BOTTOM w0.14: DM1.41 54.73,19.6 54.73,16.59 54.04,15.91 53.92,15.91 53.87,15.86 v1(53.87,15.86)
M_A_DQ11: length 78.9
  TOP w0.14: v1(53.95,14.39) v2(54.53,14.39)
  L4 w0.114: v1(53.95,14.39) 54.48,14.39 54.76,14.11 54.76,13.29 54.89,13.17 55.75,13.17 55.88,13.29 55.88,14.06 55.55,14.39 55.55,14.79 55.85,15.1 55.85,15.55 55.12,16.28 55.12,17.89 61.03,23.8 61.03,26.88 81.13,46.98 81.13,50.4 87.55,56.83 87.55,59.98 90.22,62.65 v1(90.22,65.82)
  BOTTOM w0.089: CPU1.AU68 93.26,66.51 92.96,66.21 91.08,66.21 90.84,65.97 90.42,65.97 90.27,65.82 v1(90.22,65.82)
  BOTTOM w0.14: v1(53.95,14.39) 54.41,14.39 54.97,13.82 DM1.42
M_A_DQ12: length 78.2
  TOP w0.14: v1(50.54,13.17) 50.06,13.17 v2(49.89,13.35)
  L4 w0.114: v1(85.83,66.76) 85.72,66.66 85.72,62.17 84.68,61.13 84.68,59.34 78.55,53.22 78.35,53.01 78.35,48.08 56.51,26.24 56.51,23.9 50.57,17.96 50.57,15.96 49.95,15.34 49.95,13.45 50.23,13.17 v1(50.54,13.17)
  BOTTOM w0.089: v1(85.83,66.76) 85.83,67.57 86.72,68.46 88.67,68.46 88.73,68.4 89.05,68.4 89.06,68.41 90.43,68.41 90.57,68.55 CPU1.AR71
  BOTTOM w0.14: DM1.24 50.48,11.4 50.48,13.11 v1(50.54,13.17)
M_A_DQ13: length 79.3
  TOP w0.14: v2(50.42,16.67) 50.19,16.67 50.18,16.67 v1(49.73,16.67)
  L4 w0.114: v1(49.73,16.67) 50.29,17.22 50.29,18.25 56.15,24.11 56.15,26.38 77.99,48.22 77.99,53.16 78.41,53.57 84.33,59.49 84.33,61.28 85.22,62.17 85.22,63.33 84.81,63.74 84.81,64.19 84.94,64.32 85.19,64.32 85.32,64.45 85.32,64.7 85.19,64.83 84.94,64.83 84.81,64.96 84.81,65.21 84.94,65.34 85.19,65.34 85.32,65.46 85.32,65.72 85.19,65.85 84.94,65.85 84.81,65.97 84.81,66.37 86.59,68.16 89.13,68.16 v1(89.64,67.65)
  BOTTOM w0.089: v1(89.64,67.65) 89.68,67.69 89.68,67.73 90.01,68.06 90.63,68.06 90.66,68.09 90.69,68.09 90.7,68.1 91.34,68.1 91.56,68.15 91.99,68.15 92.25,68.28 CPU1.AR69
  BOTTOM w0.14: v1(49.73,16.67) 50.11,16.67 50.75,17.31 50.75,18.54 50.73,18.57 50.73,19.6 DM1.25
M_A_DQ14: length 77.8
  TOP w0.14: v1(53.93,12.98) 54.11,12.98 v2(54.43,12.66)
  L4 w0.114: v1(87.73,64.88) 87.73,61.68 86.36,60.31 86.36,57.14 80.06,50.84 80.06,47.42 58.18,25.54 58.18,23.06 53.31,18.2 53.31,15.3 52.88,14.87 52.88,14.43 53.01,14.31 53.21,14.31 53.34,14.18 53.34,13.93 53.21,13.8 53.01,13.8 52.88,13.67 52.88,13.42 53.19,13.11 53.19,12.91 52.88,12.61 52.88,12.2 53.01,12.08 53.9,12.08 54.03,12.2 54.03,12.88 v1(53.93,12.98)
  BOTTOM w0.089: CPU1.AU70 91.69,66.96 91.01,66.96 90.68,66.63 89.07,66.63 88.14,65.7 88.14,65.48 88.14,65.48 88.14,65.19 87.86,64.91 87.76,64.91 v1(87.73,64.88)
  BOTTOM w0.14: 53.98,11.4 53.98,12.94 v1(53.93,12.98)
M_A_DQ15: length 78.4
  TOP w0.14: v1(53.91,17.21) v2(54.48,17.21)
  L4 w0.114: v1(88.67,65.64) 88.72,65.64 89.33,65.03 89.33,64.81 89.2,64.68 88.34,64.68 88.21,64.55 88.21,64.3 88.34,64.17 89.2,64.17 89.33,64.05 89.33,63.79 89.2,63.66 88.24,63.66 88.11,63.54 88.11,63.28 88.24,63.16 89.2,63.16 89.33,63.03 89.33,62.78 88.57,62.02 88.57,62.02 86.84,60.29 86.84,57.12 80.42,50.69 80.42,47.27 60.32,27.17 60.32,24.13 58.36,22.17 58.18,22.17 58.09,22.26 57.91,22.26 57.73,22.08 57.73,21.9 57.82,21.81 57.82,21.63 57.64,21.45 57.46,21.45 57.37,21.54 57.19,21.54 57.01,21.36 57.01,21.18 57.1,21.09 57.1,20.91 56.92,20.73 56.74,20.73 56.65,20.82 56.47,20.82 56.29,20.64 56.29,20.46 56.38,20.37 56.38,20.19 56.2,20.01 56.02,20.01 55.93,20.1 55.75,20.1 55.57,19.92 55.57,19.74 55.66,19.65 55.66,19.47 55.48,19.29 55.3,19.29 55.21,19.38 55.03,19.38 54.85,19.2 54.85,19.02 54.94,18.93 54.94,18.75 54.45,18.26 53.8,18.26 53.56,18.01 53.56,17.56 v1(53.91,17.21)
  BOTTOM w0.089: CPU1.AU69 92.3,66.92 91.98,66.92 91.83,66.77 91.07,66.77 90.75,66.45 89.25,66.45 88.67,65.87 v1(88.67,65.64)
  BOTTOM w0.14: v1(53.91,17.21) 53.55,17.57 53.55,18.43 53.73,18.61 53.73,19.6 DM1.37
M_A_DQ16: length 70.4
  L4 w0.114: v1(89.78,58.06) 89.52,58.06 88.98,57.52 88.98,56.01 82.55,49.58 82.55,46.39 62.45,26.29 62.45,23.1 56.87,17.52 56.87,15.63 v1(56.57,15.33)
  BOTTOM w0.089: v1(89.78,58.06) 89.84,58.06 90.7,58.92 v2(90.7,59.29) 90.7,59.77 90.83,59.89 90.83,60.96 91.48,61.61 93.65,61.61 94.98,62.94 94.98,63.82 95.06,63.91 CPU1.BB65
  BOTTOM w0.14: v1(56.57,15.33) 57.12,14.77 57.12,12.91 56.98,12.77 56.98,12.41 56.97,12.41 DM1.50
M_A_DQ17: length 73
  TOP w0.14: v2(55.52,15.58) 55.88,15.94 v1(55.88,16.11)
  L4 w0.114: v1(89.79,61.33) 89.53,61.33 87.91,59.7 87.91,56.45 81.69,50.23 81.48,50.02 81.48,46.83 61.38,26.73 61.38,23.62 55.4,17.64 55.4,16.6 v1(55.88,16.11)
  BOTTOM w0.089: CPU1.AW65 94.71,65.35 94.71,65.14 94.67,65 94.63,64.88 94.49,64.74 94.35,64.74 94.18,64.65 94.14,64.49 94.14,64.32 94.16,64.25 94.16,63.18 93.14,62.16 91.17,62.16 90.34,61.33 v1(89.79,61.33)
  BOTTOM w0.14: v1(55.88,16.11) 55.98,16.11 56.96,17.09 56.96,18.39 56.73,18.62 56.73,19.6 DM1.49
M_A_DQ18: length 72.6
  L4 w0.114: v1(58.72,15) 58.46,15 58.17,15.29 58.17,15.63 59.11,16.57 59.11,18.35 63.41,22.65 63.41,25.89 83.58,46.06 83.58,49.15 90.42,55.99 90.42,59.45 91.61,60.64 v1(91.87,60.64)
  BOTTOM w0.089: v1(91.87,60.64) 91.9,60.67 v2(92.58,60.67) 93.04,60.67 93.39,61.02 93.91,61.02 96.16,63.27 96.16,63.64 95.95,63.85 95.95,64.19 95.99,64.33 95.99,65.21 95.95,65.25 95.95,65.52 96.1,65.78 CPU1.AW63
  BOTTOM w0.14: v1(58.72,15) 59.97,13.75 DM1.62
M_A_DQ19: length 71.6
  L4 w0.114: v1(60.27,17.79) 60.72,17.35 60.72,16.44 60.93,16.23 61.15,16.23 61.37,16.44 61.37,17.75 61.37,17.84 60.71,18.5 60.71,18.86 61.44,19.59 61.59,19.59 61.72,19.47 61.72,18.81 61.88,18.65 62.08,18.65 62.23,18.81 62.23,19.47 62.36,19.59 62.84,19.59 64.48,21.23 64.48,25.45 84.65,45.61 84.65,48.71 91.49,55.55 91.49,57.12 91.73,57.36 v1(91.92,57.36)
  BOTTOM w0.089: CPU1.AY63 96.69,64.84 96.69,63.83 96.69,63.82 96.69,63.05 94.13,60.49 93.61,60.49 92.73,59.6 v2(92.73,58.23) 92.73,57.7 92.42,57.39 91.95,57.39 v1(91.92,57.36)
  BOTTOM w0.14: v1(60.27,17.79) 60.08,17.98 60.08,18.44 60.22,18.58 DM1.63
M_A_DQ20: length 71.9
  TOP w0.14: v2(55.98,13.57) 56.26,13.85 v1(56.59,13.85)
  L4 w0.114: v1(89.8,59.36) 88.62,58.18 88.62,56.15 82.19,49.73 82.19,46.54 62.09,26.43 62.09,23.25 56.64,17.8 56.64,16.09 56.15,15.59 56.15,14.3 v1(56.59,13.85)
  BOTTOM w0.089: v1(89.8,59.36) 89.85,59.36 90.59,60.11 90.59,60.98 91.41,61.79 93.58,61.79 94.8,63.02 94.8,64.17 94.87,64.43 CPU1.BA65
  BOTTOM w0.14: v1(56.59,13.85) 55.97,13.24 DM1.46
M_A_DQ21: length 71.8
  TOP w0.14: v1(55.83,17.46) v2(55.83,18.07)
  L4 w0.114: v1(89.81,60.01) 89.39,60.42 89.11,60.42 88.75,60.06 88.75,59.85 89.18,59.42 89.18,59.24 89,59.07 88.82,59.07 88.52,59.37 88.34,59.37 88.27,59.3 88.27,56.3 81.84,49.88 81.84,46.68 61.74,26.58 61.74,23.4 56.41,18.07 56.41,17.64 56.16,17.39 55.9,17.39 v1(55.83,17.46)
  BOTTOM w0.089: CPU1.AY65 95.06,65.15 94.83,64.92 94.82,64.88 94.82,64.87 94.75,64.62 94.7,64.5 94.62,64.19 94.62,63.09 93.5,61.97 91.34,61.97 90.52,61.15 90.29,60.92 90.29,60.72 90.42,60.59 90.42,60.18 90.22,59.98 89.84,59.98 v1(89.81,60.01)
  BOTTOM w0.14: DM1.45 55.73,19.6 55.73,18.35 55.85,18.22 56.08,18.22 56.31,17.99 56.31,17.59 56.18,17.46 v1(55.83,17.46)
M_A_DQ22: length 71.7
  TOP w0.14: v1(58.69,13.73) 58.98,13.73 v2(59.26,13.45)
  L4 w0.114: v1(58.69,13.73) 58.98,13.73 59.51,14.26 59.51,18.43 61.16,20.08 62.12,20.08 62.44,20.4 62.44,21.18 62.76,21.5 63.44,21.5 63.77,21.83 63.77,25.74 83.94,45.91 83.94,49 90.78,55.84 90.78,58.43 91.64,59.29 v1(91.85,59.29)
  BOTTOM w0.089: v1(91.85,59.29) 91.92,59.37 91.99,59.37 93.47,60.84 93.99,60.84 96.34,63.2 96.34,63.71 96.13,63.92 96.13,64.17 96.19,64.43 CPU1.BA63
  BOTTOM w0.14: v1(58.69,13.73) 58.87,13.54 58.88,13.54 59.19,13.23 59.19,12.58 58.97,12.36 DM1.58
M_A_DQ23: length 71.3
  TOP w0.14: v1(60.22,15.07) 60.22,14.84 v2(59.89,14.51)
  L4 w0.114: v1(60.22,15.07) 59.74,15.56 59.74,18.22 61.34,19.82 62.57,19.82 64.13,21.38 64.13,25.59 84.29,45.76 84.29,48.85 91.14,55.7 91.14,58.14 91.66,58.66 v1(91.9,58.66)
  BOTTOM w0.089: v1(91.9,58.66) 92.3,59.06 92.3,59.42 93.54,60.67 94.06,60.67 96.52,63.12 96.52,63.75 96.51,63.75 96.51,63.96 CPU1.BB63
  BOTTOM w0.14: DM1.59 59.22,16.02 60.17,15.07 v1(60.22,15.07)
M_A_DQ24: length 69.9
  TOP w0.14: v1(61.44,15.5) v2(61.44,16.16)
  L4 w0.114: v1(93.84,58.78) 93.84,58.79 93.71,58.91 93.27,58.91 92.99,58.63 92.99,57.16 92.2,56.37 92.2,55.26 85.36,48.41 85.36,45.32 65.29,25.24 65.29,21.01 61.82,17.54 61.82,15.73 61.59,15.5 v1(61.44,15.5)
  BOTTOM w0.089: v1(93.84,58.78) 94.66,59.6 94.66,60.52 97.07,62.93 97.07,64.39 CPU1.BA61
  BOTTOM w0.14: DM1.70 61.97,15.3 61.77,15.5 v1(61.44,15.5)
M_A_DQ25: length 72.1
  TOP w0.14: v2(63.22,16.72) 63.04,16.55 v1(62.59,16.55)
  L4 w0.114: v1(93.84,56.74) 92.91,55.82 92.91,54.98 86.07,48.14 86.07,45.02 66.09,25.04 66.09,20.33 64.26,18.5 64.26,17.24 64.14,17.11 63.8,17.11 63.68,16.98 63.68,16.73 63.8,16.6 64.14,16.6 64.26,16.47 64.26,15.59 63.95,15.28 63.32,15.28 63.04,15.56 63.04,16.09 v1(62.59,16.55)
  BOTTOM w0.089: v1(93.84,56.74) 95.19,58.1 95.19,60.54 97.45,62.8 97.45,63.7 97.68,63.93 97.68,64.5 97.8,64.62 97.8,65.63 CPU1.AW61
  BOTTOM w0.14: DM1.71 62.22,18.35 61.99,18.12 61.99,17.14 v1(62.59,16.55)
M_A_DQ26: length 70
  TOP w0.14: v1(65.59,16.93) 65.2,16.93 65.05,17.08 v2(65,17.08)
  L4 w0.114: v1(65.59,16.93) 65.71,16.93 66.24,16.39 66.24,15.41 66.5,15.16 66.85,15.16 67.11,15.41 67.11,17.15 66.98,17.28 66.27,17.28 66.12,17.43 66.12,17.64 66.27,17.78 66.98,17.78 67.11,17.91 67.11,24.69 87.11,44.69 87.11,47.78 93.88,54.54 93.88,55 94.92,56.04 94.92,56.81 95.63,57.53 v1(95.63,57.55)
  BOTTOM w0.089: v1(95.63,57.55) 95.68,57.55 96.57,58.44 96.57,60.67 98.7,62.8 98.7,64.04 CPU1.BB59
  BOTTOM w0.14: v1(65.59,16.93) 65.46,16.93 65.13,17.25 65.13,17.8 65.22,17.89 DM1.83
M_A_DQ27: length 72.5
  TOP w0.14: v1(65.57,13.07) 65.96,13.07 v2(66.14,13.24)
  L4 w0.114: v1(65.57,13.07) 65.78,12.86 67.51,12.86 68.22,13.57 68.22,13.71 68.09,13.84 67.59,13.84 67.46,13.97 67.46,14.22 67.59,14.35 68.09,14.35 68.22,14.48 68.22,24.3 88.18,44.26 88.18,47.31 v1(95.8,54.93)
  BOTTOM w0.089: CPU1.AW59 98.96,65.82 99,65.7 99,65.31 99.07,65.17 99.1,65.07 99.13,64.99 99.22,64.89 99.4,64.81 99.47,64.81 99.64,64.64 99.64,64.36 99.62,64.32 99.61,64.31 99.57,64.24 99.57,62.62 97.2,60.24 97.2,56.33 v1(95.8,54.93)
  BOTTOM w0.14: v1(65.57,13.07) 65.48,12.97 65.48,11.4 DM1.84
M_A_DQ28: length 69.4
  TOP w0.14: v2(60.91,13.78) 60.91,13.8 61.26,14.16 v1(61.44,14.16)
  L4 w0.114: v1(61.44,14.16) 62.1,14.82 62.1,17.33 65.64,20.87 65.64,25.1 85.72,45.17 85.72,48.27 92.56,55.11 92.56,56.12 93.34,56.91 93.34,57.61 v1(93.84,58.1)
  BOTTOM w0.089: CPU1.BB61 97.27,63.94 97.27,62.87 94.91,60.51 94.91,58.1 94.56,57.75 94.19,57.75 v1(93.84,58.1)
  BOTTOM w0.14: DM1.66 60.97,13.26 60.99,13.27 60.99,13.7 v1(61.44,14.16)
M_A_DQ29: length 71.3
  TOP w0.14: v2(59.72,16.19) 59.92,16.39 v1(60.27,16.39)
  L4 w0.114: v1(93.84,60.08) 93.7,60.22 93.15,60.22 92.63,59.7 92.63,57.31 91.85,56.52 91.85,55.4 85,48.56 85,45.47 64.93,25.39 64.93,21.14 61.59,17.81 61.59,16.27 61.32,15.99 60.68,15.99 v1(60.27,16.39)
  BOTTOM w0.089: CPU1.AY61 97.03,64.72 96.87,64.56 96.87,63.9 96.87,63.9 96.87,62.98 93.97,60.08 v1(93.84,60.08)
  BOTTOM w0.14: DM1.67 61.22,18.58 61.53,18.27 61.53,16.66 61.26,16.39 v1(60.27,16.39)
M_A_DQ30: length 71.1
  TOP w0.14: v1(65.59,15.66) 65.96,15.66 v2(66.14,15.83)
  L4 w0.114: v1(65.59,15.66) 66.44,14.8 66.99,14.8 67.51,15.32 67.51,20.33 67.51,20.34 67.51,24.59 87.47,44.55 87.47,47.65 94.23,54.41 94.23,54.74 95.28,55.79 95.28,56.63 95.53,56.89 v1(95.66,56.89)
  BOTTOM w0.089: v1(95.66,56.89) 96.77,58 96.77,60.59 98.88,62.7 98.88,63.81 99,63.93 99,64.18 98.95,64.31 98.85,64.41 98.85,64.63 CPU1.BA59
  BOTTOM w0.14: DM1.79 64.22,18.44 64.18,18.4 64.18,15.94 64.59,15.53 65.46,15.53 v1(65.59,15.66)
M_A_DQ31: length 71.6
  TOP w0.14: v2(65,14.51) 65.13,14.39 v1(65.57,14.39)
  L4 w0.114: v1(65.57,14.39) 66.19,14.39 66.32,14.26 66.32,13.65 66.45,13.52 66.9,13.52 67.03,13.65 67.03,14.46 67.87,15.3 67.87,20.33 67.86,20.34 67.86,24.45 87.82,44.41 87.82,47.5 94.59,54.27 94.59,54.35 95.8,55.56 95.83,55.56 v1(95.83,55.56)
  BOTTOM w0.089: CPU1.AY59 98.84,65.08 98.93,64.98 98.99,64.87 99.01,64.78 99.04,64.68 99.09,64.57 99.09,64.49 99.18,64.21 99.18,63.86 99.05,63.73 99.05,62.6 97,60.54 97,56.65 95.92,55.57 95.83,55.57 v1(95.83,55.56)
  BOTTOM w0.14: v1(65.57,14.39) 65.4,14.39 64.48,13.46 64.48,11.4 DM1.80
M_A_DQ32: length 77.3
  TOP w0.14: v2(92.2,16.52) 92.35,16.37 v1(92.84,16.37)
  L6 w0.114: v1(92.84,16.37) 93.25,16.78 93.25,20.23 93.14,20.34 93.14,24.65 83.4,34.39 83.4,59 83.49,59.09 83.49,61.9 83.19,62.67 82.98,62.88 82.98,68.66 84.63,70.32 84.63,70.81 85.02,71.19 89.6,71.19 92.72,74.31 94.93,74.31 v1(95.53,73.71)
  BOTTOM w0.14: CPU1.AF65 95.21,73.38 v1(95.53,73.71) ; DM1.191 94.23,19.6 94.23,17.76 v1(92.84,16.37)
M_A_DQ33: length 76.4
  TOP w0.14: v1(95.76,13.83) v2(95.15,13.83)
  L6 w0.114: v1(95.76,13.83) 94.87,14.72 94.87,18.22 94.39,18.7 94.39,24.88 84.73,34.54 84.52,34.75 84.52,62.27 84.5,62.34 84.29,62.75 84.28,62.78 84.28,66.68 87.11,69.5 89.42,69.5 93.21,73.29 95.77,73.29 v1(96.19,73.71)
  BOTTOM w0.14: v1(96.19,73.71) 95.86,73.38 CPU1.AF64 ; v1(95.76,13.83) 95.69,13.83 94.97,13.12 DM1.194
M_A_DQ34: length 76.4
  TOP w0.14: v1(97.17,17.81) 97.28,17.81 97.28,17.82 v2(97.74,17.82)
  L6 w0.114: v1(97.17,17.81) 96.93,18.05 96.93,18.72 97.05,18.85 97.36,18.85 97.49,18.98 97.49,19.18 97.36,19.31 97.1,19.31 96.98,19.43 96.98,19.64 97.1,19.76 97.45,19.76 97.56,19.88 97.56,20.11 97.45,20.22 97.13,20.22 97,20.35 97,20.55 97.13,20.68 97.45,20.68 97.56,20.79 97.56,21.15 97.04,21.67 96.66,21.67 96.55,21.79 96.55,22.02 96.66,22.13 97.38,22.13 97.51,22.26 97.51,22.46 97.38,22.59 96.29,22.59 96.16,22.72 96.16,22.92 96.29,23.05 97.33,23.05 97.46,23.17 97.46,23.38 97.33,23.5 96.29,23.5 96.16,23.63 96.16,23.83 96.29,23.96 97.04,23.96 97.16,24.07 97.16,24.47 86.17,35.46 86.17,61.81 89.08,64.72 89.08,66.18 89.38,66.48 90.28,66.48 91.74,67.94 91.74,69.24 93.71,71.21 94.84,71.21 95.28,70.77 96.01,70.77 96.14,70.9 96.14,71.28 v1(95.53,71.88)
  BOTTOM w0.14: v1(97.17,17.81) 97.23,17.87 97.23,19.6 DM1.203 ; v1(95.53,71.88) 95.21,71.55 CPU1.AK65
M_A_DQ35: length 77.5
  TOP w0.14: v2(97.82,16.34) 97.56,16.34 97.56,16.34 v1(97.21,16.34)
  L6 w0.114: v1(96.19,71.88) 96.37,71.7 96.37,70.7 96.24,70.57 95.1,70.57 94.66,71.01 93.79,71.01 91.94,69.16 91.94,67.78 91.28,67.12 91.28,66.02 89.79,64.53 89.38,64.53 86.51,61.67 86.51,35.6 97.92,24.19 97.92,22.99 98.03,22.87 98.39,22.87 98.51,22.74 98.51,22.54 98.39,22.41 98.03,22.41 97.92,22.3 97.92,22.07 98.03,21.96 98.35,21.96 98.47,21.83 98.47,21.63 98.35,21.5 98.03,21.5 97.92,21.39 97.92,21.16 98.03,21.04 98.32,21.04 98.45,20.92 98.45,20.71 98.32,20.59 98.03,20.59 97.92,20.47 97.92,20.24 98.03,20.13 98.35,20.13 98.47,20 98.47,19.8 98.35,19.67 98.03,19.67 97.92,19.56 97.92,19.33 98.03,19.21 98.32,19.21 98.45,19.09 98.45,18.88 98.32,18.76 97.82,18.76 97.69,18.63 97.69,17.71 98.27,17.13 98.27,16.39 97.99,16.11 97.43,16.11 v1(97.21,16.34)
  BOTTOM w0.14: v1(96.19,71.88) 95.86,71.55 CPU1.AK64 ; v1(97.21,16.34) 97.27,16.34 98.23,17.29 98.23,19.6 DM1.207
M_A_DQ36: length 76.6
  TOP w0.14: v1(93.48,14.97) 93.46,14.95 v2(92.79,14.95)
  L6 w0.114: v1(93.48,14.97) 93.48,24.79 83.83,34.44 83.83,61.96 83.53,62.74 83.53,68.33 85.4,70.19 87.11,70.19 88.81,70.19 89.01,70 89.34,70 93.45,74.11 94.48,74.11 v1(94.88,73.71)
  BOTTOM w0.14: CPU1.AF66 94.56,73.38 v1(94.88,73.71) ; v1(93.48,14.97) 93.64,14.81 93.7,14.81 93.97,14.54 DM1.190
M_A_DQ37: length 76.1
  TOP w0.14: v1(94.36,16.5) 94.06,16.5 v2(93.78,16.77)
  L6 w0.114: v1(94.36,16.5) 93.98,16.88 93.98,24.75 93.83,24.9 93.83,24.93 84.18,34.58 84.18,62.22 83.87,62.82 83.87,66.76 84.17,67.06 84.17,67.22 83.89,67.5 83.89,67.67 84.05,67.83 84.21,67.83 84.5,67.54 84.66,67.54 84.82,67.7 84.82,67.86 84.43,68.26 84.43,68.44 84.57,68.58 84.75,68.58 85.14,68.19 85.3,68.19 85.47,68.35 85.47,68.51 85.12,68.85 85.12,69.03 85.27,69.18 85.45,69.18 85.79,68.83 85.95,68.83 86.96,69.85 88.87,69.85 88.92,69.79 89.42,69.79 93.34,73.71 v1(94.23,73.71)
  BOTTOM w0.14: v1(94.36,16.5) 95.22,17.36 DM1.195 ; CPU1.AF67 93.91,73.38 v1(94.23,73.71)
M_A_DQ38: length 75.2
  TOP w0.14: v1(97.97,13.75) 97.64,13.75 v2(97.43,13.55)
  L6 w0.114: v1(97.97,13.75) 97.47,13.75 96.3,14.91 96.3,20.84 95.47,21.68 95.47,25.17 85.48,35.15 85.48,62.1 85.8,62.41 85.8,64.25 86.13,64.59 86.13,64.75 85.86,65.03 85.86,65.19 86.02,65.35 86.18,65.35 86.46,65.07 86.62,65.07 86.78,65.23 86.78,65.4 86.5,65.68 86.5,65.84 86.66,66 86.83,66 87.1,65.72 87.27,65.72 87.43,65.88 87.43,66.04 87.15,66.32 87.15,66.48 87.31,66.65 87.47,66.65 87.75,66.37 87.91,66.37 88.72,67.17 90.39,67.17 91.33,68.11 91.33,69.41 93.8,71.88 v1(94.24,71.88)
  BOTTOM w0.14: CPU1.AK67 93.91,71.55 v1(94.24,71.88) ; v1(97.97,13.75) 97.94,13.75 97.48,13.29 DM1.204
M_A_DQ39: length 75.8
  TOP w0.14: v2(97.43,14.84) 97.69,15.1 v1(97.97,15.1)
  L6 w0.114: v1(94.88,71.88) 94.42,71.41 93.62,71.41 91.54,69.33 91.54,68.03 90.32,66.81 88.82,66.81 88.21,66.2 88.21,64.34 87.79,63.92 87.63,63.92 87,64.55 86.82,64.55 86.67,64.41 86.67,64.23 87.13,63.77 87.13,63.59 86.99,63.45 86.81,63.45 86.58,63.68 86.4,63.68 86.26,63.53 86.26,63.35 86.66,62.95 86.66,62.79 85.83,61.95 85.83,35.29 95.81,25.31 95.81,21.82 96.65,20.98 96.65,15.28 97.08,14.84 97.71,14.84 v1(97.97,15.1)
  BOTTOM w0.14: v1(94.88,71.88) 94.56,71.55 CPU1.AK66 ; DM1.208 98.48,12.38 98.45,12.4 98.45,14.62 v1(97.97,15.1)
M_A_DQ40: length 82.3
  TOP w0.14: v2(88.37,16.09) 88.6,15.85 v1(88.89,15.85)
  L6 w0.114: v1(87.61,74.36) 87.39,74.14 87.39,74.13 86.76,73.51 82.47,73.51 81.64,72.68 81.64,72.09 75.87,66.32 75.46,65.91 75.46,56.19 75.46,56.19 75.46,55.9 75.46,55.48 78.03,52.91 78.03,34.58 87.82,24.79 87.82,19.69 87.93,19.57 88.35,19.57 88.47,19.46 88.47,19.23 88.35,19.12 87.93,19.12 87.82,19 87.82,18.74 88.47,18.1 88.47,16.27 v1(88.89,15.85)
  BOTTOM w0.14: v1(87.61,74.36) 87.76,74.5 88.54,74.5 88.73,74.69 89.07,74.69 89.25,74.5 90.71,74.5 91.37,73.85 91.47,73.85 91.75,73.56 CPU1.AF70 ; v1(88.89,15.85) 89.46,16.43 89.46,18.23 89.7,18.47 89.7,18.74 89.72,18.76 DM1.173
M_A_DQ41: length 84.6
  TOP w0.14: v1(88.89,13.09) 88.89,12.8 v2(89.15,12.53)
  L6 w0.114: v1(86.28,74.32) 82.32,74.32 80.96,72.96 80.96,72.45 74.77,66.26 74.77,56.47 74.77,55.2 77.34,52.63 77.34,34.25 86.97,24.62 86.97,18.58 87.88,17.66 87.88,14.09 v1(88.89,13.09)
  BOTTOM w0.14: CPU1.AF68 93.05,73.46 92.66,73.84 92.46,73.84 91.62,74.69 91.17,74.69 90.9,74.96 89.44,74.96 89.23,75.18 87.14,75.18 v1(86.28,74.32) ; DM1.170 88.97,13 v1(88.89,13.09)
M_A_DQ42: length 80.7
  L6 w0.114: v1(91.25,13.75) 91.66,13.33 91.66,12.83 91.79,12.7 92.1,12.7 92.23,12.83 92.23,14.11 91.88,14.46 91.88,18.31 91.45,18.74 91.45,20.99 90.59,21.85 90.59,24.56 79.68,35.47 79.68,53.6 77.11,56.17 77.11,65.12 84.21,72.22 85.27,72.22 v1(85.75,72.71)
  BOTTOM w0.089: CPU1.AH71 90.38,72.23 90.16,72.45 88.65,72.45 88.39,72.2 v2(86.56,72.2) 86.26,72.2 v1(85.75,72.71)
  BOTTOM w0.14: v1(91.25,13.75) 91.97,13.02 DM1.182
M_A_DQ43: length 83.7
  L6 w0.114: v1(91.25,15.07) 91.37,15.07 91.66,15.36 91.66,18.22 91.1,18.79 91.1,19.33 90.22,20.21 90.22,20.4 90.33,20.52 90.98,20.52 91.11,20.64 91.11,20.85 90.98,20.97 90.33,20.97 90.22,21.09 90.22,24.44 79.34,35.33 79.34,53.45 76.77,56.03 76.77,65.26 84.18,72.68 v1(84.91,72.68)
  BOTTOM w0.089: CPU1.AH68 92.92,71.9 90.22,71.9 89.95,72.17 88.74,72.17 88.37,71.79 85.55,71.79 v2(85.31,72.03) 84.91,72.43 v1(84.91,72.68)
  BOTTOM w0.14: v1(91.25,15.07) 91.55,15.07 91.85,15.36 91.85,18.02 92.23,18.39 92.23,19.6 DM1.183
M_A_DQ44: length 81.5
  TOP w0.14: v2(89.51,17.36) 89.45,17.3 v1(88.89,17.3)
  L6 w0.114: v1(88.9,74.28) 88.18,74.28 87.07,73.16 82.61,73.16 81.98,72.53 81.98,71.95 76.02,65.98 75.8,65.77 75.8,55.63 78.37,53.05 78.37,34.82 88.28,24.92 88.28,24.23 88.39,24.12 88.71,24.12 88.82,24 88.82,23.77 88.71,23.66 88.39,23.66 88.28,23.54 88.28,23.2 88.39,23.08 88.84,23.08 88.95,22.97 88.95,22.74 88.84,22.63 88.39,22.63 88.28,22.51 88.28,22.2 88.39,22.08 88.91,22.08 89.03,21.97 89.03,21.74 88.91,21.63 88.39,21.63 88.28,21.51 88.28,21.28 88.39,21.17 88.91,21.17 89.03,21.05 89.03,20.83 88.91,20.71 88.39,20.71 88.28,20.6 88.28,20.19 89.3,19.17 89.3,17.71 v1(88.89,17.3)
  BOTTOM w0.14: v1(88.9,74.28) 90.59,74.28 CPU1.AF71 ; v1(88.89,17.3) 88.7,17.49 88.7,17.49 88.44,17.75 88.44,18.38 88.72,18.67 DM1.169
M_A_DQ45: length 83.5
  TOP w0.14: v1(88.89,14.36) 89.47,14.36 v2(89.48,14.34)
  L6 w0.114: v1(88.89,14.36) 88.13,15.12 88.13,17.77 87.36,18.53 87.36,24.76 77.69,34.44 77.69,52.77 75.12,55.34 75.12,55.76 75.11,55.76 75.11,56.33 75.12,56.33 75.12,66.05 75.73,66.67 81.3,72.23 81.3,72.82 82.33,73.85 86.49,73.85 v1(86.96,74.32)
  BOTTOM w0.14: v1(86.96,74.32) 87.16,74.52 87.16,74.54 87.42,74.81 88.53,74.81 88.63,74.92 89.17,74.92 89.35,74.73 90.8,74.73 91.46,74.07 91.89,74.07 92.37,73.59 92.47,73.59 CPU1.AF69 ; DM1.174 89.97,13.27 v1(88.89,14.36)
M_A_DQ46: length 82.1
  TOP w0.14: v1(93.48,13.7) v2(92.86,13.7)
  L6 w0.114: v1(87.12,72.71) 86.3,71.88 84.35,71.88 78.15,65.68 78.15,65.52 78.37,65.31 78.37,65.14 78.21,64.98 78.04,64.98 77.83,65.2 77.67,65.2 77.45,64.98 77.45,56.31 80.02,53.74 80.02,35.7 90.98,24.75 90.98,21.95 91.8,21.13 91.8,18.7 92.09,18.4 92.09,15.26 92.51,14.84 92.51,12.91 92.63,12.79 92.94,12.79 93.07,12.91 93.07,13.5 93.27,13.7 v1(93.48,13.7)
  BOTTOM w0.089: v1(87.12,72.71) 87.3,72.53 88.28,72.53 88.46,72.71 90.18,72.71 90.38,72.5 91.36,72.5 91.58,72.44 91.75,72.44 91.96,72.24 CPU1.AH70
  BOTTOM w0.14: DM1.186 92.97,13.41 93.27,13.7 v1(93.48,13.7)
M_A_DQ47: length 83.3
  TOP w0.14: v1(92.84,17.64) v2(92.84,18.2)
  L6 w0.114: v1(87.83,72.93) 87.83,72.35 87.02,71.54 84.5,71.54 83.62,70.67 83.62,69.79 82.88,69.05 82.72,69.05 82.49,69.28 82.32,69.28 82.16,69.12 82.16,68.96 82.39,68.72 82.39,68.56 82.23,68.4 82.07,68.4 81.84,68.63 81.68,68.63 81.52,68.47 81.52,68.31 81.75,68.08 81.75,67.92 81.59,67.76 81.43,67.76 81.17,68.01 81.01,68.01 80.85,67.85 80.85,67.69 81.1,67.43 81.1,67.27 80.94,67.11 80.78,67.11 80.52,67.37 80.36,67.37 80.2,67.2 80.2,67.04 80.46,66.79 80.46,66.62 80.29,66.46 80.13,66.46 79.88,66.72 79.71,66.72 79.55,66.56 79.55,66.4 79.81,66.14 79.81,65.98 79.65,65.82 79.49,65.82 79.23,66.07 79.07,66.07 78.91,65.91 78.91,65.75 79.16,65.49 79.16,65.33 77.79,63.96 77.79,56.45 80.37,53.88 80.37,35.84 92.33,23.88 92.33,23.36 92.21,23.25 91.58,23.25 91.47,23.14 91.47,22.91 91.58,22.79 92.19,22.79 92.32,22.67 92.32,22.46 92.19,22.34 91.58,22.34 91.47,22.22 91.47,21.99 91.58,21.88 92.21,21.88 92.33,21.76 92.33,18.15 v1(92.84,17.64)
  BOTTOM w0.089: CPU1.AH69 92.61,72.24 92.21,72.63 91.57,72.63 91.39,72.68 91.38,72.68 91.38,72.69 90.5,72.69 90.28,72.91 89.27,72.91 89.12,73.06 87.96,73.06 v1(87.83,72.93)
  BOTTOM w0.14: DM1.187 93.23,19.6 93.23,17.98 92.88,17.64 v1(92.84,17.64)
M_A_DQ48: length 68.4
  TOP w0.14: v2(102.54,13.73) 102.51,13.75 v1(101.96,13.75)
  L6 w0.114: v1(101.96,13.75) 102.26,13.45 102.95,13.45 103.45,13.96 103.45,15.63 103,16.09 103,19.9 102.73,20.17 102.73,24.2 89.94,36.99 89.94,54.75 89.31,55.38 89.31,61.7 90.33,62.72 90.99,62.72 92.43,64.17 93,64.17 95.44,66.61 95.44,66.99 v1(94.99,67.44)
  BOTTOM w0.14: DM1.224 102.48,13.27 102.02,13.73 101.98,13.73 v1(101.96,13.75) ; v1(94.99,67.44) 94.57,67.85 CPU1.AT66
M_A_DQ49: length 68.6
  TOP w0.14: v1(101.98,15.23) 101.47,15.23 101.37,15.33 v2(101.32,15.33)
  L6 w0.114: v1(95.04,66.79) 95.04,66.5 92.94,64.4 92.38,64.4 90.92,62.95 90.27,62.95 88.95,61.63 88.95,55.26 89.6,54.61 89.6,36.84 102.38,24.06 102.38,20.03 102.62,19.8 102.62,15.99 103.07,15.53 103.07,14.84 102.95,14.72 102.69,14.72 102.18,15.23 v1(101.98,15.23)
  BOTTOM w0.14: v1(95.04,66.79) 94.63,67.2 CPU1.AU66 ; DM1.225 102.72,15.71 102.23,15.23 v1(101.98,15.23)
M_A_DQ50: length 70.9
  TOP w0.14: v2(100.36,16.11) 100.33,16.11 100.2,15.99 v1(99.69,15.99)
  L6 w0.114: v1(95.88,68.83) 95.45,69.26 95.45,69.6 94.44,70.6 93.96,70.6 92.48,69.12 92.48,67.37 91.85,66.74 91.85,66.01 89.82,63.99 89.8,63.99 87.24,61.42 87.24,54.61 87.88,53.96 87.88,36.22 99.45,24.66 99.45,18.37 98.99,17.92 98.99,16.69 v1(99.69,15.99)
  BOTTOM w0.14: v1(99.69,15.99) 100.23,16.52 100.23,19.6 DM1.215 ; v1(95.88,68.83) 95.76,68.83 CPU1.AP65
M_A_DQ51: length 72.1
  TOP w0.14: v1(99.44,15.1) 99.19,15.1 v2(98.93,15.35)
  L6 w0.114: v1(95.85,69.47) 95.85,69.48 94.53,70.8 93.88,70.8 92.2,69.13 92.2,67.6 91.54,66.94 91.54,66 89.88,64.33 89.66,64.33 86.89,61.57 86.89,54.44 87.5,53.84 87.5,36.12 99.11,24.52 99.11,18.36 98.64,17.89 98.64,15.9 v1(99.44,15.1)
  BOTTOM w0.14: v1(95.85,69.47) 95.78,69.47 CPU1.AN65 ; v1(99.44,15.1) 100.48,14.06 DM1.216
M_A_DQ52: length 71.2
  TOP w0.14: v1(99.67,17.3) 99.08,17.3 v2(99.06,17.28)
  L6 w0.114: v1(95.01,69.47) 94.55,69.47 94.08,69 93.57,69 92.86,68.29 92.86,67.35 92.2,66.69 92.2,66.08 89.9,63.78 89.88,63.78 87.66,61.56 87.66,61.36 87.58,61.28 87.58,54.75 88.24,54.09 88.24,36.35 99.79,24.8 99.79,23.57 99.91,23.45 100.85,23.45 100.97,23.34 100.97,23.11 100.85,23 99.91,23 99.79,22.88 99.79,22.65 99.91,22.54 100.85,22.54 100.97,22.43 100.97,22.2 100.85,22.08 99.91,22.08 99.79,21.97 99.79,21.74 99.91,21.63 100.85,21.63 100.97,21.51 100.97,21.28 100.85,21.17 99.91,21.17 99.79,21.05 99.79,18.86 100.09,18.57 100.09,17.71 v1(99.67,17.3)
  BOTTOM w0.14: DM1.211 99.2,19.58 99.2,17.77 99.49,17.49 99.49,17.49 v1(99.67,17.3) ; v1(95.01,69.47) 94.68,69.8 CPU1.AN66
M_A_DQ53: length 70
  TOP w0.14: v1(99.47,13.07) 100.08,13.07 v2(100.1,13.09)
  L6 w0.114: v1(99.47,13.07) 100.05,13.07 100.44,13.45 100.44,15.55 100.41,15.58 100.41,18.86 100.14,19.13 100.14,20.31 100.64,20.81 101.07,20.81 101.33,21.08 101.33,23.75 100.14,24.94 88.58,36.5 88.58,54.23 87.95,54.86 87.95,60.72 88.06,60.83 88.06,61.67 89.97,63.58 90.63,63.58 92.14,65.09 92.63,65.09 92.94,65.4 92.94,66.14 93.45,66.65 93.45,68.07 94.17,68.79 95.02,68.79 v1(95.03,68.8)
  BOTTOM w0.14: v1(99.47,13.07) 99.48,12.83 DM1.212 ; CPU1.AP66 94.68,69.15 95.03,68.8 v1(95.03,68.8)
M_A_DQ54: length 69.9
  TOP w0.14: v2(103.58,17.31) 103.66,17.31 103.66,17.3 v1(104.25,17.3)
  L6 w0.114: v1(104.25,17.3) 103.84,17.3 103.5,17.64 103.5,18.6 103.63,18.73 104.55,18.73 104.67,18.86 104.67,19.06 104.55,19.19 103.66,19.19 103.53,19.32 103.53,19.52 103.66,19.65 104.6,19.65 104.72,19.77 104.72,19.98 104.6,20.1 103.9,20.1 103.78,20.22 103.78,20.8 104.18,21.2 104.56,21.2 104.67,21.31 104.67,21.54 104.56,21.65 104.09,21.65 103.96,21.78 103.96,21.98 104.09,22.11 104.56,22.11 104.67,22.23 104.67,22.45 104.56,22.57 104.13,22.57 104.01,22.68 104.01,23.89 90.7,37.2 90.7,56.27 90.7,56.27 90.7,60.86 90.7,60.86 90.7,61.33 91.44,62.07 91.44,62.37 91.62,62.54 91.91,62.54 92.09,62.72 92.09,63.02 92.26,63.19 92.56,63.19 93.14,63.76 93.33,63.76 96.27,66.71 96.27,67 96.47,67.19 96.47,67.52 96.39,67.6 95.98,67.6 v1(95.9,67.53)
  BOTTOM w0.14: CPU1.AT65 95.58,67.85 v1(95.9,67.53) ; DM1.229 103.72,17.52 103.94,17.3 v1(104.25,17.3)
M_A_DQ55: length 69.6
  TOP w0.14: v1(104.18,16.03) 104.62,16.03 104.62,16.04 v2(104.8,16.04)
  L6 w0.114: v1(104.18,16.03) 103.66,16.03 103.25,16.44 103.25,20.07 103.1,20.23 103.1,20.87 103.21,20.98 103.48,20.98 103.61,21.11 103.61,21.31 103.48,21.44 103.21,21.44 103.1,21.55 103.1,21.78 103.21,21.9 103.48,21.9 103.61,22.02 103.61,22.23 103.48,22.35 103.21,22.35 103.1,22.47 103.1,22.7 103.21,22.81 103.53,22.81 103.66,22.94 103.66,23.14 103.53,23.27 103.21,23.27 103.1,23.38 103.1,24.32 90.34,37.08 90.34,61.35 90.89,61.9 90.89,62.28 92.58,63.97 93.08,63.97 95.87,66.76 v1(95.87,66.87)
  BOTTOM w0.14: CPU1.AU65 95.54,67.2 v1(95.87,66.87) ; DM1.228 103.48,13.81 103.1,14.18 103.1,16.5 103.25,16.65 103.56,16.65 v1(104.18,16.03)
M_A_DQ56: length 72
  TOP w0.14: v2(103.45,15.12) 103.61,15.12 103.61,15.12 v1(104.04,15.12)
  L6 w0.114: v1(104.04,15.12) 104.19,15.12 105.05,15.99 105.05,18.3 105.61,18.86 105.61,19.04 105.5,19.16 105.24,19.16 105.13,19.27 105.13,19.5 105.24,19.61 105.5,19.61 105.61,19.73 105.61,19.96 105.5,20.07 105.24,20.07 105.13,20.18 105.13,20.41 105.24,20.53 105.5,20.53 105.61,20.64 105.61,20.87 105.5,20.98 105.24,20.98 105.13,21.1 105.13,21.33 105.24,21.44 105.5,21.44 105.61,21.56 105.61,21.78 105.5,21.9 105.24,21.9 105.13,22.01 105.13,22.24 105.24,22.36 105.5,22.36 105.61,22.47 105.61,22.7 105.5,22.81 105,22.81 104.88,22.94 104.88,23.14 105,23.27 105.5,23.27 105.61,23.38 105.61,23.85 91.68,37.79 91.68,56 91.05,56.64 91.05,60.91 92.43,62.29 92.79,62.29 94.08,63.58 94.08,64.14 96.49,66.55 96.49,66.9 96.87,67.27 v1(96.87,68.19)
  BOTTOM w0.14: DM1.236 105.48,13.81 104.17,15.12 v1(104.04,15.12) ; v1(96.87,68.19) 97.2,67.85 CPU1.AT61
M_A_DQ57: length 71
  TOP w0.14: v2(105.71,17.38) 105.77,17.38 105.88,17.27 v1(106.38,17.27)
  L6 w0.114: v1(97.76,66.81) 97.31,66.36 97.31,65.6 97.07,65.36 96.51,65.36 94.69,63.54 94.69,63.33 92.71,61.34 92.71,38.33 93.1,37.94 93.26,37.94 93.35,38.02 93.51,38.02 93.67,37.86 93.67,37.7 93.58,37.61 93.58,37.45 93.74,37.29 93.91,37.29 93.99,37.38 94.15,37.38 94.32,37.22 94.32,37.05 94.23,36.97 94.23,36.81 94.39,36.64 94.55,36.64 94.64,36.73 94.8,36.73 94.96,36.57 94.96,36.41 94.88,36.32 94.88,36.16 95.04,36 95.2,36 95.29,36.08 95.45,36.08 95.61,35.92 95.61,35.76 95.52,35.67 95.52,35.51 95.68,35.35 95.85,35.35 95.93,35.44 96.09,35.44 96.26,35.28 96.26,35.11 96.17,35.03 96.17,34.87 96.33,34.7 96.49,34.7 96.58,34.79 96.74,34.79 96.9,34.63 96.9,34.47 96.82,34.38 96.82,34.22 96.98,34.06 97.14,34.06 97.23,34.14 97.39,34.14 97.55,33.98 97.55,33.82 97.46,33.73 97.46,33.57 97.62,33.41 97.79,33.41 97.87,33.5 98.03,33.5 98.2,33.34 98.2,33.17 98.11,33.09 98.11,32.93 98.27,32.76 98.43,32.76 98.52,32.85 98.68,32.85 98.84,32.69 98.84,32.53 98.76,32.44 98.76,32.28 98.92,32.12 99.08,32.12 99.17,32.2 99.33,32.2 99.49,32.04 99.49,31.88 99.4,31.79 99.4,31.63 99.56,31.47 99.73,31.47 99.81,31.56 99.97,31.56 100.14,31.4 100.14,31.23 100.05,31.15 100.05,30.99 100.21,30.82 100.37,30.82 100.46,30.91 100.62,30.91 100.78,30.75 100.78,30.59 100.7,30.5 100.7,30.34 100.86,30.18 101.02,30.18 101.11,30.26 101.27,30.26 101.43,30.1 101.43,29.94 101.34,29.85 101.34,29.69 101.51,29.53 101.67,29.53 101.75,29.62 101.91,29.62 102.08,29.46 102.08,29.29 101.99,29.21 101.99,29.05 102.15,28.88 102.31,28.88 102.4,28.97 102.56,28.97 102.72,28.81 102.72,28.65 102.64,28.56 102.64,28.4 102.8,28.24 102.96,28.24 103.05,28.32 103.21,28.32 103.37,28.16 103.37,28 103.28,27.91 103.28,27.75 103.45,27.59 103.61,27.59 103.69,27.68 103.85,27.68 104.02,27.52 104.02,27.35 103.93,27.27 103.93,27.11 104.09,26.94 104.25,26.94 104.34,27.03 104.5,27.03 104.66,26.87 104.66,26.71 104.58,26.62 104.58,26.46 104.74,26.3 104.9,26.3 104.99,26.38 105.15,26.38 105.31,26.22 105.31,26.06 105.22,25.97 105.22,25.81 105.39,25.65 105.55,25.65 105.63,25.74 105.79,25.74 105.96,25.58 105.96,25.41 105.87,25.33 105.87,25.17 106.03,25 106.19,25 106.28,25.09 106.44,25.09 106.6,24.93 106.6,24.77 106.52,24.68 106.52,24.52 106.79,24.25 106.79,17.69 v1(106.38,17.27)
  BOTTOM w0.14: DM1.237 105.72,17.89 106.34,17.27 v1(106.38,17.27) ; CPU1.AU61 97.66,66.81 v1(97.76,66.81)
M_A_DQ58: length 75
  TOP w0.14: v1(109.07,17.16) 108.74,17.16 v2(108.48,17.41)
  L6 w0.114: v1(109.07,17.16) 108.76,17.47 108.76,18.07 109.25,18.55 109.25,24.01 108.38,24.87 108.38,26.45 105,29.83 104.84,29.83 104.38,29.37 104.22,29.37 104.06,29.53 104.06,29.69 104.51,30.15 104.51,30.31 104.35,30.48 104.19,30.48 103.73,30.02 103.57,30.02 103.41,30.18 103.41,30.34 103.87,30.8 103.87,30.96 103.71,31.12 103.54,31.12 103.09,30.66 102.92,30.66 102.76,30.83 102.76,30.99 103.22,31.45 103.22,31.61 103.06,31.77 102.9,31.77 102.44,31.31 102.28,31.31 102.12,31.47 102.12,31.63 102.57,32.09 102.57,32.25 102.41,32.42 102.25,32.42 101.79,31.96 101.63,31.96 101.47,32.12 101.47,32.28 101.93,32.74 101.93,32.9 101.77,33.06 101.6,33.06 101.15,32.6 100.98,32.6 100.82,32.77 100.82,32.93 101.28,33.39 101.28,33.55 101.12,33.71 100.96,33.71 100.5,33.25 100.34,33.25 94.04,39.55 94.04,53.97 94.74,54.67 94.74,61.57 98.65,65.48 98.65,66.19 99.02,66.56 99.02,69.05 v1(98.62,69.46)
  BOTTOM w0.14: v1(109.07,17.16) 108.72,17.5 DM1.249 ; v1(98.62,69.46) 98.32,69.15 CPU1.AP60
M_A_DQ59: length 74.7
  TOP w0.14: v2(104.62,13.85) 104.6,13.83 v1(104.01,13.83)
  L6 w0.114: v1(97.73,69.48) 97.73,69.35 97.29,68.9 97.29,67.4 96.7,66.81 96.7,66.47 94.28,64.05 94.28,63.49 92.88,62.09 92.57,62.09 91.39,60.91 91.39,56.91 92.02,56.27 92.02,38.04 105.96,24.11 105.96,18.82 105.38,18.25 105.38,15.1 105.27,14.99 104.6,14.99 104.47,14.86 104.47,14.66 104.6,14.53 105.02,14.53 105.64,13.92 106.71,13.92 106.83,13.79 106.83,13.45 106.71,13.32 105.28,13.32 104.78,13.83 v1(104.01,13.83)
  BOTTOM w0.14: v1(104.01,13.83) 104.04,13.83 104.48,13.39 DM1.232 ; v1(97.73,69.48) 98.05,69.8 CPU1.AN60
M_A_DQ60: length 74.4
  TOP w0.14: v2(108.43,14.46) 108.61,14.46 108.61,14.46 v1(108.99,14.46)
  L6 w0.114: v1(108.99,14.46) 109.02,14.46 109.62,15.06 109.62,24.12 108.72,25.02 108.72,26.59 100.87,34.45 100.7,34.45 100.36,34.1 100.2,34.1 100.04,34.26 100.04,34.43 100.38,34.77 100.38,34.93 100.22,35.09 100.06,35.09 99.71,34.75 99.55,34.75 99.39,34.91 99.39,35.07 99.73,35.42 99.73,35.58 99.57,35.74 98.56,35.74 94.38,39.92 94.38,53.7 95.12,54.44 95.12,61.66 99,65.53 99,66.25 99.92,67.17 99.92,67.76 99.92,67.76 99.92,69.7 99.6,70.02 99.34,70.02 98.83,70.53 98.17,70.53 v1(97.76,70.12)
  BOTTOM w0.14: v1(108.99,14.46) 107.98,13.44 107.98,11.4 DM1.246 ; v1(97.76,70.12) 97.45,69.8 CPU1.AN61
M_A_DQ61: length 73.7
  TOP w0.14: v2(108.56,12.74) 108.56,12.74 108.89,13.07 v1(109.05,13.07)
  L6 w0.114: v1(109.05,13.07) 109.96,13.98 109.96,24.26 109.07,25.16 109.07,26.73 94.72,41.07 94.72,53.33 95.91,54.51 95.97,54.51 96.52,55.07 96.52,62.66 98.8,64.95 99.07,64.95 100.11,65.99 100.11,67.04 100.12,67.05 100.12,67.68 100.12,69.78 99.68,70.22 99.43,70.22 98.92,70.73 97.81,70.73 97.33,70.25 97.33,69.3 v1(96.87,68.84)
  BOTTOM w0.14: v1(96.87,68.84) 97.18,69.15 CPU1.AP61 ; v1(109.05,13.07) 108.98,12.99 108.98,11.4 DM1.250
M_A_DQ62: length 73.7
  TOP w0.14: v2(108.57,15.87) 108.71,15.73 v1(109.12,15.73)
  L6 w0.114: v1(109.12,15.73) 108.94,15.73 108.46,16.22 108.46,18.15 108.92,18.6 108.92,20.33 108.9,20.34 108.9,23.87 108.04,24.73 108.04,26.3 107.87,26.47 107.71,26.47 107.28,26.04 107.11,26.04 106.95,26.2 106.95,26.37 107.38,26.8 107.38,26.96 107.22,27.12 107.06,27.12 106.63,26.69 106.47,26.69 106.31,26.85 106.31,27.01 106.74,27.44 106.74,27.61 106.58,27.77 106.41,27.77 105.98,27.34 105.82,27.34 105.66,27.5 105.66,27.66 106.09,28.09 106.09,28.25 105.93,28.41 105.77,28.41 105.34,27.98 105.17,27.98 105.01,28.14 105.01,28.31 105.44,28.74 105.44,28.9 105.28,29.06 105.12,29.06 104.7,28.64 104.43,28.64 93.7,39.37 93.7,54.16 94.4,54.86 94.4,61.51 98.45,65.56 98.45,66.28 98.62,66.45 v1(98.62,68.15)
  BOTTOM w0.14: DM1.245 107.72,17.13 v1(109.12,15.73) ; v1(98.62,68.15) 98.32,67.85 CPU1.AT60
M_A_DQ63: length 73.6
  TOP w0.14: v2(106.32,15.33) 106.32,15.92 v1(106.35,15.95)
  L6 w0.114: v1(97.76,67.48) 96.9,66.62 96.9,66.38 94.49,63.97 94.49,63.41 92.37,61.29 92.37,38.18 106.3,24.25 106.3,18.68 105.6,17.98 105.6,15.25 105.73,15.12 106.25,15.12 106.38,15 106.38,14.77 106.25,14.64 105.73,14.64 105.6,14.51 105.6,14.26 105.73,14.13 106.73,14.13 106.86,14.26 106.86,15.68 106.59,15.95 v1(106.35,15.95)
  BOTTOM w0.14: CPU1.AU60 97.91,67.48 v1(97.76,67.48) ; DM1.233 104.72,18.6 104.75,18.57 104.75,17.56 105.23,17.08 105.23,16.65 105.11,16.52 104.75,16.52 104.62,16.39 104.62,15.86 104.75,15.73 106.13,15.73 v1(106.35,15.95)
M_A_DQS_DN0: length 87.8
  TOP w0.14: v1(87.07,70.65) 87.05,70.67 v2(87.05,71.21)
  L4 w0.114: v1(87.07,70.65) 87.02,70.65 86.59,70.21 86.25,70.21 86.05,70.01 86.05,70.01 85.49,70.01 85.49,70.01 85.39,70.01 85.39,70.01 85.09,70.01 84.6,69.52 82.77,69.52 82.46,69.21 82.46,69.03 82.7,68.79 82.7,68.41 82.43,68.15 82.06,68.15 81.83,68.38 81.68,68.38 81.52,68.23 81.52,68.08 81.74,67.86 81.74,67.49 81.47,67.21 81.1,67.21 80.87,67.43 80.59,67.43 76.46,63.3 76.46,58.28 76.13,57.94 76.13,49.11 54.29,27.27 54.29,24.88 50.05,20.64 50.05,20.42 48.45,18.82 46.98,18.82 46.53,18.37 46.53,17.28 46.65,17.16 46.82,17.16 46.96,17.31 v1(46.96,17.38)
  BOTTOM w0.089: CPU1.AM70 92.08,70.04 92.08,70.04 91.91,70.04 91.7,69.98 91.56,69.98 91.42,70.03 90.84,70.03 90.83,70.03 89.64,70.03 89.57,69.97 88.86,69.97 88.7,69.81 87.22,69.81 87.11,69.7 86.77,69.7 86.65,69.82 86.65,70.03 86.77,70.15 87.16,70.15 87.29,70.28 87.29,70.52 87.16,70.65 v1(87.07,70.65)
  BOTTOM w0.14: DM1.11 47.22,18.44 47.36,18.3 47.7,18.3 47.83,18.17 47.83,17.23 47.7,17.1 47.55,17.1 47.42,17.23 47.42,17.54 47.31,17.64 47.07,17.64 46.96,17.54 v1(46.96,17.38)
M_A_DQS_DN1: length 79
  TOP w0.14: v1(52.23,13.7) v2(51.66,13.7)
  L4 w0.114: v1(87.72,67.65) 87.72,67.34 87.71,67.32 87.71,67.14 86.8,66.23 86.8,66.22 86.53,65.94 86.53,61.95 85.41,60.83 85.41,58.88 80.89,54.37 80.89,53.04 80.35,52.49 80.34,52.49 80.03,52.18 80.03,52.17 79.63,51.78 79.62,51.78 79.07,51.22 79.07,47.78 57.23,25.94 57.23,23.57 51.05,17.4 51.05,14.14 51.49,13.7 51.97,13.7 51.99,13.71 52.22,13.71 v1(52.23,13.7)
  BOTTOM w0.089: CPU1.AT69 92.65,67.61 92.4,67.61 92.26,67.51 91.93,67.51 91.73,67.45 91.53,67.45 91.4,67.49 91.05,67.49 91.02,67.47
  BOTTOM w0.102: v1(87.72,67.65) 87.72,67.62 88.33,67.02 90.54,67.02 90.84,67.32 90.88,67.32 91.02,67.47
  BOTTOM w0.14: v1(52.23,13.7) 52.63,13.31 52.63,12.53 52.48,12.38 52.48,11.4 DM1.32
M_A_DQS_DN2: length 71.7
  L4 w0.114: v1(89.81,56.97) 89.81,57.36 89.68,57.49 89.48,57.49 89.35,57.36 89.35,56.13 89.34,56.12 89.34,55.76 82.92,49.33 82.92,46.24 62.82,26.13 62.82,22.95 59.98,20.11 59.97,20.11 58.18,18.32 58.05,18.19 58.05,16.44 57.92,16.32 57.71,16.32 57.31,16.72 v1(57.31,16.76)
  BOTTOM w0.089: v1(89.81,56.97) 89.81,57.14 91.28,58.61 91.28,58.85 91.28,60.73 91.78,61.24 93.82,61.24 95.35,62.77 95.35,63.6 95.5,63.75 95.5,64.19 95.46,64.32 95.46,64.49 95.51,64.66 95.61,64.91 CPU1.BA64
  BOTTOM w0.102: v2(90.68,57.72) 90.53,57.86
  BOTTOM w0.14: v1(57.31,16.76) 57.31,16.74 57.57,16.48 57.84,16.48 57.97,16.6 57.97,18.42 57.72,18.66 DM1.53
M_A_DQS_DN3: length 71.1
  TOP w0.14: v1(62.58,13.7) 62.93,13.7 v2(63.15,13.49)
  L4 w0.114: v1(95.62,58.85) 95.27,58.85 94.51,58.08 94.51,57.27 94.51,57.27 94.51,56.35 93.51,55.35 93.51,54.72 86.74,47.95 86.74,44.84 66.7,24.8 66.7,19.58 64.88,17.76 64.88,15.58 63.15,13.84 62.72,13.84 v1(62.58,13.7)
  BOTTOM w0.089: CPU1.AY60 98.32,65.57 98.32,65.23 98.46,65.04 98.46,64.71 98.52,64.51 98.52,64.31 98.48,64.16 98.48,63.88 98.51,63.85 98.51,63.13 98.5,63.12 98.5,62.95 96.37,60.83 96.37,59.21 96.18,59.01 95.78,59.01 v1(95.62,58.85)
  BOTTOM w0.14: DM1.74 62.97,12.43 63.11,12.57 63.11,13.33 62.74,13.7 v1(62.58,13.7)
M_A_DQS_DN4: length 76.3
  TOP w0.14: v1(95.86,15.17) 95.79,15.1 v2(95.25,15.1)
  L6 w0.114: v1(95.86,15.17) 95.78,15.17 95.38,15.58 95.38,16.05 95.14,16.28 95.14,18.19 95.39,18.44 95.68,18.44 95.81,18.57 95.81,18.77 95.68,18.9 95.33,18.9 95.07,19.16 95.07,19.77 95.33,20.04 95.57,20.04 95.68,20.15 95.68,20.38 95.57,20.49 95.39,20.49 94.76,21.12 94.76,25.03 84.89,34.9 84.89,62.34 85.16,62.62 85.16,67.04 85.55,67.43 86.51,68.39 90.4,68.39 90.83,68.82 90.83,69.52 93.66,72.35 93.7,72.35 93.88,72.52 94.6,72.52 94.8,72.72 94.8,72.75 v1(94.82,72.78)
  BOTTOM w0.14: v1(95.86,15.17) 96.22,15.17 96.4,14.99 96.4,12.87 95.97,12.44 DM1.198 ; CPU1.AH66 94.61,72.34 94.82,72.55 v1(94.82,72.78)
M_A_DQS_DN5: length 82.8
  L6 w0.114: v1(91.25,16.59) 91.22,16.62 90.41,16.62 89.59,17.45 89.59,18.57 89.83,18.82 90.53,18.82 90.65,18.95 90.65,19.15 90.53,19.28 89.83,19.28 89.59,19.53 89.59,24.13 78.74,34.97 78.74,53.21 76.17,55.78 76.17,65.61 82.42,71.87 v1(82.42,72.35)
  BOTTOM w0.089: 88.44,73.75 88.48,73.72 88.98,73.72 89.24,73.98 90.47,73.98 90.59,73.86 90.59,73.85 91.15,73.29 91.39,73.29 91.53,73.34 91.73,73.34 91.93,73.28 92.24,73.28 92.42,73.16 CPU1.AG69
  BOTTOM w0.14: DM1.177 90.72,18.42 90.7,18.4 90.7,18.39 90.44,18.13 90.44,17.08 90.77,16.75 91.03,16.75 91.19,16.59 v1(91.25,16.59) ; v2(85.6,73.72) 85.6,73.49 ; 85.6,73.49 86.79,73.49 87.05,73.75 88.44,73.75 ; 85.6,73.49 82.7,73.49 82.45,73.24 82.45,72.38 v1(82.42,72.35)
