# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB3_RXP3_R: length 4.2
  TOP w0.127: v2(102.34,111.31) 102.03,111.62 v1(101.73,111.62) R6221.2
  BOTTOM w0.127: WWAN1.31 103.25,111.75 103.12,111.62 102.79,111.62 102.46,111.29 102.05,111.29 v1(101.73,111.62)
USB3_TXN3_R: length 4.1
  TOP w0.127: C6208.2 101.05,112.53 101.78,112.53 v1(101.95,112.36) 102.24,112.36 v2(102.49,112.61)
  BOTTOM w0.127: v1(101.95,112.36) 102.22,112.63 102.75,112.63 102.99,112.88 103.12,112.88 103.25,112.75 WWAN1.35
USB3_TXP3_R: length 4.2
  TOP w0.127: C6207.2 101.73,113.4 v1(101.95,113.17) 102.03,113.25 102.03,113.7 v2(102.11,113.78)
  BOTTOM w0.127: v1(101.95,113.17) 102.25,112.88 102.65,112.88 102.89,113.12 103.12,113.12 103.25,113.25 WWAN1.37
USB20_VCCA: length 10.6
  TOP w0.305: v1(278.84,27.57) 278.64,27.37 AFTP6311.1
  L6 w0.508: v1(273.56,36.31) 273.69,36.31 273.75,36.37 276.44,36.37 279.43,33.39 v1(279.43,32.14)
  BOTTOM w0.508: v1(273.56,36.31) 273.69,36.43 273.69,36.56 274.19,37.07 ED3701.5
USB30_RX_CPU_N1: length 187.4
  L6 w0.102: v1(16.49,48.47) 16.8,48.77 16.8,50.33 18.08,51.62 18.08,57.01 16.7,58.4 16.7,76.16 20.37,79.83 24.6,79.83 28.63,83.86 28.63,92.95 34.35,98.66 42.55,98.66 49.8,105.92 59.08,105.92 61.3,103.69 63.46,103.69 65.97,101.18 71.24,101.18 72.72,102.65 75.88,102.65 78.49,105.26 89.07,105.26 90.94,103.39 97.02,103.39 98.83,101.57 106.15,101.57 108.3,99.42 110.46,97.26 110.46,95.55 111.08,94.93 116.32,94.93 117.37,95.97 121.35,95.97 125.43,91.9 125.43,87.41 127.33,85.51 127.33,83.58 127.81,83.1 127.81,82.46 v1(127.9,82.37)
  BOTTOM w0.127: R3608.1 21.28,50.66 22.08,50.66 22.21,50.54 22.21,49.9 22.08,49.77 21.74,49.77 20.84,48.87 19.15,48.87 18.81,49.2 ; v2(18.97,49.36) 18.81,49.2 ; 18.81,49.2 18.01,50.01 17.3,50.01 16.78,49.49 16.78,49.23 16.78,48.75 v1(16.49,48.47) ; v1(127.9,82.37) 127.58,82.04 CPU1.H8
USB30_RX_CPU_N2: length 57.5
  TOP w0.127: R6226.1 v1(99.31,110.73) 99.31,110.7 v2(98.91,110.3)
  L6 w0.102: v1(99.31,110.73) 99.31,110.91 99.06,111.16 97.71,111.16 97.52,110.97 97.52,106.83 98.82,105.54 99.62,105.54 101.22,103.95 105.72,103.95 109.43,100.24 116.16,100.24 119.06,97.34 123.06,97.34 127.53,92.87 127.53,88.78 126.98,88.23 126.98,87 129.59,84.39 129.59,82.89 128.91,82.2 128.59,82.2 128.5,82.11 128.5,81.83 128.63,81.7 v1(128.81,81.7)
  BOTTOM w0.127: CPU1.J6 128.36,81.53 128.53,81.7 v1(128.81,81.7)
USB30_RX_CPU_N3: length 197.2
  L6 w0.102: v1(126.12,81.7) 126.14,81.7 126.57,82.13 126.57,82.47 126.72,82.63 126.72,85.18 125,86.9 124.25,86.9 122.07,89.08 122.07,92.16 120.45,93.79 118.26,93.79 116.97,92.49 110.47,92.49 106.82,96.14 105.83,96.14 103.23,98.74 97.6,98.74 95.72,100.62 82.06,100.62 80.43,98.99 74.85,98.99 73.65,97.8 55.9,97.8 54.31,97.8 53.57,97.06 51.79,97.06 48.9,94.17 48.9,91.85 47.99,90.94 41.3,90.94 38.73,88.38 38.73,86.98 36.78,85.02 32.88,85.02 25.51,77.66 24.3,77.66 21.49,74.85 21.49,74.03 19.61,72.15 19.61,59.14 20.98,57.77 20.98,50.34 16.1,45.47 16.1,41.08 18.39,38.79 18.39,30.84 23.66,25.56 24.7,25.56 25.8,24.46 25.8,23.2 25.57,22.97 25.29,22.97 25.28,22.97 23.97,22.97 23.7,22.7 23.7,22.16 v1(23.62,22.08)
  BOTTOM w0.127: CPU1.J10 126.43,81.39 v1(126.12,81.7) ; R3612.1 22.49,22.92 23.39,22.92 23.62,22.69 v1(23.62,22.08) 23.62,21.94 v2(23.99,21.58)
USB30_RX_CPU_P1: length 187.5
  L6 w0.102: v1(127.04,82.38) 127.28,82.38 127.61,82.71 127.61,83.01 127.13,83.49 127.13,85.42 125.22,87.33 125.22,91.82 121.27,95.77 117.45,95.77 116.41,94.73 111,94.73 110.26,95.46 110.26,97.18 108.16,99.28 106.07,101.37 98.75,101.37 96.93,103.19 90.86,103.19 88.98,105.06 78.58,105.06 75.97,102.45 72.8,102.45 71.33,100.98 65.89,100.98 63.37,103.49 61.21,103.49 58.99,105.71 49.88,105.71 42.63,98.46 34.43,98.46 28.84,92.86 28.84,83.78 24.68,79.63 20.45,79.63 16.9,76.08 16.9,58.48 18.29,57.1 18.29,51.54 17,50.25 17,48.77 v1(17.3,48.47)
  BOTTOM w0.127: v1(127.04,82.38) 127.04,82.5 127.23,82.69 CPU1.G8 ; v2(22.66,50.18) 22.45,50.18 ; 22.45,50.18 22.45,49.8 22.18,49.53 21.84,49.53 20.94,48.63 19.05,48.63 17.91,49.77 17.4,49.77 17.02,49.39 17.02,49.13 17.02,48.75 v1(17.3,48.47) ; 22.45,50.18 22.45,50.64 22.18,50.91 21.41,50.91 R3607.1
USB30_RX_CPU_P2: length 57.6
  TOP w0.127: R6221.1 v1(99.31,111.62) v2(98.73,111.62)
  L6 w0.102: v1(127.89,81.68) 128.3,82.09 128.3,82.2 128.51,82.41 128.82,82.41 129.39,82.97 129.39,84.3 126.78,86.91 126.78,88.32 127.33,88.87 127.33,92.79 122.98,97.14 118.97,97.14 116.08,100.04 109.34,100.04 105.63,103.74 101.13,103.74 99.54,105.34 98.73,105.34 97.32,106.75 97.32,111.06 97.63,111.36 99.06,111.36 v1(99.31,111.62)
  BOTTOM w0.127: v1(127.89,81.68) 128.24,82.04 CPU1.H6
USB30_RX_CPU_P3: length 196.7
  L6 w0.102: v1(126.13,82.36) 126.17,82.36 126.52,82.71 126.52,85.09 124.91,86.7 124.16,86.7 121.87,88.99 121.87,92.08 120.37,93.58 118.35,93.58 117.05,92.29 110.38,92.29 106.74,95.93 105.75,95.93 103.14,98.54 97.52,98.54 95.64,100.42 82.14,100.42 80.52,98.79 74.93,98.79 73.74,97.6 55.82,97.6 55.82,97.6 54.39,97.6 53.65,96.86 51.87,96.86 49.1,94.09 49.1,91.77 48.07,90.74 41.38,90.74 38.94,88.29 38.94,86.9 36.86,84.82 32.96,84.82 25.6,77.46 24.38,77.46 21.69,74.76 21.69,73.95 19.81,72.07 19.81,59.22 21.18,57.85 21.18,50.26 16.31,45.39 16.31,41.16 18.59,38.88 18.59,30.92 23.75,25.77 24.78,25.77 26.01,24.55 26.01,23.12 25.65,22.76 25.2,22.76 25.2,22.77 24.05,22.77 23.9,22.61 23.9,22.42 24.23,22.08 v1(24.38,22.08)
  BOTTOM w0.127: v2(23.8,23.15) 23.65,23 ; 23.65,23 23.49,23.16 22.61,23.16 R3611.1 ; 23.65,23 23.86,22.79 24.37,22.79 24.5,22.67 24.5,22.2 v1(24.38,22.08) ; CPU1.H10 126.38,82.04 126.13,82.29 v1(126.13,82.36)
USB30_TX_CPU_N1: length 176.5
  L6 w0.102: v1(18.8,54.82) 19.03,54.59 19.4,54.59 19.6,54.79 19.6,56.85 17.45,59.01 17.45,75.89 20.67,79.11 24.85,79.11 30.43,84.69 30.43,92.49 32.59,94.65 32.59,94.65 33.18,95.24 36.42,95.24 39.16,97.98 44,97.98 51.23,105.2 58.82,105.2 60.43,103.59 60.43,101.23 61.16,100.49 71.69,100.49 73.16,101.97 76.17,101.97 78.02,103.82 82.97,103.82 83.73,104.58 86.12,104.58 87.99,102.7 96.73,102.7 98.55,100.89 105.87,100.89 109.12,97.64 109.12,95.87 111.02,93.97 116.33,93.97 117.65,95.29 121.07,95.29 123.57,92.78 123.57,90.72 123.89,90.4 124.4,90.4 v1(124.54,90.54)
  BOTTOM w0.089: v1(124.54,90.54) 124.59,90.54 125.26,89.86 125.26,88.06 125.08,87.87 125.08,87.42 124.55,86.89 124.55,86.61 124.58,86.52 124.58,86.25 124.55,86.16 124.55,85.96 124.6,85.83 124.6,85.62 CPU1.C13
  BOTTOM w0.127: v1(18.8,54.82) 19.52,54.82 19.93,55.23 20.93,55.23 22.34,53.82 23.85,53.82 ; 23.85,53.82 24.48,53.82 24.96,53.34 24.96,52.51 24.51,52.06 24.22,52.06 C3601.1 ; 23.85,53.82 v2(23.85,54.04)
USB30_TX_CPU_N2: length 54.4
  TOP w0.127: C6208.1 v1(99.31,112.51) 99.03,112.51 v2(98.7,112.84)
  L6 w0.102: v1(126.11,87.69) 126.11,87.84 126.51,88.24 126.51,88.36 126.85,88.7 126.85,92.59 122.78,96.66 118.77,96.66 115.88,99.55 109.58,99.55 109.14,99.55 106.27,102.42 100.54,102.42 100.15,102.81 100.15,104.04 99.34,104.86 97.79,104.86 97.09,105.55 96.84,105.81 96.84,111.51 98.09,112.76 99.06,112.76 v1(99.31,112.51)
  BOTTOM w0.089: v1(126.11,87.69) 126,87.8 125.67,87.8 125.48,87.6 125.48,86.73 CPU1.B13
USB30_TX_CPU_N3: length 199
  TOP w0.127: v1(24.51,24.09) 24.51,24.62 v2(24.56,24.67)
  L6 w0.102: v1(124.41,89.19) 123.33,89.19 122.83,89.69 122.83,92.43 120.75,94.51 117.96,94.51 116.67,93.22 110.77,93.22 107.12,96.86 106.1,96.86 103.53,99.43 97.88,99.43 95.99,101.32 87.3,101.32 86.9,101.71 82.18,101.71 80.15,99.68 74.52,99.68 73.96,99.12 60.59,99.12 59.96,99.76 53.22,99.76 52.51,100.47 51.98,100.47 51.45,99.95 51.45,99.03 50.28,97.86 50.28,96.65 48.21,94.58 48.21,92.22 47.62,91.63 38.36,91.63 36.03,93.97 34.65,93.97 33.01,92.33 31.19,90.51 31.19,84.31 25.29,78.41 23.2,78.41 20.6,75.81 20.6,75.49 18.89,73.78 18.89,58.89 20.29,57.49 20.29,50.63 15.42,45.76 15.42,40.79 17.7,38.51 17.7,30.38 23.31,24.78 24.47,24.78 24.77,24.48 24.77,24.35 v1(24.51,24.09)
  BOTTOM w0.102: CPU1.B15 123.83,86.64 123.83,87.22 124.03,87.42 124.03,87.89 124.24,88.1
  BOTTOM w0.127: v1(24.51,24.09) 24.87,24.09 25.57,24.8 25.57,25.2 25.45,25.33 24.9,25.33 C3604.1 ; 124.24,88.1 124.58,88.1 124.82,88.34 124.82,88.78 v1(124.41,89.19)
USB30_TX_CPU_P1: length 176.4
  L6 w0.102: v1(124.41,89.88) 124.41,90.04 124.26,90.2 123.81,90.2 123.37,90.64 123.37,92.7 120.99,95.08 117.73,95.08 116.41,93.76 110.94,93.76 108.92,95.79 108.92,97.55 105.78,100.68 98.46,100.68 96.65,102.5 87.9,102.5 86.03,104.37 83.81,104.37 83.06,103.62 78.11,103.62 76.25,101.76 73.25,101.76 71.78,100.29 61.08,100.29 60.22,101.15 60.22,103.51 58.73,105 51.31,105 44.09,97.78 39.25,97.78 36.5,95.03 33.26,95.03 32.8,94.57 30.63,92.4 30.63,84.6 24.93,78.9 20.75,78.9 17.65,75.8 17.65,59.09 19.81,56.94 19.81,54.71 19.49,54.39 19.1,54.39 v1(18.8,54.09)
  BOTTOM w0.089: v1(124.41,89.88) 124.58,90.05 124.81,90.05 125.07,89.79 125.07,88.14 124.89,87.95 124.89,87.5 124.36,86.97 124.36,86.58 124.39,86.49 124.39,86.29 124.37,86.2 124.37,85.93 124.42,85.79 124.42,85.15 CPU1.D13
  BOTTOM w0.127: 21.13,54.69 20.83,54.99 20.03,54.99 19.62,54.58 19.29,54.58 v1(18.8,54.09) ; 21.13,54.69 22.24,53.58 24.38,53.58 24.72,53.24 24.72,52.61 24.41,52.3 24.21,52.3 C3602.1 ; 21.13,54.69 v2(20.98,54.54)
USB30_TX_CPU_P2: length 54.2
  TOP w0.127: C6207.1 v1(99.31,113.4) v2(99.31,113.95)
  L6 w0.102: v1(126.11,88.4) 126.26,88.4 126.64,88.78 126.64,92.5 122.69,96.45 118.69,96.45 115.79,99.35 109.63,99.35 109.06,99.35 106.19,102.22 100.46,102.22 99.95,102.73 99.95,103.96 99.25,104.65 97.71,104.65 96.95,105.41 96.63,105.72 96.63,111.59 98.01,112.96 99.19,112.96 99.31,113.09 v1(99.31,113.4)
  BOTTOM w0.089: v1(126.11,88.4) 126.11,88.24 125.86,87.99 125.59,87.99 125.29,87.68 125.29,86.81 125.07,86.6 124.92,86.6 CPU1.A13
USB30_TX_CPU_P3: length 198.5
  L6 w0.102: v1(24.56,23.43) 24.97,23.84 24.97,24.56 24.56,24.98 23.39,24.98 17.91,30.46 17.91,38.59 15.62,40.88 15.62,45.67 20.49,50.54 20.49,57.57 19.09,58.97 19.09,73.7 20.8,75.41 20.8,75.72 23.28,78.2 25.38,78.2 31.39,84.22 31.39,90.42 33.1,92.13 34.73,93.76 35.94,93.76 38.28,91.43 47.7,91.43 48.41,92.14 48.41,94.5 50.48,96.57 50.48,97.78 51.66,98.95 51.66,99.86 52.06,100.27 52.42,100.27 53.14,99.55 59.87,99.55 60.51,98.92 74.04,98.92 74.6,99.48 80.23,99.48 82.27,101.51 86.82,101.51 87.21,101.12 95.91,101.12 97.8,99.22 103.45,99.22 106.01,96.66 107.04,96.66 110.68,93.01 116.75,93.01 118.05,94.31 120.67,94.31 122.63,92.34 122.63,89.6 123.25,88.99 124.02,88.99 124.41,88.6 v1(124.41,88.5)
  BOTTOM w0.102: CPU1.A15 123.62,86.88 123.62,87.3 123.83,87.5 123.83,87.97 124,88.14 124,88.4 124.1,88.5 v1(124.41,88.5)
  BOTTOM w0.127: v1(24.56,23.43) 24.56,23.44 25.81,24.7 25.81,25 ; 25.81,25 25.81,25.3 25.55,25.57 24.9,25.57 C3605.1 ; 25.81,25 v2(26.04,25)
USB30_VCCB: length 12.2
  TOP w0.508: 14.37,32.89 USB2.1 ; USB2.1 14.37,34.31 ; USB2.1 15.08,33.6 ; v3(20.32,30.85) 22.1,32.62 v1(22.1,38.33)
  BOTTOM w0.508: ED3604.5 21.18,37.45 22.06,38.33 v1(22.1,38.33)
  vias: v2(18.06,31.35) v3(19.81,31.61)
USB30_VCCC: length 5.8
  TOP w0.508: USB1.1 15.08,53.6 ; USB1.1 14.37,52.89 ; USB1.1 13.66,53.6 ; USB1.1 14.37,54.31
  BOTTOM w0.508: 20.97,59.18 EC3619.1 20.97,58.04 20.68,57.74 20.6,57.74 20.14,57.29 ED3602.5
  vias: v2(18.16,57.92) v2(24.13,58.28) v3(15.11,59.93) v3(15.75,60.56) v3(15.75,59.29) v3(22.73,54.98) v3(23.88,54.98) v3(24.77,54.98)
USB_CAMERA_PN4: length 12
  TOP w0.127: EL5501.3 45.3,69.51 44.41,70.39 44.41,70.83 EL5503.3 44.41,71.28 44.41,72.05 45.12,72.75 45.12,74.4 44.93,74.59 44.93,77.17 45.21,77.45 v1(45.21,77.46) 44.98,77.68 v2(44.98,78.04)
  BOTTOM w0.127: LCD1.30 45.15,77.39 45.21,77.45 v1(45.21,77.46)
USB_CAMERA_PP4: length 11.5
  TOP w0.127: 44.69,74.86 44.69,74.49 44.88,74.3 44.88,73.68 EL5503.4 44.88,73.2 44.88,72.85 44.17,72.15 44.17,70.29 44.75,69.71 44.75,69.2 EL5501.2 ; 44.69,74.86 44.69,77.09 v1(44.45,77.33) ; 44.69,74.86 v2(44.53,74.86)
  BOTTOM w0.127: LCD1.31 44.65,76.24 44.91,76.5 44.91,76.97 44.55,77.33 v1(44.45,77.33)
USB_CHG_EN: length 77.8
  TOP w0.127: U9601.10 73.72,73.3 75.03,71.99 75.03,70.39 v1(74.75,70.11) ; U3401.5 27.33,57.92 28.28,58.87 31.02,58.87 31.28,58.61 31.28,58.25 31.18,58.14 31.18,57.07 31.24,57.01 31.24,56.89 34.89,53.24 39.33,53.24 39.75,52.82 v2(40.49,52.82) v1(41.83,52.82)
  L4 w0.127: v1(74.75,70.11) 74.58,70.11 72.63,72.06 62.41,72.06 60.77,73.69 60.77,74.38 60.16,74.99 57.95,74.99 52.5,69.54 50.89,69.54 49.44,68.09 49.44,67.46 48.9,66.91 48.2,66.91 45.88,64.59 42.11,64.59 41.37,63.85 41.34,63.85 39.95,62.46 39.95,54.7 v1(41.83,52.82)
  BOTTOM w0.127: RN9601.1 75.07,69.16 74.75,69.48 v1(74.75,70.11)
USB_CON_PN6: length 11.9
  TOP w0.127: AFTP5806.1 37.52,68.45 ; 37.52,68.45 39.04,68.45 R6110.1 ; 37.52,68.45 36.99,68.45 35.7,67.16 35.42,67.16 v1(35.05,66.79)
  BOTTOM w0.127: v1(35.05,66.79) 34.95,66.89 32.83,66.89 31.84,67.88 30.18,67.88 30.05,67.75 WLAN1.5
USB_CON_PN7: length 13.2
  TOP w0.127: R5535.1 42.78,69.28 42.78,70.03 42.5,70.32 42.5,70.81 EL5503.1 42.5,71.3 42.5,71.82 43.22,72.54 43.22,74.13 42.98,74.37 42.98,76.31 42.58,76.71 42.58,77.58 42.8,77.79 v1(42.8,77.84) 42.77,77.86 v2(42.77,78.5)
  BOTTOM w0.127: LCD1.34 43.15,76.54 42.74,76.96 42.74,77.77 v1(42.8,77.84)
USB_CON_PP6: length 11.8
  TOP w0.127: AFTP5807.1 35.8,67.59 ; 35.8,67.59 36.89,68.69 39.18,68.69 R6111.1 ; 35.8,67.59 35.6,67.4 35.2,67.4 v1(35.05,67.55)
  BOTTOM w0.127: v1(35.05,67.55) 34.63,67.13 32.93,67.13 31.94,68.12 30.18,68.12 30.05,68.25 WLAN1.3
USB_CON_PP7: length 12.7
  TOP w0.127: R5536.1 42.54,69.26 42.54,69.93 42.26,70.21 42.26,71.92 42.98,72.64 42.98,73.2 EL5503.6 42.98,73.68 42.98,74.03 42.74,74.27 42.74,76.21 42.34,76.61 42.34,76.77 ; 42.34,76.77 v2(42.19,76.77) ; 42.34,76.77 42.34,77.66 v1(42.16,77.84)
  BOTTOM w0.127: v1(42.16,77.84) 42.49,77.51 42.49,76.74 42.65,76.59 LCD1.35
USB_CPU_PN0: length 121.3
  TOP w0.127: v1(32.08,55.33) 32.08,55.31 31.64,54.86 31.18,54.86 31.14,54.82 30.5,54.82 30.46,54.86 29.86,54.86 29.47,55.25 29.47,55.72 29.07,56.12 U3401.2 ; v2(127.1,75.6) 126.99,75.49 v1(126.99,75)
  L6 w0.102: v1(126.99,75) 126.99,74.82 126.47,74.3 125.63,74.3 124.85,75.07 122.74,75.07 121.15,76.67 118.21,76.67 117.58,77.3 116.72,77.3 115.15,75.73 101.97,75.73 97.86,79.84 89.49,79.84 88.88,79.23 87.12,79.23 86.94,79.41 81.08,79.41 78.41,76.75 75.75,76.75 72.7,73.7 71.32,73.7 70.65,74.36 67.05,74.36 66.12,73.44 61.47,73.44 60.2,74.71 58.57,74.71 54.99,71.13 52.23,71.13 51.82,71.54 42.23,71.54 37.92,67.23 37.92,66.1 33.35,61.53 33.35,59.72 32.6,58.97 32.6,55.86 32.08,55.33 v1(32.08,55.33)
  BOTTOM w0.127: CPU1.AB9 126.99,75.27 v1(126.99,75)
USB_CPU_PN1: length 163
  L6 w0.102: v1(23.95,27.95) 23.95,27.78 23.77,27.59 22.89,27.59 21.82,28.67 21.82,35.95 20.42,37.35 20.42,38.02 16.99,41.45 16.99,45.1 21.86,49.97 21.86,53.06 22.64,53.83 25.49,53.83 27.42,55.76 28.26,55.76 30.32,53.71 31.55,53.71 33.29,55.45 33.29,58.69 34.04,59.43 34.04,60.91 37.93,64.81 39.61,64.81 40.11,65.31 40.11,68.44 42.11,70.44 55.5,70.44 58.37,73.31 60.63,73.31 61.18,72.76 66.41,72.76 67.17,73.52 67.87,73.52 68.73,72.65 72.63,72.65 76.04,76.06 78.7,76.06 81.36,78.73 86.66,78.73 87.2,78.18 88.82,78.18 89.19,78.55 96.67,78.55 96.99,78.86 97.95,78.86 101.69,75.13 115.57,75.13 116.95,76.51 117.48,76.51 117.73,76.26 120.67,76.26 122.39,74.53 124.35,74.53 124.76,74.12 124.76,73.84 125.33,73.28 128.29,73.28 128.95,73.94 v1(129.02,73.94)
  BOTTOM w0.127: CPU1.AD6 129.21,74.13 v1(129.02,73.94) ; EL3602.1 23.89,27.89 v1(23.95,27.95) 24.31,27.95 v2(24.51,28.15)
USB_CPU_PN2: length 164.8
  L6 w0.102: v1(269.49,35.16) 269.19,34.86 268.66,34.86 265.66,37.85 263.29,37.85 262.99,37.55 261.28,37.55 261.25,37.51 260.64,37.51 260.38,37.25 259.77,36.64 244.8,36.64 243.69,37.75 238.43,37.75 237.45,36.76 235.26,36.76 226.53,45.5 222.71,45.5 220.22,47.99 220.22,50.02 218.82,51.42 216.14,51.42 214.08,53.48 212.4,53.48 211.71,54.16 197.99,54.16 193.34,58.82 187.41,58.82 185.92,57.33 181.04,57.33 179.96,58.41 179.96,62.22 179.04,63.13 177.19,63.13 175.82,64.5 172.53,64.5 172.25,64.22 171.86,64.22 169.98,66.1 168.64,66.1 160.74,74 157.66,74 157.23,73.57 151.7,73.57 151.47,73.34 v1(151.13,73.34)
  BOTTOM w0.089: CPU1.AH3 130.31,71.93 130.56,71.67 131.06,71.67 131.15,71.71 131.42,71.71 131.51,71.67 131.71,71.67 131.8,71.71 132.66,71.71 132.79,71.57 133.61,71.57 133.75,71.72 134.73,71.72 134.76,71.75 134.77,71.75
  BOTTOM w0.127: 149.99,73.12 150.91,73.12 v1(151.13,73.34) ; 149.99,73.12 148.49,73.12 148.34,73.28 146.17,73.28 145.6,72.7 142.85,72.7 141.88,71.74 137.63,71.74 137.48,71.89 135.53,71.89 135.39,71.75 134.77,71.75 ; 149.99,73.12 v2(149.99,73.34) ; v1(269.49,35.16) 269.53,35.12 EL3701.4
USB_CPU_PN3: length 181.9
  L6 w0.102: v1(270,31.13) 270,30.99 270.28,30.71 270.59,30.71 270.69,30.81 270.69,32.83 269.82,33.69 268.17,33.69 267.16,34.71 262.55,34.71 261.71,33.87 248.73,33.87 247.86,33.01 246.39,33.01 246.22,33 244.85,34.38 243.87,34.38 243.21,35.04 238.92,35.04 238.39,34.5 232.8,34.5 229.69,37.61 229.69,38.39 226.34,41.74 224.56,41.74 223.06,43.24 220.75,43.24 217.58,46.42 217.58,48.45 217.1,48.93 213.75,48.93 210.83,51.85 196.37,51.85 194.99,51.85 189.92,46.77 174.57,46.77 171.15,50.2 168.71,50.2 167.85,51.06 166.19,52.72 157.4,52.72 155.14,54.98 148.8,54.98 146.35,57.42 143.2,57.42 142.16,58.46 142.16,62.23 137.3,67.09 136.49,67.09 135.25,68.33 135.25,73.37 134.06,74.56 131.5,74.56 131.01,74.08 129.53,74.08 129.25,74.36 127.41,74.36 127.32,74.26 127.32,74.05 127.46,73.9 v1(127.61,73.9)
  BOTTOM w0.127: v1(127.61,73.9) 127.61,74.26 127.4,74.47 CPU1.AD9 ; R9203.1 272.08,29.67 272.08,30.13 271.76,30.45 ; 271.76,30.45 271.5,30.71 270.42,30.71 v1(270,31.13) ; 271.76,30.45 v2(271.91,30.59)
USB_CPU_PN4: length 103
  TOP w0.127: EL5501.4 45.3,67.56 44.86,67.12 44.86,66.91 44.98,66.79 45.44,66.79 45.56,66.66 v1(45.56,66.58) 45.58,66.56 45.95,66.56 v2(46.2,66.81)
  L6 w0.102: v1(45.56,66.58) 45.54,66.58 45.42,66.45 45.42,66.1 45.54,65.97 45.76,65.97 46.02,66.24 46.02,67.51 47.11,68.59 56.78,68.59 58.78,70.6 71.42,70.6 71.54,70.47 73.95,70.47 75.42,71.94 76.23,71.94 78.19,73.91 79.24,73.91 80.95,75.63 84.33,75.63 85,76.3 89.51,76.3 89.57,76.35 96.99,76.35 99.63,73.71 116.2,73.71 117.25,72.66 120.14,72.66 121.26,71.55 123.52,71.55 124.05,71.03 128,71.03 128.99,70.04 131.36,70.04 131.83,70.51 133.69,70.51 133.99,70.8 v1(133.99,71.13)
  BOTTOM w0.089: CPU1.AJ1 132.09,71.11 132.98,71.11 133.47,70.62 133.76,70.62 133.99,70.85 v1(133.99,71.13)
USB_CPU_PN5: length 172
  L6 w0.102: v1(128.9,72.84) 128.87,72.84 128.68,72.65 128.68,72.5 128.75,72.43 130.53,72.43 130.95,72.85 134.28,72.85 134.77,72.36 134.77,68.13 134.86,68.04 134.86,67.98 136.23,66.61 137.1,66.61 141.66,62.06 141.66,58.29 143,56.94 146.15,56.94 148.67,54.42 155.02,54.42 157.2,52.24 165.99,52.24 167.65,50.58 168.51,49.72 170.95,49.72 174.37,46.29 190.21,46.29 195.17,51.24 195.29,51.36 210.63,51.36 213.93,48.07 215.44,48.07 216.41,47.1 216.41,46.61 221.88,41.14 226.26,41.14 229.21,38.19 229.21,37.41 232.6,34.02 238.59,34.02 239.12,34.55 243.01,34.55 243.67,33.89 244.6,33.89 245.97,32.52 246.02,32.52 248.06,32.52 248.93,33.39 265.78,33.39 266.11,33.72 266.91,33.72 268.16,32.46 269,32.46 v1(269.43,32.9)
  BOTTOM w0.127: v1(128.9,72.84) 128.9,72.84 128.9,73.21 129.09,73.4 CPU1.AF6 ; EL3301.4 270.19,32.84 269.97,32.62 269.71,32.62 v1(269.43,32.9) 269.41,32.88 268.99,32.88 v2(268.86,33.01)
USB_CPU_PN6: length 108.7
  TOP w0.127: R6110.2 40.44,68.17 41.29,68.17 v1(41.4,68.06) 41.38,68.03 v2(41.38,67.37)
  L6 w0.102: v1(133.97,72.14) 133.82,72.14 133.28,71.6 131.94,71.6 130.64,70.3 129.24,70.3 128.29,71.26 124.09,71.26 123.47,71.88 121.95,71.88 121.46,72.37 121.46,72.67 120.88,73.25 120.88,74.2 120.5,74.57 120.11,74.57 119.82,74.29 119.82,74.26 119.21,73.65 116.93,73.65 116.53,74.05 100.05,74.05 97.38,76.72 90.56,76.72 90.49,76.78 86.19,76.78 85.64,77.33 81.97,77.33 79.27,74.62 77.42,74.62 73.75,70.96 71.74,70.96 71.62,71.08 58.56,71.08 56.55,69.07 46.85,69.07 44.05,66.27 41.63,66.27 41.44,66.46 41.44,67.21 41.71,67.47 41.71,67.75 v1(41.4,68.06)
  BOTTOM w0.127: v1(133.97,72.14) 133.8,72.14 133.51,71.85 133.51,71.85 133.48,71.82 133.15,71.82 133.03,71.93 CPU1.AH1
USB_CPU_PN7: length 96.8
  TOP w0.127: R5535.2 43.01,67.83 v1(43.01,66.95) 43.03,66.94 43.38,66.94 v2(43.59,66.74)
  L6 w0.102: v1(43.01,66.95) 42.76,67.21 42.76,67.5 43.15,67.89 43.47,67.89 45.34,69.76 55.93,69.76 58.14,71.97 71.87,71.97 72.2,71.64 73.46,71.64 77.15,75.33 78.93,75.33 81.65,78.04 85.9,78.04 86.46,77.48 88.8,77.48 89.28,77.96 96.99,77.96 100.4,74.56 118.29,74.56 118.83,75.09 121.01,75.09 121.47,74.63 121.47,73.93 122.39,73.01 122.9,73.01 123.64,72.27 124.62,72.27 124.64,72.29 125.16,72.29 125.18,72.26 125.99,72.26 126.22,72.03 126.97,72.03 127.32,72.38 127.32,72.59 v1(127.58,72.86)
  BOTTOM w0.127: v1(127.58,72.86) 127.58,72.96 127.91,73.28 CPU1.AF8
USB_CPU_PP0: length 120.8
  TOP w0.127: v2(29.74,56.09) 29.59,55.94 ; 29.59,55.94 29.71,55.82 29.71,55.35 29.96,55.1 30.56,55.1 30.6,55.06 31.04,55.06 31.08,55.1 31.2,55.1 31.42,55.32 v1(31.42,55.46) ; 29.59,55.94 29.17,56.36 28.72,56.36 28.46,56.62 U3401.3
  L6 w0.102: v1(31.42,55.46) 31.42,55.59 31.59,55.76 32.22,55.76 32.4,55.94 32.4,59.06 33.15,59.8 33.15,61.61 37.72,66.19 37.72,67.31 42.15,71.74 51.9,71.74 52.31,71.33 54.91,71.33 58.49,74.92 60.28,74.92 61.55,73.65 66.04,73.65 66.96,74.57 70.73,74.57 71.4,73.9 72.62,73.9 75.67,76.95 78.33,76.95 80.99,79.61 87.03,79.61 87.21,79.44 88.8,79.44 89.41,80.05 97.94,80.05 102.06,75.93 115.06,75.93 116.64,77.51 117.66,77.51 118.3,76.87 121.24,76.87 122.83,75.28 124.94,75.28 125.71,74.5 126.38,74.5 126.48,74.6 126.48,74.81 v1(126.28,75)
  BOTTOM w0.127: v1(126.28,75) 126.28,75.34 126.47,75.53 CPU1.AB10
USB_CPU_PP1: length 163
  L6 w0.102: v1(128.37,73.93) 128.37,73.64 128.21,73.48 125.41,73.48 124.97,73.93 124.97,74.2 124.43,74.74 122.48,74.74 120.75,76.46 117.81,76.46 117.56,76.71 116.86,76.71 115.48,75.33 101.77,75.33 98.04,79.07 96.9,79.07 96.58,78.75 89.1,78.75 88.73,78.38 87.29,78.38 86.74,78.93 81.28,78.93 78.61,76.27 75.96,76.27 72.55,72.86 68.82,72.86 67.95,73.72 67.09,73.72 66.32,72.96 61.27,72.96 60.71,73.52 58.28,73.52 55.41,70.65 42.02,70.65 39.9,68.53 39.9,65.39 39.52,65.01 37.85,65.01 33.83,61 33.83,59.52 33.09,58.77 33.09,55.53 31.46,53.91 30.4,53.91 28.35,55.97 27.34,55.97 25.41,54.04 22.56,54.04 21.66,53.14 21.66,50.06 16.79,45.19 16.79,41.36 20.22,37.93 20.22,37.26 21.62,35.87 21.62,28.58 22.81,27.39 23.75,27.39 v1(23.98,27.16)
  BOTTOM w0.127: v2(24.51,26.83) 24.18,27.16 v1(23.98,27.16) 23.94,27.2 EL3602.4 ; CPU1.AD7 128.56,74.12 v1(128.37,73.93)
USB_CPU_PP2: length 164.7
  L6 w0.102: v1(151.25,72.7) 151.25,72.83 151.79,73.37 157.31,73.37 157.74,73.8 160.66,73.8 168.55,65.9 169.89,65.9 171.77,64.02 172.33,64.02 172.61,64.3 175.74,64.3 177.11,62.93 178.96,62.93 179.75,62.13 179.75,58.32 180.95,57.12 186,57.12 187.49,58.62 193.25,58.62 197.91,53.96 211.63,53.96 212.31,53.28 214,53.28 216.05,51.22 218.73,51.22 220.01,49.94 220.01,47.91 222.62,45.3 226.44,45.3 235.18,36.56 237.53,36.56 238.52,37.55 243.61,37.55 244.72,36.43 259.85,36.43 260.52,37.1 260.73,37.31 261.33,37.31 261.37,37.35 263.08,37.35 263.38,37.65 265.58,37.65 268.57,34.66 269.2,34.66 v1(269.49,34.36)
  BOTTOM w0.089: CPU1.AJ3 130.86,71.49 131.09,71.49 131.18,71.53 131.38,71.53 131.47,71.49 131.74,71.49 131.83,71.53 132.57,71.53 132.72,71.38 133.69,71.38 133.83,71.53 134.74,71.53 134.77,71.5
  BOTTOM w0.127: v1(269.49,34.36) 269.58,34.44 EL3701.1 ; 134.77,71.5 135.49,71.5 135.63,71.65 137.38,71.65 137.53,71.5 141.98,71.5 142.95,72.46 145.7,72.46 146.27,73.04 148.24,73.04 148.39,72.88 148.79,72.88 ; 148.79,72.88 151.07,72.88 v1(151.25,72.7) ; 148.79,72.88 v2(148.79,72.71)
USB_CPU_PP3: length 181.9
  L6 w0.102: v1(270,30.36) 270.15,30.51 270.67,30.51 270.89,30.73 270.89,32.91 269.91,33.89 268.26,33.89 267.24,34.91 262.46,34.91 261.63,34.07 248.64,34.07 247.78,33.21 246.3,33.21 244.93,34.58 243.95,34.58 243.29,35.24 238.83,35.24 238.3,34.71 232.88,34.71 229.9,37.7 229.9,38.48 226.43,41.95 224.65,41.95 223.15,43.44 220.84,43.44 217.78,46.5 217.78,48.37 217.78,48.54 217.18,49.13 213.83,49.13 210.92,52.05 196.45,52.05 194.91,52.05 189.83,46.98 174.66,46.98 171.23,50.4 168.79,50.4 167.93,51.27 166.27,52.92 157.48,52.92 155.23,55.18 148.88,55.18 146.43,57.63 143.28,57.63 142.37,58.55 142.37,62.32 137.39,67.3 136.58,67.3 135.46,68.41 135.46,73.45 134.15,74.76 131.41,74.76 130.93,74.28 129.62,74.28 129.34,74.56 127.33,74.56 126.92,74.15 v1(126.92,73.92)
  BOTTOM w0.127: 270.64,30.47 270.1,30.47 v1(270,30.36) ; 270.64,30.47 v2(270.64,30.34) ; 270.64,30.47 271.4,30.47 271.84,30.03 271.84,29.67 R9204.1 ; v1(126.92,73.92) 126.6,74.23 CPU1.AD10
USB_CPU_PP4: length 102.9
  TOP w0.127: EL5501.1 44.62,67.81 44.62,66.81 44.62,66.81 44.62,66.69 v1(44.98,66.32) 45.21,66.09 v2(45.21,65.77)
  L6 w0.102: v1(44.98,66.32) 44.98,66.25 45.46,65.77 45.85,65.77 46.23,66.15 46.23,67.42 47.19,68.39 56.86,68.39 58.87,70.39 71.34,70.39 71.46,70.27 74.03,70.27 75.5,71.74 76.31,71.74 78.28,73.71 79.32,73.71 81.04,75.42 84.42,75.42 85.09,76.1 89.6,76.1 89.65,76.15 96.9,76.15 99.55,73.51 116.11,73.51 117.16,72.46 120.06,72.46 121.17,71.35 123.44,71.35 123.96,70.83 127.91,70.83 128.91,69.84 131.44,69.84 131.91,70.3 134.07,70.3 v1(134.11,70.34)
  BOTTOM w0.089: CPU1.AJ2 131.63,70.92 132.9,70.92 133.39,70.43 134.02,70.43 v1(134.11,70.34)
USB_CPU_PP5: length 172.1
  TOP w0.127: v1(128.27,72.84) 128.27,72.65 v2(128.57,72.35)
  L6 w0.102: v1(269.43,32.09) 269.27,32.26 268.08,32.26 266.83,33.51 266.19,33.51 265.86,33.18 249.01,33.18 248.15,32.32 245.89,32.32 244.52,33.69 243.58,33.69 242.92,34.35 239.2,34.35 238.67,33.82 232.52,33.82 229.01,37.33 229.01,38.11 226.18,40.94 221.8,40.94 216.2,46.53 216.2,47.02 215.36,47.86 213.84,47.86 210.55,51.16 195.37,51.16 190.3,46.09 174.29,46.09 170.86,49.52 168.42,49.52 167.56,50.38 167.56,50.38 165.9,52.04 157.11,52.04 154.93,54.21 148.59,54.21 146.06,56.74 142.92,56.74 141.45,58.2 141.45,61.97 137.02,66.41 136.15,66.41 134.57,67.99 134.57,72.27 134.19,72.65 131.03,72.65 130.61,72.23 128.66,72.23 128.47,72.42 128.47,72.64 v1(128.27,72.84)
  BOTTOM w0.127: v1(128.27,72.84) 128.27,73.11 CPU1.AF7 ; v1(269.43,32.09) 269.71,32.38 270,32.38 270.22,32.16 EL3301.1
USB_CPU_PP6: length 108.8
  TOP w0.127: R6111.2 40.41,68.86 v1(41.37,68.86) 41.37,69.59 v2(41.35,69.61)
  L6 w0.102: v1(133.35,72.26) 133.35,71.95 133.2,71.8 131.86,71.8 130.56,70.51 129.33,70.51 128.37,71.46 124.17,71.46 123.55,72.08 122.04,72.08 121.67,72.45 121.67,72.76 121.08,73.34 121.08,74.28 120.59,74.78 120.02,74.78 119.62,74.38 119.62,74.35 119.12,73.85 117.01,73.85 116.61,74.25 100.13,74.25 97.46,76.92 90.64,76.92 90.58,76.99 86.27,76.99 85.73,77.53 81.89,77.53 79.18,74.83 77.33,74.83 73.67,71.16 71.83,71.16 71.7,71.28 58.47,71.28 56.46,69.28 46.77,69.28 43.96,66.47 41.72,66.47 41.65,66.54 41.65,67.12 41.91,67.39 41.91,68.34 41.4,68.86 v1(41.37,68.86)
  BOTTOM w0.127: CPU1.AH2 131.24,72.21 131.77,72.21 131.81,72.17 133.26,72.17 v1(133.35,72.26)
USB_CPU_PP7: length 96.7
  TOP w0.127: R5536.2 42.33,67.83 v1(42.33,66.95) ; v2(127.2,73.37) 127.2,73.21 v1(126.87,72.88)
  L6 w0.102: v1(42.33,66.95) 42.56,67.18 42.56,67.59 43.07,68.1 43.39,68.1 45.25,69.96 55.85,69.96 58.06,72.17 71.96,72.17 72.28,71.85 73.38,71.85 77.07,75.53 78.85,75.53 81.56,78.24 85.99,78.24 86.55,77.68 88.71,77.68 89.2,78.17 97.08,78.17 100.48,74.76 118.21,74.76 118.75,75.3 121.09,75.3 121.68,74.71 121.68,74.02 122.48,73.21 122.99,73.21 123.72,72.48 124.54,72.48 124.55,72.49 125.24,72.49 125.27,72.46 126.07,72.46 126.3,72.23 126.88,72.23 127.11,72.46 127.11,72.64 v1(126.87,72.88)
  BOTTOM w0.127: CPU1.AF9 127.25,73.39 126.87,73.01 v1(126.87,72.88)
USB_EN#: length 28.8
  TOP w0.127: v1(223.7,13.12) 224.56,13.98 v2(225.22,13.98) 225.91,13.98 226.5,13.38 Q2401.S 226.5,12.49 226.82,12.18 228.41,12.18 228.79,11.8 R2479.2 R2461.2 ; KBC24.13 215.31,27.54 v1(214.96,27.19)
  BOTTOM w0.127: v1(223.7,13.12) 222.35,14.46 221.26,14.46 219.13,16.6 219.13,17.13 217.6,18.65 217.6,22.21 216.84,22.97 216.84,25.87 215.52,27.19 v1(214.96,27.19)
USB_OC0#: length 144.1
  TOP w0.102: v1(30.66,54.34) 30.66,54.24 v2(30.2,53.78) 30.05,53.63 30.05,52.89 29.44,52.28 26.95,52.28 25.54,53.69 U3401.13
  L4 w0.102: v1(128.14,88.89) 127.34,89.69 127.16,89.69 124.2,92.64 119.48,92.64 118.38,91.54 110.07,91.54 106.57,95.04 102.12,95.04 95.03,87.96 89.22,87.96 83.79,82.54 69.33,82.54 68.06,83.81 62.33,83.81 60.45,85.69 59.54,85.69 59.28,85.44 59.28,85.01 57.82,83.55 57.37,83.55 56.74,82.92 53.28,82.92 50.2,79.84 42.12,79.84 36.3,74.03 34.6,74.03 33.46,72.88 33.46,64.24 33.95,63.76 33.95,59.84 33.58,59.47 33.58,56.22 32.21,54.85 31.17,54.85 v1(30.66,54.34)
  BOTTOM w0.102: RN1602.7 127.38,90.41 127.33,90.36 127.33,89.67 128.12,88.89 v1(128.14,88.89) 128.36,88.67 128.36,88.01 127.28,86.94 CPU1.A9
USB_OC1#: length 180
  L4 w0.102: v1(21.08,32.88) 21.97,33.77 21.97,36.05 20.83,37.2 20.83,40.88 22.86,42.91 22.86,46.42 27.18,50.73 32.89,50.73 33.16,51.01 33.48,51.22 33.54,51.25 33.64,51.34 33.77,51.34 33.83,51.37 33.92,51.39 34.49,51.96 34.49,53.91 33.88,54.52 32.07,54.52 31.46,53.91 30.48,53.91 30.23,54.16 30.23,58.66 31.24,59.68 31.37,59.68 31.41,59.72 32.06,59.72 32.14,59.8 32.61,59.8 33.74,60.93 33.74,63.59 32.52,64.82 32.52,69.04 32.33,69.23 32.33,69.96 32.58,70.21 32.58,72.86 33.95,74.23 36.22,74.23 42.04,80.05 50.12,80.05 53.19,83.12 56.65,83.12 57.29,83.75 57.74,83.75 59.08,85.1 59.08,85.52 59.66,86.1 60.43,86.1 61.36,85.18 62.97,85.18 63.93,84.21 68.51,84.21 69.61,83.11 69.66,83.06 69.78,82.94 83.3,82.94 88.8,88.44 94.93,88.44 101.99,95.5 106.69,95.5 110.24,91.95 117.99,91.95 119.09,93.05 124.42,93.05 125.03,92.44 125.87,92.44 v1(128.32,89.99)
  BOTTOM w0.102: U3502.3 17.08,32.82 17.4,33.13 v2(20.14,33.13) 20.83,33.13 v1(21.08,32.88) ; CPU1.C9 127.28,85.64 127.8,86.15 127.8,86.92 128.74,87.86 128.74,89.15 128.32,89.57 v1(128.32,89.99) 128.32,90.08 128.54,90.29 RN1602.5
USB_OC2#: length 205.9
  L3 w0.102: v1(127.96,88.18) 130.18,88.18 v1(130.84,88.83)
  L4 w0.102: v1(278.51,23.61) 279.4,24.5 279.58,24.5 280.29,25.21 280.29,34.1 279.66,34.73 275.77,34.73 273.76,36.74 268.02,36.74 266.84,35.56 243.49,35.56 242.71,36.33 232.79,36.33 230.76,38.36 230.76,40.6 226.68,44.68 223.79,44.68 218.44,50.02 216.51,50.02 215.82,50.71 215.82,53.42 214.8,54.44 195.22,54.44 194.28,55.38 v1(194.28,55.84)
  L6 w0.102: v1(194.28,55.84) 190.86,55.84 189.56,57.14 188.11,57.14 186.82,55.84 184.02,55.84 183.46,55.28 181.03,55.28 179.33,56.98 169.35,56.98 168.99,57.34 168.99,59.88 168.39,60.48 164.93,60.48 164.07,61.34 164.07,62.77 163.28,63.56 158.44,63.56 158.12,63.88 158.12,64.66 156.86,65.92 156.84,65.92 153.61,69.15 148.83,69.15 141.78,76.2 141.78,78.65 138.36,82.08 136.01,82.08 130.84,87.25 v1(130.84,88.83)
  BOTTOM w0.102: U3503.3 278.64,23.73 v1(278.51,23.61) ; CPU1.D9 126.95,85.1 126.95,87.74 127.22,88.01 127.79,88.01 v1(127.96,88.18) 127.08,89.06 v2(126.8,89.06) 126.73,89.13 RN1602.8
USB_OC3#: length 5.7
  BOTTOM w0.102: RN1602.6 127.89,90.41 127.76,90.28 v2(127.76,89.82) 127.79,89.82 128.55,89.07 128.55,87.93 127.57,86.95 127.57,86.35 CPU1.B9
USB_PN0_C: length 19.7
  L6 w0.102: v1(17.63,54.04) 17.29,54.37 17.29,54.61 16.85,55.05 16.3,55.05 15.59,54.35 15.59,53.07 16.54,52.12 16.54,51.63 15.11,50.2 14.47,50.2 14.37,50.3 USB1.2
  BOTTOM w0.127: 17.14,54.78 16.88,55.04 16.04,55.04 15.7,55.38 15.7,56.05 16.23,56.58 16.52,56.58 ED3602.1 17.01,56.58 17.81,56.58 18.53,55.85 20.32,55.85 20.7,56.23 21.17,56.23 EL3601.3 ; 17.14,54.78 v2(17.26,54.9) ; 17.14,54.78 17.31,54.61 17.31,54.35 v1(17.63,54.04)
USB_PN0_R: length 3
  TOP w0.127: v2(22.83,56.09) 23.34,56.09 v1(23.47,55.97) 23.75,56.25 23.97,56.25 24.1,56.12 U3401.11
  BOTTOM w0.127: v1(23.47,55.97) 22.68,55.97 EL3601.4
USB_PN1_C: length 26
  TOP w0.127: v1(16.7,37.06) 16.71,37.07 v2(17.28,37.07)
  L6 w0.102: USB2.2 14.37,30.3 14.47,30.2 14.84,30.2 16.05,31.41 16.05,33.94 15.42,34.57 15.42,35.96 16.14,36.69 16.33,36.69 v1(16.7,37.06)
  BOTTOM w0.127: EL3602.2 21.23,27.89 21.03,28.08 21.03,28.52 21.89,29.39 21.89,36.36 21.28,36.97 19.56,36.97 18.86,36.27 18.19,36.27 ED3604.1 17.73,36.27 17.49,36.27 16.98,36.79 16.98,36.79 v1(16.7,37.06)
USB_PN2_C: length 18
  TOP w0.127: AFTP6301.1 284.58,38.63 284.42,38.71 284.39,38.8 284.39,38.86 283.33,39.92 282.9,39.92 v1(282.61,40.2)
  BOTTOM w0.127: EL3701.3 271.95,35.12 272.16,34.91 272.29,34.91 272.54,35.16 272.54,36.67 273.65,37.78 274.38,37.78 ED3701.6 274.87,37.78 275.78,37.78 276.51,38.52 278.26,38.52 279.65,39.91 280.24,39.91 280.62,40.3 IOBD3.3 281.53,40.3 281.91,39.92 282.33,39.92 v1(282.61,40.2)
USB_PN3_C: length 24.1
  TOP w0.127: 271.25,21.12 268.73,21.12 268.61,21.25 268.61,22.63 268.78,22.81 269.76,22.81 270.47,23.52 271.32,23.52 ED9201.1 271.78,23.52 272.12,23.52 273.08,22.56 273.62,22.56 v1(273.94,22.24) ; 271.25,21.12 AFTP8903.1 ; 271.25,21.12 271.9,21.12 273.2,19.82 274.02,19.82 274.15,19.95 FPR1.4
  BOTTOM w0.127: v1(273.94,22.24) 273.94,22.39 274.12,22.57 274.51,22.57 274.73,22.79 274.73,23.43 274.42,23.73 272.8,23.73 272.06,24.47 272.06,26.72 EC9202.2 271.98,27.59 271.98,27.91 R9203.2
USB_PN5_C: length 16.4
  TOP w0.127: v1(282.53,37.23) 283.3,37.23 283.85,36.69 AFTP6304.1
  BOTTOM w0.127: v1(282.53,37.23) 282.24,36.95 281.94,36.95 281.58,37.3 IOBD3.6 280.34,37.3 279.93,36.89 279.17,36.89 278.87,36.59 276.11,36.59 275.39,35.86 274.88,35.86 ED3701.4 274.37,35.86 274.35,35.86 272.54,34.06 272.54,32.87 272.29,32.62 272.04,32.62 271.82,32.84 EL3301.3
USB_PP0_C: length 20.2
  TOP w0.127: v1(16.87,54.04) 16.87,54.32 v2(17.14,54.6)
  L6 w0.102: USB1.3 14.37,49.9 14.47,50 15.19,50 16.74,51.55 16.74,52.21 15.8,53.15 15.8,54.26 16.38,54.85 16.77,54.85 17.06,54.55 17.06,54.23 v1(16.87,54.04)
  BOTTOM w0.127: EL3601.2 21.18,56.47 20.6,56.47 20.22,56.09 19.7,56.09 ED3602.6 19.22,56.09 18.63,56.09 17.91,56.82 16.13,56.82 15.46,56.15 15.46,55.28 15.94,54.8 16.78,54.8 17.07,54.51 17.07,54.24 v1(16.87,54.04)
USB_PP0_R: length 3
  TOP w0.127: U3401.10 24.12,56.62 23.99,56.49 23.75,56.49 v1(23.47,56.78) 23.24,57 v2(23.24,57.39)
  BOTTOM w0.127: v1(23.47,56.78) 22.73,56.78 EL3601.1
USB_PP1_C: length 25.5
  L6 w0.102: USB2.3 14.37,29.9 14.47,30 14.93,30 16.26,31.33 16.26,34.02 15.62,34.66 15.62,35.88 16.23,36.48 16.41,36.48 16.42,36.48 16.52,36.48 v1(16.7,36.3)
  BOTTOM w0.127: v1(16.7,36.3) 16.81,36.4 17.02,36.4 17.39,36.03 18.96,36.03 19.66,36.73 20.42,36.73 ED3604.6 20.88,36.73 21.18,36.73 21.65,36.26 21.65,29.49 20.79,28.62 20.79,28.28 ; v2(20.65,28.28) 20.79,28.28 ; 20.79,28.28 20.79,27.98 21.57,27.2 EL3602.3
USB_PP2_C: length 17.7
  TOP w0.127: v1(282.61,39.4) 282.9,39.68 283.23,39.68 284.15,38.76 284.19,38.64 284.1,38.48 AFTP6302.1
  BOTTOM w0.127: v1(282.61,39.4) 282.33,39.68 281.93,39.68 281.55,39.3 IOBD3.4 280.62,39.3 280.25,39.67 279.75,39.67 278.34,38.26 277.56,38.26 ED3701.1 277.06,38.28 276.61,38.28 275.88,37.54 273.75,37.54 272.78,36.57 272.78,35.06 272.39,34.67 272.16,34.67 271.93,34.44 EL3701.2
USB_PP3_C: length 24.1
  TOP w0.127: v1(273.92,22.98) 273.74,22.8 273.18,22.8 272.22,23.76 270.37,23.76 269.66,23.05 269.1,23.05 ED9201.6 268.36,22.87 268.36,21.15 268.63,20.88 269.42,20.88 ; 269.42,20.88 AFTP8904.1 ; 269.42,20.88 271.8,20.88 273.1,19.58 274.02,19.58 274.15,19.45 FPR1.3
  BOTTOM w0.127: v1(273.92,22.98) 274.08,22.81 274.41,22.81 274.49,22.89 274.49,23.33 274.32,23.49 272.7,23.49 271.82,24.37 271.82,26.86 EC9201.2 271.74,27.28 271.74,28.11 R9204.2
USB_PP5_C: length 16.8
  TOP w0.127: v1(282.53,36.42) 282.53,36.6 282.9,36.98 283.22,36.98 283.55,36.64 283.55,36.26 283.08,35.8 AFTP6303.1
  BOTTOM w0.127: EL3301.2 271.82,32.16 272.04,32.38 272.39,32.38 272.78,32.77 272.78,33.96 274.45,35.62 275.49,35.62 276.21,36.35 277.09,36.35 ED3701.3 277.55,36.35 278.97,36.35 279.27,36.65 280,36.65 280.35,36.3 IOBD3.7 281.55,36.3 281.96,36.7 282.25,36.7 v1(282.53,36.42)
USB_PWR_EN#: length 306.3
  TOP w0.127: v2(223.27,11.42) 223.77,11.92 Q2401.D ; Q2401.D 224.6,12.62 224.76,12.79 v1(224.76,12.86) ; Q2401.D 224.73,11.8 226.76,11.8 227.27,11.29 R2479.1
  L3 w0.127: v1(224.76,12.86) 224.76,12.41 224.28,11.92 214.8,11.92 212.27,14.45 205.45,14.45 204.95,13.96 199.99,13.96 199.89,13.85 199.05,13.85 198.94,13.96 198.24,13.96 198.18,13.89 197.81,13.89 197.75,13.96 195.96,13.96 194.5,12.49 194.5,11.55 193.16,10.21 192.21,10.21 191.26,9.26 191.13,9.26 191.01,9.13 191.01,8.96 190.88,8.83 190.86,8.83 190.29,8.26 184.76,8.26 184.46,7.96 175.21,7.96 174.91,8.26 146.02,8.26 142.49,4.73 135.43,4.73 133.57,2.87 119.37,2.87 118.05,4.19 114.76,4.19 112.51,1.94 81.86,1.94 81.28,2.53 68.17,2.53 67.5,3.2 61.79,3.2 60.32,1.72 43.93,1.72 v1(43.87,1.79)
  L6 w0.127: v1(16.76,35.55) 17.02,35.29 17.02,29.45 21.97,24.5 21.97,21.9 23.18,20.69 25.01,20.69 28.75,16.95 30.18,16.95 30.68,16.44 30.68,15.28 31.5,14.46 31.5,12.66 33.4,10.76 33.4,9.39 41,1.79 v1(43.87,1.79) ; v1(274.7,24.5) 274.19,23.99 273.19,23.99 271.02,21.82 257.62,21.82 256.57,20.76 249.96,20.76 241.8,12.6 240.35,12.6 239.41,11.66 230.33,11.66 229.74,11.06 227.48,11.06 225.68,12.86 v1(224.76,12.86)
  BOTTOM w0.127: v1(16.76,35.55) 17.08,35.22 U3502.4 ; v1(274.7,24.5) 274.76,24.56 R2434.2 275.71,24.44 U3503.4
USB_UART_SEL_D9: length 4.7
  BOTTOM w0.089: CPU1.P2 131.51,79 131.74,79 131.83,78.96 131.94,78.96 131.95,78.96 132.76,78.96 132.78,78.98 133.25,78.98 133.44,78.79 134.56,78.79 135.15,79.39
  BOTTOM w0.102: TP2006.1 135.23,79.47 135.15,79.39
USB_WWAN_N_R: length 5.6
  TOP w0.127: R6222.2 101.21,107.88 101.8,107.88 v1(102.11,108.19) v2(102.67,108.19)
  BOTTOM w0.127: v1(102.11,108.19) 102.42,107.88 102.55,107.88 102.87,107.55 102.87,106.6 103.22,106.25 WWAN1.9
USB_WWAN_P_R: length 5.7
  TOP w0.127: v2(102.11,106.79) v1(102.11,107.38) 101.85,107.64 101.12,107.64 101.1,107.63 R6210.2
  BOTTOM w0.127: v1(102.11,107.38) 102.36,107.64 102.45,107.64 102.63,107.45 102.63,106.5 103.38,105.75 WWAN1.7
USB_WWAN_PN8: length 84.6
  TOP w0.127: v1(98.93,108.32) 99.12,108.13 99.7,108.13 R6222.1
  L6 w0.102: v1(147.47,74.25) 147.47,74.26 147.17,74.56 147.17,79.36 142.77,83.75 142.44,83.75 136.65,89.54 136.65,89.81 134.27,92.19 131.83,92.19 129.87,94.14 129.87,96.06 127.4,98.54 119.55,98.54 116.66,101.43 109.92,101.43 105.5,105.85 102.7,105.85 100.62,107.94 99.31,107.94 v1(98.93,108.32)
  BOTTOM w0.127: CPU1.AG1 133.12,72.6 133.18,72.66 133.2,72.66 133.2,72.66 134.82,72.66 134.82,72.65 136.93,72.65 ; 136.93,72.65 v2(136.93,72.43) ; 136.93,72.65 137.43,72.65 137.84,72.25 141.44,72.25 142.4,73.21 145.21,73.21 145.8,73.8 146.87,73.8 147.32,74.25 v1(147.47,74.25)
USB_WWAN_PP8: length 84.5
  TOP w0.127: v1(98.93,107.3) 99.19,107.55 99.67,107.55 99.89,107.34 R6210.1
  L6 w0.102: v1(98.93,107.3) 99.36,107.73 100.53,107.73 102.62,105.65 105.42,105.65 109.84,101.23 116.57,101.23 119.47,98.33 127.31,98.33 129.67,95.98 129.67,94.06 131.74,91.98 134.19,91.98 136.45,89.72 136.45,89.46 142.36,83.55 142.69,83.55 146.97,79.27 146.97,74.37 146.85,74.25 v1(146.69,74.25)
  BOTTOM w0.127: 139.37,72.49 141.34,72.49 142.3,73.45 145.11,73.45 145.7,74.05 146.49,74.05 v1(146.69,74.25) ; 139.37,72.49 v2(139.37,72.68) ; 139.37,72.49 137.94,72.49 137.53,72.9 134.92,72.9 134.92,72.9 133.1,72.9 133.1,72.9 133.08,72.9 133.02,72.84 132.22,72.84 132.14,72.91 131.47,72.91 131.28,72.72 CPU1.AG2
USBCHARGER_CB0: length 260.8
  TOP w0.127: v1(26.54,59.41) 26.54,59.41 U3401.6 ; v1(51.59,26.2) 52.37,26.2 57.41,31.24 120.68,31.24 126.72,37.27 148.16,37.27 156.33,29.1 165.72,29.1 167.26,27.56 170.65,27.56 v1(171.1,28.01) ; KBC24.118 211.11,22.3 211.01,22.4 211.01,24.17 211.27,24.43 211.97,24.43 v1(212.47,23.93)
  L3 w0.127: v1(212.47,23.93) 212.07,23.53 208.47,23.53 203.89,18.95 194.75,18.95 193.78,19.91 192.75,19.91 190.78,21.88 190.78,23.2 190.03,23.95 190.03,25.92 187.43,28.52 182.4,28.52 182.25,28.67 171.77,28.67 v1(171.1,28.01) ; v1(25.78,22.08) 26.44,22.08 29.12,19.4 42.08,19.4 42.21,19.53 42.94,19.53 49.61,26.2 v1(51.59,26.2)
  L4 w0.127: v1(25.78,22.08) 25.78,26.02 24.77,27.04 24.77,28.05 20.07,32.75 20.07,34.01 21.29,35.23 21.29,35.98 20.32,36.94 20.32,41.26 22.1,43.04 22.1,46.34 21.21,47.23 21.21,51.64 21.75,52.18 21.75,56.05 23.18,57.47 24.86,57.47 26.33,58.94 26.33,59.2 v1(26.54,59.41)
  BOTTOM w0.127: v2(26.35,61.22) R2447.1 26.35,59.61 v1(26.54,59.41)
USBCOMP: length 2.1
  TOP w0.14: R1603.1 129.08,75.79 129.08,75.07 v1(129.02,75) 129.02,74.77 128.75,74.51 v2(128.73,74.51)
  BOTTOM w0.14: CPU1.AB6 129.21,75.26 v1(129.02,75)
V_SM_VREF_CNTA: length 130.6
  TOP w0.508: v1(87.25,10.02) 86.36,10.91 R1206.2
  L4 w0.508: v1(48.23,23.76) 42.34,17.88 42.34,13.56 43.87,12.02 43.95,12.02 44.64,11.34 45.37,11.34 46.17,10.54 55.69,10.54 55.91,10.76 86.18,10.76 86.92,10.02 v1(87.25,10.02)
  BOTTOM w0.089: CPU1.AY67 94,65.1 94,64.67 93.96,64.52 93.96,64.27 93.98,64.19 93.98,63.46 92.94,62.42
  BOTTOM w0.254: v1(48.23,23.76) 48.31,23.68 50.6,23.68 54.01,27.09 54.01,27.24 64.76,38 64.76,39.28 64.92,39.43 66.18,40.7 66.29,40.7 66.73,41.13 75.54,41.13 88.9,54.5 v2(88.9,55.59) 88.9,58.41 89.14,58.64 89.14,61.34 90.22,62.42 92.94,62.42
  BOTTOM w0.508: C1222.1 87.08,9.85 v1(87.25,10.02)
V_SM_VREF_CNTB: length 12.6
  BOTTOM w0.089: 92.34,62.95 93.37,63.98 93.37,63.98 93.42,64.14 CPU1.BA67
  BOTTOM w0.305: 92.34,62.95 90.23,62.95 88.65,61.37 88.65,60.54
  BOTTOM w0.508: R1305.2 86.74,56.69 C1323.1 87.63,56.82 87.63,58.34 v2(87.84,58.55) 88.65,59.36 88.65,60.54
VCI_IN1#: length 2.7
  TOP w0.102: R2452.1 214.24,19.48 v2(214.2,19.52) 214.2,19.88 214.32,20 KBC24.126
VGA_CORE: length 20.7
  TOP w0.508: PR8545.2 204.37,51.42 203.76,52.03 203.73,52.03 202.77,53 v2(202.77,53.31) 201.85,54.22 v1(201.85,55.2)
  L6 w0.508: v1(201.85,55.2) 201.5,54.85 200.52,54.85 199.26,56.11 199.26,56.75 198.45,57.57 198.45,58.68 197.36,59.78 197.36,63.65 v3(194.55,66.46)
  vias: v1(173.03,78.77) v1(174.01,84.48) v1(173.97,78.7) v1(176.02,84.56) v1(176.05,81.95) v1(176.14,82.8) v1(176.14,79.83) v1(176.9,83.76) v1(176.91,80.78) v1(176.94,77.83) v1(177.83,83.86) v1(177.89,77.76) v1(178.1,75.43) v1(178.74,77.82) v1(178.82,84.55) v1(178.82,83.78) v1(178.83,80.77) v1(178.9,78.92) v1(179.32,75.77) v1(179.3,75.11) v1(179.74,79.98) v1(179.78,83.74) v1(179.88,81.51) v1(179.86,76.74) v1(180.6,75.94) v1(180.6,75.21) v1(180.79,84.58) v1(181.94,80.75) v1(181.91,79.63) v1(182.57,79.64) v3(184.89,67.01) v3(184.9,66.16) v3(185.75,67.01) v3(185.76,66.16) v3(186.68,67) v3(186.69,66.15) v3(187.59,67) v3(187.6,66.15) v3(188.46,67) v3(188.47,66.15) v3(189.37,67) v3(189.38,66.15) v3(190.24,67) v3(190.25,66.15) v3(191.15,67) v3(191.16,66.15) v3(192.85,66.98) v3(192.89,66.1) v3(193.27,77.84) v3(193.29,76.95) v3(193.27,76.06) v3(193.29,75.17) v3(193.27,74.28) v3(193.27,73.38) v3(193.65,67.35) v3(193.65,66.46) v3(194.13,78.78) v3(194.18,77.84) v3(194.18,76.95) v3(194.18,76.06) v3(194.18,75.17) v3(194.18,74.28) v3(194.18,73.38) v3(194.55,67.35) v3(198.5,80.25) v3(198.5,79.36) v3(198.5,78.47) v3(198.5,77.58) v3(198.5,76.69) v3(198.5,75.8) v3(198.5,74.92) v3(198.5,74.03) v3(198.5,73.14)
VGA_RST#: length 22.2
  L4 w0.102: v1(161.85,75.83) 161.85,72.71 165.42,69.13 166.72,69.13 166.78,69.2 v1(168.02,69.2)
  BOTTOM w0.102: v1(161.85,75.83) 161.39,75.83 160.48,76.74 v2(159.79,76.74) 153.85,76.74 153.4,76.3 R7621.2 C7609.1 ; v1(168.02,69.2) 168.52,69.7 GPU1.AL27
VGA_SVC: length 64.8
  TOP w0.254: v1(199.62,59.77) 198.06,61.33 185.19,61.33 184.78,61.73 184.78,61.83 183.17,63.45 179.28,63.45 178.9,63.07 178.48,63.07 178.21,63.33 176.94,63.33 176.48,63.79 176.45,63.79 176.01,64.23 175.61,64.23 175.11,63.74 174.68,63.74 v1(174.6,63.66) ; R7919.1 184.77,81.98 v1(184.71,81.93)
  L3 w0.254: v1(184.71,81.93) 186.14,81.93 189.14,78.93 189.14,77.79 189.06,77.71 189.06,77.7 188.42,77.06 v1(188.42,76.97)
  L4 w0.254: v1(174.12,67.42) 179.03,72.33 179.52,72.33 179.69,72.5 189.79,72.5 190.22,72.94 190.22,74.54 188.42,76.34 v1(188.42,76.97)
  BOTTOM w0.254: v1(174.6,63.66) 174.6,63.71 174.43,63.88 R7923.1 R7939.2 R7946.1 174.43,66.57 174.82,66.95 v2(174.82,67.33) 174.73,67.42 v1(174.12,67.42) ; v1(199.62,59.77) 199.68,59.77 199.77,59.68 PR8509.1
VGA_SVD: length 69.8
  TOP w0.254: v1(199.09,58.18) 198.04,58.18 195.4,60.82 184.98,60.82 184.28,61.52 184.28,61.62 182.96,62.94 181.96,62.94 181.44,62.42 180.5,62.42 179.95,61.86 178.48,61.86 177.56,62.77 175.68,62.77 175.18,62.27 172.9,62.27 171.55,63.61 171.55,65.01 v1(172.06,65.52)
  L4 w0.254: v1(174.14,68.44) 174.65,68.95 174.65,69.43 178.31,73.09 178.36,73.09 178.64,73.37 178.64,73.47 180.09,74.92 180.09,76.28 180.34,76.54 180.34,76.94 179.76,77.52 179.76,78.32 180.24,78.79 180.24,79.73 183.27,82.76 184.5,82.76 186.57,84.82 191.64,84.82 v1(192.28,85.46)
  BOTTOM w0.254: v1(199.09,58.18) 199.09,58.17 199.36,57.9 PR8512.1 ; v1(172.06,65.52) 172.12,65.45 R7940.1 ; v1(174.14,68.44) 173.74,68.44 172.66,67.36 v2(172.66,67.19) R7944.1 172.72,66.22 R7940.1 ; R7920.1 192.28,84.88 v1(192.28,85.46) ; R7925.2 R7940.1
VGA_SVT: length 39.4
  TOP w0.254: PR8513.1 207.14,57.2 207.14,56.36 206.77,55.99 204.64,55.99 202.38,58.25 199.9,58.25 199.03,57.38 193.3,57.38 191.74,58.94 190.37,60.31 184.77,60.31 183.77,61.31 183.77,61.41 182.75,62.43 v1(182.28,62.43)
  L4 w0.254: v1(182.28,62.43) 182.27,62.44 182.27,64.77 v1(180.72,66.32)
  BOTTOM w0.254: R7924.1 R7934.2 R7945.1 177.86,66.41 178.49,66.41 v2(178.87,66.03) 179.25,66.41 180.63,66.41 v1(180.72,66.32)
VGA_VDD_RUN_FB_H: length 46
  TOP w0.254: PR8535.2 181.48,75.4 v1(181.58,75.3) ; v1(214.91,60.28) 214.5,60.69 TP8502.1 213.55,60.69 PR8534.2
  L3 w0.254: v1(189.74,73.14) 191,71.88 194.74,71.88 195.83,70.78 195.83,66.03 v1(198.75,63.1)
  L4 w0.254: v1(198.75,63.1) 199.14,62.72 202.95,62.72 204.07,61.61 213.59,61.61 v1(214.91,60.28) ; v1(181.58,75.3) 182.47,74.41 187.32,74.41 188.59,73.14 v1(189.74,73.14)
VGA_VDD_RUN_FB_L: length 50.6
  TOP w0.254: v1(180.91,77.81) 180.91,78.71 181.29,79.09 PR8531.1 ; v1(215.77,62.6) 214.76,63.61 TP8501.1 PR8530.2
  L3 w0.254: v1(197.99,62.98) 197.87,63.1 197.36,63.1 195.33,65.14 195.33,70.57 194.54,71.36 190.8,71.36 189.26,72.9 189.26,73.54 v1(189.36,73.65)
  L4 w0.254: v1(189.36,73.65) 186.39,76.61 182.11,76.61 v1(180.91,77.81) ; v1(215.77,62.6) 215.7,62.6 215.12,62.01 214.7,62.01 214.6,62.11 204.28,62.11 202.78,63.61 198.54,63.61 197.99,63.06 v1(197.99,62.98)
VGA_VSUM-_1: length 2
  TOP w0.254: v2(218.39,59.14) 218.36,59.17 PR8533.1 217.49,58.28 PR8529.2
VPP_EN_R: length 9.6
  TOP w0.127: v1(55.91,7.5) v2(56.64,6.77) 57,6.41 v1(57,2.91)
  BOTTOM w0.127: v1(55.91,7.5) 55.41,8 PC5401.1 PR5407.1 55.38,9.13 PR5405.2 ; v1(57,2.91) 55.88,4.02 PU5402.2
VR_CAP: length 6
  TOP w0.203: v1(215.14,29.59) 215.24,29.59 215.25,29.6 215.78,29.6 215.83,29.54 KBC24.18
  BOTTOM w0.254: C2418.1 218.91,27.96 217.3,29.58 v2(216.97,29.58) 215.15,29.58 v1(215.14,29.59)
VR_EN: length 200.9
  TOP w0.102: v1(195.71,48.25) 195.71,52.79 v2(199.11,56.19) 199.11,56.47 199.97,57.34 200.69,57.34 v1(200.79,57.24)
  L3 w0.102: v1(200.79,57.24) 200.79,57.41 200.66,57.54 200.66,62.77 197.69,65.75 197.69,70.95 196.77,71.87 196.77,81.67 197.13,82.03 197.13,84.72 199.44,87.03 202.26,87.03 202.97,87.74 202.97,89.77 206.4,93.2 206.4,97.71 211.05,102.36 211.05,114.23 v1(210.21,115.07)
  L4 w0.102: v1(154.01,123.26) 158.93,123.26 163.29,127.62 190.88,127.62 191.77,126.73 204.31,126.73 206.04,125 206.04,119.8 208.56,117.28 209.83,117.28 210.72,116.39 210.72,115.58 v1(210.21,115.07)
  L6 w0.102: v1(195.71,48.25) 195.22,48.25 191.59,44.61 191.59,39.57 195.22,35.94 195.22,35.48 v1(192.91,33.17)
  BOTTOM w0.102: R4002.2 192.15,9.76 191.36,10.55 191.36,15.94 190.83,16.47 190.83,25.11 190.86,25.13 190.86,29.86 190.83,29.88 190.83,30.39 190.23,30.99 189.94,30.99 189.51,31.42 189.51,32.62 190.29,33.4 192.68,33.4 v1(192.91,33.17) ; PR4630.2 150.99,120.2 150.99,121.05 152.28,122.34 153.09,122.34 v1(154.01,123.26)
VR_RDY: length 2.8
  BOTTOM w0.102: PR4670.2 152.84,119.16 152.01,120 PR4614.2 152.01,120.91 151.74,121.18 v2(151.62,121.18)
VR_SVID_ALERT#: length 98.2
  TOP w0.14: v2(149.38,120.05) 149.38,120.74 v1(149.35,120.76) PR4622.2
  L4 w0.127: v1(93.9,93.33) 94.28,93.71 94.28,102.48 95.12,103.32 95.12,106.18 v1(93.37,107.94)
  L6 w0.114: v1(149.35,120.76) 148.07,119.48 145.24,119.48 144.08,120.64 144.08,123.09 144.09,123.1 144.09,123.53 142.37,125.26 118.92,125.26 117.73,124.06 117.73,120.91 116.15,119.34 108.16,119.34 104.2,123.3 101.16,123.3 98.16,120.3 98.16,115.23 95.01,112.08 95.01,110.26 93.37,108.62 v1(93.37,107.94)
  BOTTOM w0.14: PR4666.2 v1(149.35,120.76) ; v1(93.9,93.33) 94.03,93.2 94.03,92.33 R727.2 94.58,91.51 94.92,91.17 R728.1
VR_SVID_CLK: length 96.9
  TOP w0.14: v1(150.24,120.76) 150.47,120.53 v2(150.85,120.53)
  L4 w0.127: v1(95.12,93.33) 94.79,93.66 94.79,102.27 95.63,103.11 95.63,106.54 v1(94.01,108.16)
  L6 w0.114: v1(94.01,108.16) 94.01,108.56 95.5,110.05 95.5,111.87 98.65,115.02 98.65,120.1 101.35,122.79 104.01,122.79 107.97,118.83 116.41,118.83 118.24,120.66 118.24,123.86 119.1,124.72 142.18,124.72 143.59,123.31 143.59,120.43 145.03,118.98 148.46,118.98 v1(150.24,120.76)
  BOTTOM w0.14: PR4665.1 v1(150.24,120.76) 150.19,120.81 PR4621.2 ; R732.2 95.43,93.03 v1(95.12,93.33) 95.06,93.39 R723.2
VR_SVID_DATA: length 96.9
  TOP w0.14: v2(148.13,120.1) 148.58,120.55 v1(148.58,120.73)
  L4 w0.127: v1(92.63,107.86) 92.63,107.38 93.15,106.86 93.66,106.86 94.61,105.9 94.61,103.53 93.78,102.69 93.78,94.27 93.24,93.74 v1(93.24,93.28)
  L6 w0.114: v1(92.63,107.86) 92.87,108.1 92.87,108.14 92.88,108.14 92.88,108.83 94.51,110.46 94.51,112.28 97.66,115.43 97.66,120.51 100.97,123.81 104.39,123.81 108.36,119.85 115.95,119.85 117.23,121.13 117.23,122.42 117.23,124.28 118.72,125.77 142.57,125.77 144.6,123.73 144.6,122.9 144.58,122.87 144.58,120.84 145.44,119.97 147.86,119.97 148.58,120.69 v1(148.58,120.73)
  BOTTOM w0.14: PR4623.2 148.58,121.42 v1(148.58,120.73) 148.58,120.18 PR4667.1 ; R709.2 93.57,92.95 v1(93.24,93.28)
VRAM_ID1: length 27.8
  TOP w0.102: v1(127.89,69.4) 127.9,69.42 127.91,69.42 128.05,69.56 128.35,69.56 128.6,69.81 129.92,69.81 130.2,69.53 130.2,69.04 131.4,67.84 133.67,67.84 135,69.17 137.28,69.17 137.86,68.59 143.1,68.59 143.48,68.97 144.05,68.97 144.4,68.97 145.07,69.64 v2(147.22,69.64) 151.31,69.64 R2023.2 R2024.1
  BOTTOM w0.102: v1(127.89,69.4) 127.87,69.4 127.85,69.39 127.72,69.39 127.49,69.15 CPU1.AP8
