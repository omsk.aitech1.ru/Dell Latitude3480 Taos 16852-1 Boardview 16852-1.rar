# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
WEA0#: length 50.7
  TOP w0.127: v1(164.92,108.82) 165.19,108.56 165.77,108.56 166.31,109.1 166.32,109.1 VRAM1.L3
  L4 w0.127: 163.97,110.35 164.92,109.39 v1(164.92,108.82)
  L4 w0.254: v1(170.55,87.99) 170.55,87.22 169.27,85.94 168.84,85.94 168.8,85.9 167.58,85.9 167.24,86.24 162.63,86.24 155.33,93.54 155.33,107.69 158.19,110.55 159.12,110.55 159.2,110.48 160.15,110.48 160.78,111.11 161.29,111.11 161.42,111.24 161.8,111.24 161.81,111.25 162.9,111.25 162.92,111.24 163.08,111.24 163.97,110.35
  BOTTOM w0.127: v1(164.92,108.82) 164.67,109.07 163.55,109.07 VRAM2.L3
  BOTTOM w0.14: v1(170.55,87.99) 170.55,87.99 170.14,88.4 GPU1.G25
WEA1#: length 48.2
  TOP w0.127: v1(187.97,108.98) 188.29,109.3 VRAM4.L3
  L4 w0.089: v1(181.56,87.91) 181.7,87.91 183.07,89.29 183.91,89.29 183.92,89.29 184.43,89.29 184.53,89.19 184.53,88.22 184.51,88.21 184.51,87.87 184.75,87.64 185.13,87.64 186,88.51 187.09,88.51
  L4 w0.127: 188.54,109.78 187.97,109.21 v1(187.97,108.98)
  L4 w0.254: 188.54,109.78 189.87,111.11 192.48,111.11 192.91,110.67 192.91,109.35 197.06,105.21 197.06,95.65 189.92,88.51 187.09,88.51
  BOTTOM w0.127: v1(187.97,108.98) 187.56,108.57 187.07,108.57 186.57,109.07 186.05,109.07 VRAM3.L3
  BOTTOM w0.14: v1(181.56,87.91) 181.87,87.6 GPU1.H10
WHITE_LED_BAT: length 19.4
  TOP w0.508: Q6404.C 206.25,6.08 206.82,5.51 206.82,4.18 EC6403.1 207.06,3.18 v2(209.8,3.18) 218.08,3.18 v1(219.07,4.18)
  BOTTOM w0.508: R6406.1 219.84,4.81 219.21,4.18 v1(219.07,4.18)
WIFI_RF_EN: length 217.6
  TOP w0.102: D6101.K 43.18,58.53 v2(42.42,59.29) 41.99,59.73 v1(41.91,59.73) ; v1(62.57,44.09) 62.63,44.03 109.58,44.03 117.28,51.74 R1504.2 118.04,52.04 118.04,52.26 123.19,57.41 v1(123.19,58.79) ; R1503.2 129.67,88.8 v1(129.7,88.83)
  L3 w0.102: v1(61.15,55.32) 61.12,55.32 58.9,57.54 58.9,66.68 58.14,67.44 58.14,67.47 57.34,68.27 57.34,77.16 58.2,78.03 58.2,81.41 58.51,81.71 58.58,81.71 58.62,81.67 58.98,81.67 59.23,81.92 59.23,82.96 60.96,84.69 v1(62.36,84.69)
  L4 w0.102: v1(62.57,44.09) 62.57,44.16 62.56,44.17 62.56,44.97 62.56,44.97 62.56,45.28 62.32,45.52 62.32,47.7 61.72,48.29 61.72,51.29 61.59,51.42 61.59,54.98 61.26,55.31 61.16,55.31 v1(61.15,55.32) ; v1(62.36,84.69) 62.36,84.49 62.84,84.01 68.15,84.01 69.42,82.74 83.39,82.74 88.9,88.25 95.05,88.25 102.09,95.29 106.61,95.29 110.16,91.75 118.29,91.75 119.4,92.85 124.34,92.85 127.31,89.88 127.88,89.88 128.92,88.83 v1(129.7,88.83)
  L6 w0.102: v1(61.15,55.32) 60.83,55.64 60.83,56.09 59.32,57.61 59.32,57.96 57.56,59.73 v1(41.91,59.73)
  BOTTOM w0.102: R1710.1 R1709.1 123.06,58.66 v1(123.19,58.79)
WLAN_CLKREQ_WLAN#: length 6.8
  TOP w0.14: R6112.1 33.91,55.48 AFTP5802.1 32.71,56.68 32.71,56.69 31.88,57.52 v1(31.62,57.52)
  BOTTOM w0.14: v1(31.62,57.52) 31.62,57.26 31.2,56.84 31.2,56.63 30.74,56.16 30.51,56.16 30.25,55.9 30.05,55.9 29.91,55.75 WLAN1.53
WLAN_DISABLE#1: length 8.1
  TOP w0.102: v1(38.6,54.62) 38.6,54.62 38.99,54.22 AFTP5803.1 ; D6101.A 39.93,58.02 38.88,56.97 v1(38.74,56.97)
  BOTTOM w0.102: WLAN1.56 38.2,55 38.59,54.62 v1(38.6,54.62) 38.6,54.97 39.16,55.53 39.16,56.55 v1(38.74,56.97)
WWAN_PERST#: length 6.3
  TOP w0.127: AFTP6204.1 92.99,116.06 92.61,116.44 v1(92.46,116.44) 91.83,115.82 R6215.1
  BOTTOM w0.127: v1(92.46,116.44) 92.54,116.36 95.78,116.36 95.93,116.5 WWAN1.50
WWAN_PWR_EN_D: length 5.9
  TOP w0.127: v2(90.7,103.92) 90.09,104.53 90.09,104.79 89.74,105.14 Q6201.2 88.57,105.14 88.37,105.34 88.37,106.16 88.93,106.72 R6224.1 R6212.2
WWAN_PWR_OFF#: length 5.3
  TOP w0.127: AFTP6256.1 93.54,106.52 93.54,105.91 v1(93.55,105.9) R6217.1
  BOTTOM w0.127: WWAN1.6 94.51,105.5 94.11,105.9 93.55,105.9 v1(93.55,105.9)
WWAN_RADIO_DIS#: length 33.8
  TOP w0.127: 74.49,78.76 74.98,78.27 81.08,78.27 82.44,79.63 82.44,80.83 82.55,80.95 82.55,85.76 v1(81.84,86.47) ; 74.49,78.76 73.91,78.19 73.81,78.19 73.41,77.79 U9601.16 ; 74.49,78.76 R9612.1 ; v2(84.45,98.79) 84.71,98.79 v1(85.09,99.17) 85.34,99.43 D6202.K
  L3 w0.127: v1(81.84,86.47) 81.84,88.51 83.89,90.56 83.89,97.09 85.22,98.41 85.22,99.05 v1(85.09,99.17)
WWAN_RADIO_DIS#_D: length 18.3
  TOP w0.127: v1(88.98,103.34) 88.98,103.26 88.95,103.24 88.95,101.9 88.96,101.89 88.96,100.73 88.27,100.04 D6202.A 89.46,99.43 AFTP6259.1
  BOTTOM w0.127: WWAN1.8 95.03,106 94.68,106.35 93,106.35 92.84,106.2 92.41,106.2 91.09,107.52 90.29,107.52 90.28,107.5 90.15,107.5 90.02,107.37 90.02,105.27 88.95,104.2 88.95,103.36 v1(88.98,103.34)
WWAN_RESET#: length 3.3
  TOP w0.127: v1(101.79,121.36) 101.79,120.82 TC6204.1
  BOTTOM w0.127: v1(101.79,121.36) 101.89,121.36 102.5,120.75 WWAN1.67
XCLK_BIASREF: length 6.7
  BOTTOM w0.152: 109.35,87.87 109.35,87.11 108.92,86.68 108.92,84.64 108.26,83.99 CPU1.E42
  BOTTOM w0.508: R1803.1 v2(109.16,89.06) 109.16,88.06 109.35,87.87
XDP_BPM0: length 58.6
  TOP w0.14: v1(65.71,98.42) 65.71,98.31 65.47,98.07 65.47,96.73 XDP1.21
  L3 w0.127: v1(75.06,104.89) 75.06,104.38 72.64,101.97 72.64,100.15 69.08,96.58 67.49,96.58 65.81,98.26 65.81,98.32 v1(65.71,98.42)
  BOTTOM w0.114: CPU1.C55 100.59,85.87
  BOTTOM w0.14: v1(75.06,104.89) 75.12,104.89 75.57,105.34 76.19,105.34 78.16,105.34 79.69,105.34 79.97,105.06 86.06,105.06 86.87,104.25 86.87,103.49 87.93,102.43 94.93,102.43 97.53,99.83 97.53,99.54 98.67,98.4 99.23,98.4 101.11,96.52 v2(101.11,94.68) 101.11,93.16 101.52,92.75 101.52,88.56 100.67,87.71 100.67,85.95 100.59,85.87
XDP_BPM1: length 60.5
  TOP w0.14: v1(65.02,98.38) 65.02,98.38 65.02,97.05 65,97.02 XDP1.23
  L3 w0.127: v1(65.02,98.38) 65.02,98.79 65.41,99.17 67.34,99.17 67.53,98.99 67.53,98.23 67.79,97.97 68.89,97.97 72.14,101.21 72.14,102.22 74.3,104.38 v1(74.3,104.89)
  BOTTOM w0.102: 101.78,88.76 101.78,88.5 100.88,87.6 100.88,85.61 100.71,85.44 100.71,85.21 CPU1.D55
  BOTTOM w0.14: v1(74.3,104.89) 74.93,105.52 74.93,105.53 75.18,105.78 79.88,105.78 80.16,105.5 86.38,105.5 87.31,104.57 87.31,103.67 88.11,102.88 95.11,102.88 98.61,99.38 98.61,99.09 98.85,98.85 99.41,98.85 101.78,96.48 v2(101.78,95.82) 101.78,88.76
XDP_BPM2: length 4.1
  TOP w0.14: v1(103,87.87) 103,87.56 TP9901.1
  BOTTOM w0.114: 102.87,87.87 v1(103,87.87)
  BOTTOM w0.14: 102.87,87.87 102.71,88.03 101.93,88.03 101.38,87.47 101.38,87.13 101.44,87.07 101.44,86.35 CPU1.B54
XDP_BPM3: length 5.2
  BOTTOM w0.14: TP9902.1 99.81,89.56 99.81,86.95 99.74,86.88 99.74,85.7 CPU1.C56
XDP_DBRESET#: length 11.9
  BOTTOM w0.114: EC1706.1 132.99,94.04 133.6,93.43 133.6,92.87 133.2,92.47 v2(133.2,91.88) 133.85,91.23 R1701.2 134.12,91.22 R9925.2 133.69,89.44 132.79,89.44 131.97,88.62 131.97,88.53 130.64,87.2 130.64,86.59 130.11,86.06 CPU1.B5
XDP_DBRESET_XDP#: length 90.8
  TOP w0.114: XDP1.48 59,88.64 C9905.1 v2(57.78,88.5) 57.81,88.48 57.81,87.15 v1(57.95,87.01)
  L4 w0.114: v1(57.95,87.01) 58.11,87.16 60.85,87.16 61.79,86.22 65.58,86.22 66.48,85.32 69.17,85.32 70.5,83.99 78.74,83.99 84.29,89.54 89.78,89.54 90.8,90.56 95.4,90.56 101.38,96.54 106.66,96.54 106.66,96.55 107.13,96.55 110.67,93 117.26,93 118.36,94.1 118.66,94.1 118.66,94.1 124.86,94.1 125.05,93.91 125.05,93.91 125.47,93.49 126.74,93.49 128.46,91.77 131.97,91.77 v1(133.17,90.56)
  BOTTOM w0.114: R9925.1 133.24,90.5 v1(133.17,90.56)
XDP_PRDY#: length 56.7
  TOP w0.114: v1(71.18,95.08) 71.18,95.01 70.72,94.54 70.35,94.54 70.1,94.8 70.1,94.96 69.8,95.26 69.77,95.26 69.66,95.37 69.66,95.4 69.5,95.56 XDP1.5
  L3 w0.114: v1(71.18,95.08) 71.18,95.74 74.04,98.59 74.04,101.44 74.54,101.94 74.54,101.95 76.33,103.73 v1(76.33,104.84)
  BOTTOM w0.089: CPU1.D56 100.03,84.94 100.31,85.22 100.31,85.61 100.3,85.62 100.3,86.31 100.46,86.47 100.46,87.82 101.3,88.65
  BOTTOM w0.114: v1(76.33,104.84) 76.4,104.91 79.48,104.91 79.92,104.47 81.55,104.47 81.85,104.17 82.89,104.17 82.93,104.21 82.93,104.25 83.19,104.51 85.34,104.51 85.47,104.38 86.11,104.38 86.36,104.13 86.36,103.36 87.72,102 94.75,102 97.1,99.65 97.1,99.36 98.49,97.97 99.05,97.97 100.68,96.34 v2(100.68,93.3) 100.68,92.93 101.3,92.31 101.3,88.65
XDP_PREQ#: length 58.2
  TOP w0.114: XDP1.3 70,95.52 v1(70.54,94.98)
  BOTTOM w0.089: 97.13,88.1 97.28,87.95 97.28,87.17 97.11,87 97.11,86.55 97.14,86.48 97.15,86.46 97.15,85.94 97.21,85.88 97.21,85.18 97.55,84.84 CPU1.D61
  BOTTOM w0.114: v1(70.54,94.98) 69.88,94.98 68.73,93.83 67.98,93.83 67.18,94.63 67.18,95.19 66.25,96.12 64.64,96.12 v2(64.39,96.38) 64.39,97.19 63.47,98.11 63.47,98.74 63.71,98.97 65.38,98.97 66.26,99.85 76.77,99.85 76.78,99.86 81.84,99.86 82.35,99.35 82.35,99.35 83.36,98.33 83.37,98.33 85.47,96.23 93.64,96.23 94.48,95.39 94.61,95.39 95.39,94.62 95.42,94.62 97.13,92.91 97.13,88.1
XDP_PRSNT_PIN1: length 4.8
  TOP w0.114: XDP1.1 70.5,97.89 69.24,99.15 v2(68.78,99.15) R9902.2
XDP_SMBCLK: length 3
  TOP w0.14: R9912.2 57.12,98.59 57.5,98.22 XDP1.53
XDP_SMBDAT: length 2.9
  TOP w0.14: R9911.2 57.96,99.51 57.96,96.73 XDP1.51
XDP_SPI0_IO2: length 158.4
  TOP w0.114: v1(55.65,89.09) 56,89.43 XDP1.60
  L4 w0.114: v1(62.1,104.13) 62.41,103.81 64.03,103.81 64.05,103.82 65.68,105.45 91.22,105.45 91.92,106.15 91.92,106.64 91.65,106.91 91.65,106.92 91.39,107.18 91.39,107.61 91.92,108.14 91.92,108.68 92.2,108.95 94.39,108.95 98.25,105.08 101.02,105.08 105.67,100.44 105.79,100.44 106.91,99.32 108.8,99.32 109.97,98.15 110.61,97.51 110.61,96 111.53,95.08 116.4,95.08 117.49,96.17 117.49,96.17 118.07,96.75 127.25,96.75 127.83,96.17 128.2,96.17 128.43,96.4 139.55,96.4 143.01,92.94 143.01,88.78 141.17,86.94 141.17,84.24 144,81.41 144,79.74 141.79,77.53 141.79,71.61 140.14,69.96 140.14,65.77 142.56,63.35 142.56,61.26 142.75,61.07 142.75,61 v1(142.8,60.95)
  BOTTOM w0.114: R9929.2 55.52,89.22 v1(55.65,89.09) 55.94,89.37 55.94,90.8 R9931.1 56.5,91.47 56.5,93.69 56.69,93.88 56.69,94.78 56.76,94.85 56.76,96.32 57.18,96.73 57.18,98.4 56.69,98.89 56.69,101.36 58.94,103.62 61.59,103.62 v1(62.1,104.13) ; R1827.1 144.72,63.74 v2(145.62,63.74) 145.62,63.13 143.43,60.95 v1(142.8,60.95)
XDP_TCK_JTAGX: length 58.7
  TOP w0.114: v1(55.63,101.74) 55.35,101.46 R9915.2 ; R417.1 80.3,103.3 v1(80.59,103.01)
  L4 w0.114: v1(62.56,102.5) 62.53,102.47 56.36,102.47 v1(55.63,101.74)
  BOTTOM w0.089: CPU1.A59 98.58,86.81 98.58,87.72 99.03,88.18
  BOTTOM w0.114: 99.03,88.18 99.15,88.3 99.15,94.14 v2(96.82,96.47) 95.58,97.72 95.44,97.72 95.17,97.99 95.17,99.52 94.19,100.49 86.98,100.49 85.83,101.65 84.16,101.65 83.56,102.25 81.49,102.25 80.91,102.83 80.77,102.83 v1(80.59,103.01) 78.97,103.01 78.8,103.18 72.86,103.18 72.16,103.88 65.16,103.88 64.24,102.96 63.04,102.96 62.59,102.5 v1(62.56,102.5)
XDP_TCLK: length 63.9
  TOP w0.114: R9915.1 54.94,99.74 54.94,98.77 55.5,98.21 56.13,98.21 56.5,97.84 XDP1.57 56.5,95.38 56.74,95.13 58.81,95.13 58.84,95.11 60.2,95.11 v1(60.96,94.35) ; R406.1 82.42,100.46 83.06,99.83 v1(83.06,99.3)
  BOTTOM w0.089: CPU1.B61 97.34,86.27 97.34,86.49 97.29,86.59 97.29,86.88 97.46,87.05 97.46,88.06 97.41,88.11
  BOTTOM w0.114: v1(60.96,94.35) 60.86,94.44 60.86,95.16 62.23,96.53 v2(62.23,97.39) 62.23,98.37 63.39,99.53 65.25,99.53 66.04,100.32 72.85,100.32 73.49,100.96 77.31,100.96 77.9,100.37 81.99,100.37 v1(83.06,99.3) 85.67,96.68 93.83,96.68 94.67,95.85 94.8,95.85 97.41,93.24 97.41,88.11
XDP_TCLK1: length 4.6
  TOP w0.114: R9914.1 56.22,99.55 55.63,99.55 v2(55.32,99.25) 55.91,98.66 56.36,98.66 57,98.03 XDP1.55
XDP_TDI: length 75.7
  TOP w0.114: v1(57.89,93.11) 57.89,93.01 57.45,92.57 57.45,92.43 57.18,92.16 57.18,92.09 57,91.91 XDP1.56 56.97,89.42 56.63,89.09 v1(56.63,88.97) ; v1(78.49,102.6) 78.42,102.66 R422.1
  BOTTOM w0.089: 98.26,88.63 98.22,88.59 98.22,86.14 98.4,85.96 98.4,85.61 98.11,85.33 CPU1.D60
  BOTTOM w0.114: v1(57.89,93.11) v2(58.48,93.71) 58.88,94.11 58.88,95.32 60.38,96.81 60.38,98.21 60.38,98.21 60.38,99.22 60.9,99.73 60.9,100.3 62.64,102.04 62.79,102.04 63.25,102.5 64.44,102.5 65.35,103.41 65.51,103.41 65.51,103.42 71.97,103.42 72.67,102.72 78.37,102.72 v1(78.49,102.6) 78.71,102.6 78.94,102.37 80.72,102.37 81.3,101.79 83.37,101.79 84.63,100.54 85.48,100.54 87.8,98.22 94.29,98.22 95.25,97.26 95.39,97.26 98.79,93.86 98.79,89.16 98.26,88.63 ; R9916.1 57.64,96.17 57.64,94.38 56.81,93.56 56.81,89.15 v1(56.63,88.97)
XDP_TDO_CPU: length 57.2
  TOP w0.114: R423.1 83.31,100.33 83.69,99.95 v1(83.69,99.3)
  BOTTOM w0.089: CPU1.A61 97.67,86.83 97.67,88.15
  BOTTOM w0.114: R9919.1 59.31,91.74 v2(59.31,92.52) 59.11,92.72 59.11,93.3 59.36,93.55 59.57,93.55 60.41,94.39 60.41,95.35 61.77,96.72 61.77,98.54 61.77,98.71 63.04,99.98 65.05,99.98 65.86,100.8 72.66,100.8 72.69,100.82 72.69,100.82 73.29,101.41 77.51,101.41 78.1,100.83 82.17,100.83 83.69,99.31 v1(83.69,99.3) 83.79,99.3 85.94,97.14 94.02,97.14 94.85,96.31 94.99,96.31 97.66,93.64 97.66,88.17 97.67,88.15
XDP_TMS: length 75.8
  TOP w0.114: R421.1 84.59,100.37 84.61,100.37 84.96,100.01 v1(84.96,99.81) ; v1(57.26,89.07) 57.28,89.05 57.28,88.55 57.07,88.35 56.36,88.35 56.16,88.55 56.16,89.14 56.5,89.48 XDP1.58 56.5,92.22 56.54,92.26 56.54,92.3 57.45,93.21 57.45,93.3 57.54,93.38 57.54,94 57.65,94.11 59.06,94.11 v1(59.32,94.37)
  BOTTOM w0.089: CPU1.C60 98.11,85.91 98.04,85.98 98.04,88.71 98.19,88.85 98.22,88.85 98.59,89.23 98.59,89.27
  BOTTOM w0.114: v1(57.26,89.07) 57.13,89.2 57.13,93.43 57.95,94.25 57.95,95.59 R9917.1 ; v1(59.32,94.37) 59.77,94.82 59.77,95.33 59.77,95.34 59.77,95.62 59.77,95.62 59.77,95.65 61.11,96.99 61.11,98.99 62.76,100.65 64.8,100.65 66.66,102.51 71.14,102.51 71.38,102.27 77.6,102.27 78.4,101.46 83.25,101.46 84.91,99.81 v1(84.96,99.81) 85.53,99.81 87.22,98.11 v2(87.26,98.11) 87.46,97.9 94.16,97.9 95.12,96.94 95.26,96.94 98.59,93.61 98.59,89.27
XDP_TRST#: length 67.5
  TOP w0.114: v1(84.43,99.45) 84.43,99.42 83.87,98.86 82.85,98.86 81.53,100.17 R402.1 ; v1(57.89,92.39) 57.86,92.39 57.5,92.02 XDP1.54
  L3 w0.114: v1(98.06,89.24) 98.75,88.54 v1(98.75,88.54)
  BOTTOM w0.089: v1(98.75,88.54) 98.75,88.27 98.4,87.92 98.4,86.34 CPU1.B59 ; v1(98.06,89.24) 97.86,89.05 97.86,86.02 97.69,85.75 97.69,85.55 CPU1.C61
  BOTTOM w0.114: v1(57.89,92.39) 58.17,92.67 58.17,92.77 58.79,93.39 58.79,93.43 59.23,93.87 59.44,93.87 60.09,94.52 60.09,95.48 61.44,96.84 61.44,98.87 62.89,100.32 64.92,100.32 65.76,101.15 72.57,101.15 73.15,101.73 77.65,101.73 78.24,101.15 82.73,101.15 v1(84.43,99.45) 84.43,99.2 85.73,97.89 v2(85.93,97.89) 86.33,97.5 94.11,97.5 94.99,96.63 95.12,96.63 98.06,93.69 v1(98.06,89.24)
XO_IN: length 7.4
  TOP w0.127: v1(172.08,76.1) 172.08,76.24 171.89,76.43 v2(170.59,76.43) 170.59,76.43 170.38,76.64 168.76,76.64 168.35,77.05 168.35,78.14 168.74,78.53 RN7904.2
  BOTTOM w0.127: GPU1.AC22 172.58,75.6 v1(172.08,76.1)
XO_IN2: length 9.3
  TOP w0.102: RN7904.1 v2(168.09,76.67) 168.09,76.38 168.82,75.65 172.2,75.65 172.72,76.17 172.72,76.9 v1(172.74,76.91)
  BOTTOM w0.102: GPU1.AB22 172.72,76.6 172.72,76.9 v1(172.74,76.91)
XTAL1: length 13.6
  TOP w0.114: KBC24.123 213.11,20.3 213.23,20.18 213.23,18.4 211.71,16.88 210.49,16.88 210.28,17.09 209.19,17.09 v2(209.17,17.1) 209.15,17.09 207.7,17.09 206.81,16.19 206.81,14.96 C2425.2 206.69,13.03 X2401.1
XTAL2: length 11.6
  TOP w0.114: R2458.2 R2428.1 207.58,16.18 207.92,16.51 210.04,16.51 v2(210.19,16.37) 210.24,16.32 211.46,16.32 211.48,16.29 211.94,16.29 213.79,18.15 213.79,20.08 213.91,20.2 KBC24.125
XTAL24_IN: length 10.1
  BOTTOM w0.114: 112.71,87.21 112.71,85.93 112.53,85.75 112.33,85.75 112.12,85.54 112.12,84.68 111.43,83.99 CPU1.E37
  BOTTOM w0.14: 112.71,87.21 112.71,89.46 v2(112.52,89.65) 112.33,89.84 R1802.1 R1810.1
XTAL24_IN_R: length 5.9
  BOTTOM w0.14: X1801.1 112.57,97.98 113.5,97.05 113.5,95.64 113.27,95.41 C1801.2 113.22,94.83 v2(113.22,93.86) R1810.2
XTAL24_OUT: length 14.8
  BOTTOM w0.114: CPU1.E35 112.25,83.99 112.45,84.19 112.45,84.37 112.71,84.64 112.71,84.89 112.68,84.92 112.68,85.21 112.91,85.44 113.1,85.44 113.28,85.62 113.28,85.87 113.11,86.04 113.11,86.51
  BOTTOM w0.14: 113.11,86.51 113.02,86.59 113.02,89.07 113.14,89.19 113.14,90.78 v2(113.16,90.79) 113.16,91.87 R1802.2 113.79,91.93 114.43,92.57 114.43,93.71 114.13,94 C1802.2 114.13,95.89 X1801.3
XTAL_KBC_2: length 2.8
  TOP w0.114: R2458.1 C2424.2 209.36,13.03 X2401.2
XTL_27M_X1_VGA: length 9.6
  BOTTOM w0.114: X7901.1 159.03,69.09 C7901.1 161.32,69.09 R7901.1 161.48,69.11 161.75,68.84 162.87,68.84 v2(163.04,69.02) 163.16,68.9 166.82,68.9 167.72,69.8 GPU1.AM28
XTL_27M_X2_VGA: length 14.1
  BOTTOM w0.114: GPU1.AK28 167.72,70.77 168.08,70.41 168.08,69.85 166.89,68.66 163.42,68.66 162.81,68.06 v2(162.26,68.06) 161.51,68.06 R7901.2 160.55,68.22 C7903.1 160.36,68.27 159.83,67.74 159.83,66.87 159.53,66.58 158.38,66.58 157.97,66.99 X7901.3
ZVM#: length 2.3
  TOP w0.102: v1(99.51,68.81) 99.46,68.81 99.02,68.37 99.02,67.99 99.01,67.98 TP616.1
  BOTTOM w0.102: v1(99.51,68.81) 99.53,68.81 99.64,68.69 99.82,68.69 CPU1.AR56

## Copper pours and planes (outline as drawn)
5V_HDD_S0 on TOP: 262.38,17.97 262.36,17.99 262.28,17.99 260.83,19.44 260.02,19.44 259.84,19.62 259.84,23.86 259.46,24.24 259.46,25.51 259.71,25.77 261.11,25.77 261.87,25 261.87,24.01 263.4,22.49 263.4,20.25 264.36,19.29 264.36,18.1 264.24,17.97 ; 4 cut-outs
5V_HDD_S0 on BOTTOM: 262.41,17.97 262.28,18.1 262.28,18.6 262.46,18.78 262.46,20.15 262.51,20.2 264.24,20.2 264.39,20.05 264.39,18.78 264.46,18.7 264.46,17.99 264.44,17.97
5V_S0 on TOP: 257.63,26.12 257.58,26.17 257.58,28.28 258.19,28.89 259.31,28.89 259.66,28.53 260.81,28.53 261.26,28.08 261.26,26.3 261.09,26.12 ; 4 cut-outs
5V_S0 on TOP: 66.29,45.76 66.19,45.86 66.19,46.54 65.89,46.85 65.89,49.87 66.07,50.05 66.8,50.05 67.59,49.26 67.59,46.04 67.31,45.76 ; 3 cut-outs
5V_S0 on TOP: 57.02,49.9 56.9,50.02 56.9,50.53 56.39,51.04 55.22,51.04 55.14,51.12 55.14,51.98 55.4,52.23 55.4,53.53 55.45,53.58 56.26,53.58 56.36,53.68 57.86,53.68 58.04,53.5 58.04,52.13 57.91,52 57.91,50.02 57.78,49.9 ; 1 cut-out
5V_S0 on TOP: 29.84,19.29 29.21,19.92 28.07,19.92 27.81,20.18 27.81,22.34 28.19,22.72 30.48,22.72 30.73,22.46 30.73,21.58 31.62,20.69 31.62,19.42 31.5,19.29 ; 2 cut-outs
5V_S0 on BOTTOM: 190.37,54.21 189.23,55.36 189.23,57.21 189.84,57.82 191.26,57.82 191.52,57.57 191.52,55.64 191.87,55.28 192.84,55.28 193.55,54.57 193.55,54.21
5V_S0 on L2VCC: 158.14,41.43 69.42,41.45 65.85,45.02 65.85,50.1 66.04,50.29 66.72,50.29 72.39,44.62 72.55,44.62 155.07,44.63 155.15,44.63 171.4,60.88 183.56,60.88 184.96,59.48 189.53,59.48 191.58,57.44 191.58,23.02 199.18,15.42 202.86,15.42 204.79,13.37 204.79,11.84 205.53,11.1 217.22,11.1 217.74,10.57 217.74,6.67 217.35,6.27 204.93,6.27 199.09,12.11 196.55,12.11 182.31,26.48 182.31,50.1 177.23,55.18 177.23,56.3 176.66,56.87 173.58,56.87
5V_S0 on L3: 235.28,8.98 238.3,8.98 238.71,8.57 238.71,7.94 237.21,6.44 235.81,6.44 235.79,6.46 235.76,6.46 234.54,5.24 227.28,5.24 223.98,8.54 217.09,8.54 216.18,9.46 216.18,11.52 216.38,11.72 225.91,11.72 227.03,10.6 227.03,9.15 228.52,7.66 233.96,7.66
5V_S0 on L4: 259.44,28.03 259.87,28.03 260.93,26.96 263.45,26.96 264.21,26.2 264.21,21.73 262.97,20.48 261.54,20.48 261.49,20.53 250.65,20.53 248.51,18.4 248.51,13.42 245.8,10.7 241.94,10.7 241.94,10.68 237.36,6.11 235.25,6.11 234.11,7.25 234.11,9.05 234.34,9.28 236.6,9.28 236.83,9.51 236.83,10.81 238.81,12.79 241.38,12.79 241.78,13.19 241.78,13.93 243.18,15.33 243.84,15.33 245.36,16.85 245.36,20.2 249.2,24.04 257.15,24.04 257.73,24.62 257.73,27.67 258.27,28.2 259.05,28.2 259.25,28.01 259.42,28.01
5V_S0 on L6: 58.33,48.59 58.33,41.25 56.03,38.95 53.44,38.95 51.65,37.16 51.65,36.41 49.53,34.29 49.53,31.28 48.59,30.34 47.42,30.34 45.24,28.15 45.24,27.14 45.03,26.93 43.46,26.93 42.55,26.02 42.55,25.39 42.15,24.99 39.38,24.99 38.96,24.57 38.96,21.78 38.95,21.77 38.95,21.31 38.43,20.79 31.55,20.79 30.84,21.5 30.84,22.57 30.76,22.64 29.84,22.64 29.26,22.06 29.26,20.28 30.45,19.09 31.17,19.09 31.46,18.79 39.31,18.79 41.15,20.64 41.15,22.46 41.78,23.1 44.07,23.1 44.58,23.61 46.28,23.61 52.6,29.93 52.6,30.59 53.48,31.47 53.48,35.56 54.41,36.48 57.35,36.48 60.81,39.94 60.81,47.38 60.91,47.48 66.55,47.48 66.67,47.61 66.67,50.02 66.52,50.18 65.94,50.18 64.72,51.39 64.73,51.41 64.73,52.35 64.14,52.94 60.2,52.94 59.44,53.71 56.77,53.71 56.26,53.2 56.26,50.66
5V_S5 on TOP: 45.21,21.19 45.06,21.35 45.06,23.76 44.83,23.99 44.07,23.99 43.81,24.24 43.81,26.91 44.2,26.91 44.32,26.78 44.32,25.77 44.45,25.64 46.1,25.64 47.62,24.12 47.62,21.83 46.99,21.19 ; 3 cut-outs
5V_S5 on TOP: 105.16,1.76 104.39,2.53 104.39,3.29 105.16,4.05 106.93,4.05 107.95,3.03 118.11,3.03 121.16,6.08 126.11,6.08 126.62,5.57 126.62,4.18 124.21,1.76
5V_S5 on TOP: 23.88,57.52 23.75,57.64 23.75,59.42 25.02,60.69 25.91,60.69 26.16,60.44 26.16,57.64 26.04,57.52
5V_S5 on TOP: 27.56,52.69 27.43,52.82 27.43,55.61 27.56,55.74 28.45,55.74 29.46,54.72 29.46,52.82 29.34,52.69
5V_S5 on TOP: 56.64,54.72 56.52,54.85 55.42,54.85 55.4,54.87 55.4,57.92 55.78,58.3 58.34,58.3 58.55,58.1 58.55,54.82 58.45,54.72 ; 2 cut-outs
5V_S5 on TOP: 25.22,25.74 24.38,26.58 24.38,28.66 24.18,28.86 24.18,29.37 24.26,29.45 30.68,29.45 30.76,29.37 30.76,26.02 30.48,25.74
5V_S5 on BOTTOM: 18.41,33.39 18.29,33.51 18.29,34.78 18.92,35.42 19.18,35.42 19.56,35.8 20.95,35.8 21.08,35.67 21.08,34.4 20.95,34.28 19.68,34.28 19.3,33.89 19.3,33.51 19.18,33.39 ; 1 cut-out
5V_S5 on BOTTOM: 275.74,25.08 275.49,25.33 275.49,25.82 275.44,25.87 274.62,25.87 274.45,26.05 274.45,26.78 274.57,26.91 277.01,26.91 277.14,26.78 277.14,25.23 276.99,25.08 ; 1 cut-out
5V_S5 on BOTTOM: 51.94,5.45 51.82,5.57 51.82,8.24 51.94,8.37 54.74,8.37 54.99,8.11 54.99,7.73 55.75,6.97 56.39,6.97 56.52,6.84 56.52,6.34 56.39,6.21 53.47,6.21 52.7,5.45 ; 2 cut-outs
5V_S5 on BOTTOM: 27.56,54.47 27.43,54.6 27.43,55.61 27.05,55.99 27.05,56.37 27.18,56.5 28.07,56.5 28.19,56.37 28.19,54.6 28.07,54.47 ; 1 cut-out
5V_S5 on L2VCC: 122.49,2.33 122.49,6.51 123.4,7.41 125.17,7.41 126.82,9.07 142.57,9.07 144.35,10.84 162.13,10.84 163.02,11.73 196.47,11.73 196.55,11.73 198.93,11.73 204.77,5.89 232.62,5.89 239.73,13 243.28,13 251.9,21.62 251.9,23.91 252.17,24.18 255.45,24.18 255.71,23.91 255.71,20.51 245.54,10.34 241.86,10.34 234.24,2.72 202.77,2.72 196.93,8.56 190.17,8.56 189.15,7.54 146.23,7.54 142.42,3.73 136.19,3.73 134.8,2.33
5V_S5 on L3: 25.65,44.28 25.65,31.35 28.07,28.94 28.07,25.39 27.81,25.13 22.23,25.13 20.83,26.53 20.83,31.23 19.3,32.75 19.3,39.1 16.64,41.77 16.64,50.53 19.94,53.83 25.15,53.83 27.81,56.5 35.71,56.5 36.75,55.46 36.75,51.06 36.55,50.86 31.85,50.86 31.45,50.45 31.45,50.07
5V_S5 on L4: 30.91,52.89 30.1,52.89 29.29,53.71 29.29,54.93 28.75,55.46 27.64,55.46 26.9,54.72 26.9,51.93 27.71,51.12 33.4,51.12 34.32,52.03 34.32,53.81 33.76,54.37 32.38,54.37
5V_S5 on L4: 25.48,28.79 28.42,28.79 28.96,28.26 28.96,23.3 29.64,22.62 29.64,21.07 30.58,20.13 33.07,20.13 33.15,20.05 37.72,20.05 38.48,20.81 38.48,23.99 39.5,25 42.42,25 42.8,25.39 42.8,26.66 42.93,26.78 46.1,26.78 46.61,26.27 46.61,25.13 45.21,23.73 43.43,23.73 43.42,23.75 42.56,23.75 42.55,23.76 41.4,23.76 39.88,22.24 39.88,10.04 41.11,8.81 43.85,8.81 44.86,7.81 48.03,7.81 49.48,6.36 51.89,6.36 53.06,7.53 56.79,7.53 57.96,6.36 84.4,6.36 84.96,5.8 103.81,5.8 104.55,6.54 114.4,6.54 115.29,5.65 119.81,5.65 119.81,5.67 120.68,6.54 127.79,6.54 128.17,6.16 128.17,3.95 128.14,3.92 128.14,2.78 127.64,2.27 84.51,2.27 83.95,2.83 56.49,2.83 55.33,3.99 40.27,3.99 36.45,7.81 34.8,7.81 34.01,8.6 34.01,10.25 29.31,14.95 29.31,15.99 27.18,18.12 27.18,20.69 26.92,20.94 26.9,20.94 26.9,22.64 26.21,23.33 26.21,25.11 26.24,25.13 26.24,26.3 25.22,27.32 25.22,28.53
5V_S5 on L6: 277.72,27.14 266.14,27.14 265.21,26.21 253.99,26.21 251.23,23.45 251.23,21.68 251.54,21.37 255.47,21.37 256.06,21.96 270.48,21.96 273.3,24.78 276.78,24.78 276.81,24.75 277.72,24.75 277.95,24.98 277.95,26.91
5V_S5 on L6: 29.21,20.56 30.52,19.25 32.22,19.25 32.91,18.57 32.91,16.86 36.07,13.7 36.07,11.29 38.73,8.62 41.53,8.62 42.16,7.99 42.16,5.19 41.78,4.81 38.35,4.81 33.78,9.38 33.78,12.43 32.51,13.7 32.51,14.46 27.43,19.54 27.43,22.97 27.18,23.23 27.18,24.75 25.15,26.78 25.15,28.81 22.86,31.1 22.86,36.43 21.46,37.83 21.46,47.23 22.03,47.8 24.07,47.8 25.46,49.2 25.46,50.09 27.43,52.06 31.75,52.06 32,52.31 32.51,52.31 37.21,57.01 39.17,57.01 41.55,59.4 55.91,59.4 57.66,57.64 57.66,54.34 57.15,53.83 56.64,53.83 56.13,53.33 56.13,51.29 54.48,49.64 49.91,49.64 48.01,51.55 39.5,51.55 35.18,47.23 29.46,47.23 29.21,46.98 29.21,46.09 26.54,43.42 26.54,41.51 27.18,40.88 27.18,33.01 30.61,29.58 30.61,27.42 30.1,26.91 30.1,23.48 29.21,22.59
+5V_PVDD on TOP: 35.94,8.49 35.69,8.75 33.27,8.75 33.17,8.85 30.51,8.85 29.81,9.55 29.68,9.55 28.19,11.03 26.49,11.03 26.44,11.08 26.44,11.26 26.49,11.31 28.8,11.31 29.82,10.3 30.66,10.3 31.47,9.48 34.11,9.48 34.19,9.56 36.53,9.56 36.7,9.38 36.7,8.62 36.58,8.49
+5V_PVDD on TOP: 26.47,13.12 26.44,13.14 26.44,13.27 26.57,13.4 27.58,13.4 27.71,13.52 27.71,14.49 28.94,15.72 28.94,16.89 28.57,17.26 28.57,18.15 28.32,18.4 27.94,18.4 27.81,18.53 27.81,19.29 27.94,19.42 29.34,19.42 29.72,19.04 31.24,19.04 31.75,18.53 31.75,17.38 28.32,13.96 28.32,13.62 27.81,13.12 ; 3 cut-outs
+5V_PVDD on L3: 31.7,16.6 31.95,16.34 31.95,13.27 35.56,9.66 35.89,9.66 36.42,9.13 36.42,8.47 35.28,7.33 33.45,7.33 31.57,9.21 30.78,9.21 29.59,10.4 29.59,16.37 29.82,16.6
+V1.00A_SIP on TOP: 133.48,80.66 133.35,80.78 133.35,81.44 133.81,81.9 135.51,81.9 139.87,86.26 140.35,86.26 143,88.91 144.81,88.91 144.91,88.81 144.91,87.95 144.6,87.64 144.6,86.78 142.88,86.78 141.76,85.66 141.76,83.53 138.89,80.66 ; 2 cut-outs
+V1.00A_SIP on TOP: 117.47,71.13 117.12,71.49 117.12,72.02 117.75,72.65 117.75,74.26 117.88,74.39 117.88,76.89 118.66,77.68 119.2,77.68 119.2,77.29 119.37,77.12 120.6,77.12 120.73,77 120.73,75.6 120.65,75.52 120.12,75.52 119.98,75.66 119.98,76.05 119.79,76.24 119.42,76.24 119.19,76.01 119.19,75.68 118.98,75.46 118.98,75.02 118.66,74.69 118.66,74.37 119.18,73.84 119.18,73.14 120.5,71.82 120.5,71.54 120.29,71.33 119.43,71.33 119.23,71.13 ; 1 cut-out
+V1.00A_SIP on BOTTOM: 122.39,75.19 122.34,75.24 120.13,75.24 119.96,75.41 119.96,75.97 120.09,76.11 120.37,76.11 120.5,75.98 121.28,75.98 121.78,76.48 122,76.48 122.14,76.34 122.14,76.19 122.76,75.57 122.76,75.31 122.64,75.19
+V1.00A_SIP on L2VCC: 118.32,75.23 117.92,75.63 117.92,80.17 119.32,81.57 119.32,83.85 123.78,88.31 124.25,88.31 124.9,87.66 124.9,87.31 122.62,85.03 122.62,82.33 123.62,81.33 132.29,81.33 133.17,82.22 133.65,82.22 134.67,81.2 133.4,79.93 122.6,79.93 121.86,79.19 121.86,78.53 120.06,78.53 119.57,78.04 119.57,77 120.59,75.98 120.59,75.5 120.32,75.23
+V1.00U_CPU on TOP: 124.49,78.62 123.67,79.44 123.62,79.44 123.04,80.02 123.04,80.76 122.35,81.44 120.5,81.44 120.5,81.42 120.07,80.99 119.51,80.99 119.43,81.06 119.43,81.52 119.53,81.62 120.02,81.62 120.22,81.82 120.22,81.85 120.5,82.13 122.58,82.13 122.78,81.93 123.27,81.93 123.6,81.6 123.6,81.54 123.8,81.54 124.13,81.21 124.13,80.25 124.26,80.12 129.67,80.12 130.05,80.5 130.05,80.99 130.02,81.01 130.02,81.09 129.79,81.32 129.79,81.65 130.76,82.61 130.76,87.95 131.44,88.63 131.44,88.89 132.08,89.52 132.33,89.52 132.68,89.86 132.75,89.86 132.77,89.88 132.77,91.43 132.08,92.11 132.08,93.38 132.11,93.41 132.12,93.41 132.78,94.07 132.78,94.08 134.11,95.41 141.83,95.41 144.68,92.57 144.68,92.39 144.48,92.19 143.18,92.19 140.74,94.63 135.03,94.63 135,94.65 134.67,94.65 133.77,93.75 133.77,92.86 134.11,92.52 134.11,89.57 133.81,89.27 133.22,89.27 132.72,88.76 132.41,88.76 131.47,87.82 131.47,82.36 131.27,82.15 131.27,81.19 130.66,80.58 130.66,79.51 129.77,78.62 ; 2 cut-outs
+V1.00U_CPU on BOTTOM: 142.37,91.4 142.21,91.55 142.21,93.48 142.29,93.56 144.4,93.56 144.86,93.1 144.86,92.39 143.87,91.4
+V1.00U_CPU_LS on BOTTOM: 143.51,86.85 141.99,88.38 141.99,89.9 142.11,90.03 144.02,90.03 144.15,89.9 144.15,89.14 144.65,88.63 145.67,88.63 145.8,88.5 145.8,86.98 145.67,86.85
+V3.3A_SIP on TOP: 123.49,71.36 123.24,71.61 123.24,73.01 123.24,73.01 123.24,73.11 123.23,73.13 123.23,78.35 123.44,78.56 124.35,78.56 124.55,78.36 124.55,71.5 124.41,71.36 ; 8 cut-outs
+V3.3A_SIP on BOTTOM: 136.91,70.34 136.65,70.6 136.65,70.85 137.03,71.23 143.13,71.23 143.64,71.74 146.56,71.74 146.69,71.61 146.69,70.85 146.56,70.72 143.76,70.72 143.38,70.34
+V3.3A_SIP on L3: 137.67,71.99 137.67,70.85 137.41,70.6 136.02,70.6 135.99,70.62 133.83,70.62 133.76,70.7 133.76,70.75 131.37,73.14 127.25,73.14 125.73,71.61 123.83,71.61 123.57,71.87 123.57,74.64 123.83,74.89 131.62,74.89 131.64,74.88 134.79,74.88
+VCCCLK5 on TOP: 117.13,79.36 116.67,79.82 116.02,79.82 115.94,79.9 115.94,80.5 115.95,80.51 115.95,80.73 116.08,80.86 117.58,80.86 117.83,80.6 117.83,80.16 117.61,79.94 117.61,79.51 117.47,79.36
+VCCFUSEPRG on TOP: 120.32,82.79 120.24,82.87 120.24,83.14 120.4,83.3 120.6,83.3 120.9,83.6 120.9,84.97 119.99,85.89 119.99,86.7 120.14,86.85 121.16,86.85 121.69,86.32 121.69,83.42 121.06,82.79 ; 1 cut-out
+VCCGT on TOP: 91.72,70.47 91.06,71.13 91.06,73.72 90.63,74.15 90.63,75.02 90.4,75.25 90.09,75.25 89.92,75.42 89.92,86.22 93.73,90.03 93.73,90.92 99.44,96.63 99.44,99.07 99.69,99.32 104.67,99.32 105.13,98.87 106.63,98.87 106.78,99.02 106.78,100.06 106.17,100.67 106.17,105.14 105.77,105.55 105.77,106.41 105.89,106.54 108.46,106.54 108.71,106.79 108.71,107.68 108.84,107.81 112.14,107.81 113.67,106.28 113.67,98.66 104.32,89.32 104.32,84.74 103,83.42 103,82.03 103.5,81.52 105.38,81.52 105.46,81.44 105.46,81.06 105.21,80.81 103.05,80.81 102.74,80.5 102.74,74.53 103.12,74.15 105.28,74.15 106.3,73.14 107.82,73.14 107.95,73.01 107.95,71.46 107.76,71.27 105.5,71.27 104.7,70.47 101.09,70.47 100.08,71.49 95.63,71.49 95.5,71.36 95.5,70.72 95.25,70.47 ; 63 cut-outs
+VCCGT on BOTTOM: 106.05,101.59 105.92,101.71 105.92,104.13 106.05,104.25 107.19,104.25 108.71,105.78 108.71,107.76 108.97,108.01 112.22,108.01 112.52,107.71 112.52,105.9 112.65,105.78 114.78,105.78 114.88,105.67 114.88,102.3 114.17,101.59
+VCCGT on BOTTOM: 76.58,70.6 76.07,71.11 76.07,76.85 76.35,77.12 79.81,77.12 83.95,81.27 85.13,81.27 85.13,81.25 85.22,81.17 85.22,80.88 84.96,80.63 84.58,80.63 84.2,80.25 84.2,79.61 84.45,79.36 85.85,79.36 86.89,80.39 86.98,80.39 87.04,80.46 89.18,80.46 89.53,80.81 96.32,80.81 96.73,81.21 97.06,81.21 97.5,81.65 97.5,82.4 97.54,82.44 106.93,82.44 107.01,82.36 107.01,80.95 106.76,80.7 98.26,80.7 97.83,80.27 97.83,80.06 97.22,79.45 97.22,75.73 97.19,75.7 96.79,75.7 95.97,74.88 90.96,74.88 89.66,76.19 83.44,76.19 80.51,73.25 80.12,73.25 78.64,71.77 78.64,71.38 77.85,70.6 ; 5 cut-outs
+VCCGT on L2VCC: 98.33,71.55 97.07,72.81 97.07,73.75 95.43,75.38 91.39,75.38 90.66,76.12 87.84,76.12 87.31,76.65 87.31,79.66 88.2,80.55 88.2,85 99.63,96.43 99.63,101.63 103.44,105.44 103.44,107.86 103.84,108.25 111.86,108.25 112.76,107.35 112.84,107.24 112.84,107.22 112.88,107.18 112.92,107.13 112.94,107.12 113.97,106.09 117.28,106.09 117.28,102.43 104.33,89.47 104.33,82.58 105.47,81.44 105.47,75.73 108.01,73.19 108.01,71.55
+VCCGT on L3: 91.19,75.65 91.59,75.25 96.19,75.25 96.69,74.75 96.69,73.68 96.72,73.65 96.72,71.89 97.26,71.36 107.7,71.36 107.95,71.61 107.95,73.27 105.5,75.72 105.5,81.43 104.44,82.48 104.44,89.71 114.14,99.41 114.14,106.07 112.27,107.94 97.16,107.94 96.14,106.92 96.14,91.17 93.73,88.76 93.73,86.98 96.27,84.44 96.27,81.77 95,80.5 91.44,80.5 91.19,80.25
+VCCGT on L4: 102.49,93.58 105.92,93.58 106.43,93.08 106.43,91.35 104.46,89.39 104.46,82.41 105.41,81.46 105.41,75.3 108.08,72.63 108.08,71.74 107.82,71.49 99.57,71.49 96.77,74.28 92.2,74.28 91.19,75.3 91.19,82.15 102.11,93.08 102.11,93.2
+VCCIO on TOP: 108.33,69.91 108.18,70.06 108.18,70.32 107.95,70.55 106.12,70.55 105.99,70.67 105.99,71.11 106.07,71.18 110.97,71.18 111.07,71.28 113.51,71.28 113.67,71.44 113.67,73.75 113.61,73.8 113.61,73.82 113.72,73.92 115.04,73.92 115.19,73.77 115.19,70.75 114.99,70.55 109.37,70.55 109.18,70.36 109.18,70.08 109.02,69.91 ; 1 cut-out
+VCCIO on BOTTOM: 162.69,63.23 162.69,64.25 162.56,64.37 162.05,64.37 161.16,63.49 159.51,63.49 157.48,65.52 157.48,66.28 157.61,66.41 160.15,66.41 160.66,66.91 163.32,66.91 164.08,66.15 166.24,66.15 167.21,65.19 167.21,63.49 166.95,63.23 ; 7 cut-outs
+VCCIO on BOTTOM: 108.53,69.84 107.98,70.39 107.98,70.83 108.25,71.11 108.74,71.11 109.04,70.8 109.04,70.01 108.86,69.84
+VCCIO on BOTTOM: 114.5,70.32 114.48,70.34 114.48,71.79 113.92,72.35 113.92,72.78 114.17,73.04 115.04,73.04 115.87,72.2 115.87,72.15 115.72,71.99 115.72,70.37 115.67,70.32 115.44,70.32 115.24,70.52 114.96,70.52 114.76,70.32
+VCCIO on L2VCC: 159.21,64.06 158.45,64.82 154.51,64.82 154.37,64.96 154.37,65.6 152.61,67.36 123.78,67.36 121.87,69.26 120.35,69.26 119.71,69.9 114.12,69.9 113.86,70.17 113.86,72.55 114.38,73.07 116.25,73.07 116.76,72.57 123.49,72.57 123.87,72.18 125.52,72.18 126.79,70.91 128.45,70.91 129.21,70.15 153.97,70.15 156.89,67.23 159.05,67.23 160.59,65.69 160.59,64.45 160.2,64.06
+VCCMPHYGTAON_1P0_LS_SIP on BOTTOM: 148.35,80.11 147.96,80.5 147.96,83.17 148.08,83.3 148.41,83.3 148.84,82.87 151.03,82.87 151.46,83.3 152.55,83.3 153.47,84.21 154.64,84.21 154.76,84.08 154.76,80.43 154.44,80.11 ; 2 cut-outs
+VCCMPHYGTAON_1P0_LS_SIP on BOTTOM: 123.1,78.46 122.93,78.63 122.93,78.82 122.38,79.37 121.74,79.37 121.65,79.45 121.65,79.76 121.76,79.86 124.27,79.86 124.38,79.75 124.38,78.84 124,78.46
+VCCMPHYGTAON_1P0_LS_SIP on L2VCC: 122.89,77.14 122.24,77.79 122.24,79.03 122.76,79.55 133.56,79.55 144.1,90.09 147.88,90.09 148.65,89.31 148.65,88.3 152.72,84.23 152.72,81.98 151.43,80.69 148.54,80.69 148.02,81.22 148.02,83.09 148.16,83.23 148.51,83.23 148.89,82.85 149.81,82.85 150.18,83.22 150.18,84.14 148.41,85.9 146.23,85.9 142.8,82.47 139.75,82.47 134.41,77.14
+VCCPRIM_CORE on TOP: 148.08,72.25 147.57,72.76 139.95,72.76 139.57,73.14 139.57,74.28 140.21,74.92 143.13,74.92 144.15,73.9 146.81,73.9 147.07,73.65 149.22,73.65 149.61,74.03 149.61,76.82 148.46,77.96 148.46,79.87 149.96,81.37 149.96,81.67 149.28,82.36 149.28,82.54 148.18,83.63 148.18,84.01 148.01,84.19 147.96,84.19 147.07,85.08 147.07,86.22 147.32,86.47 150.88,86.47 153.24,84.11 153.24,81.47 150.62,78.85 150.62,72.76 150.11,72.25
+VCCPRIM_CORE on TOP: 119.49,73.01 119.32,73.18 119.32,73.45 119.46,73.58 120.14,73.58 120.71,74.15 121.28,74.15 121.41,74.03 121.41,73.13 121.28,73.01 ; 1 cut-out
+VCCPRIM_CORE on TOP: 116.16,75.07 116.1,75.13 116.1,76.59 116.33,76.82 117.2,76.82 117.76,76.27 117.76,75.32 117.51,75.07 ; 1 cut-out
+VCCPRIM_CORE on BOTTOM: 119.36,73.08 119.23,73.21 119.23,73.5 119.38,73.65 119.66,73.65 119.82,73.49 120.58,73.49 121.03,73.94 121.99,73.94 122.08,73.85 122.08,73.41 121.81,73.13 120.03,73.13 120.02,73.15 119.74,73.15 119.68,73.08
+VCCPRIM_CORE on BOTTOM: 119.15,76.76 118.96,76.94 118.96,77.61 119.15,77.8 119.54,77.8 120.11,77.23 120.63,77.23 120.73,77.13 120.73,76.82 120.66,76.76
+VCCPRIM_CORE on BOTTOM: 148.84,83.02 148.16,83.7 147.57,83.7 147.19,84.08 143.89,84.08 143.61,84.36 143.61,85.35 143.66,85.41 148.21,85.41 149.53,84.08 149.68,84.08 149.91,83.86 149.91,83.12 149.81,83.02
+VCCPRIM_CORE on L2VCC: 129.36,70.53 128.6,71.3 126.95,71.3 125.68,72.57 124.03,72.57 123.65,72.95 116.92,72.95 116.41,73.45 116.4,73.45 116.4,76.23 116.79,76.63 117.4,76.63 117.54,76.49 117.54,75.47 119.43,73.58 122.13,73.58 123.27,74.72 137.87,74.72 143.07,79.92 143.07,82.2 146.38,85.52 148.26,85.52 149.8,83.98 149.8,83.38 149.65,83.23 149.05,83.23 148.67,83.61 148,83.61 147.64,83.25 147.64,81.06 148.27,80.42 148.27,78.42 141.03,71.18 141.03,70.53
+VCCPRIM_CORE on L3: 116.38,76.9 116.38,75.19 118.82,72.76 120.78,72.76 120.88,72.86 120.88,74.43 120.14,75.17 119.04,75.17 118.59,75.62 118.59,75.92 119.77,77.1 119.77,77.65 119.63,77.79 117.27,77.79
+VCCSA on TOP: 113.59,79.75 113.39,79.96 113.39,80.35 113.11,80.63 112.81,80.63 112.15,81.29 112.15,82.23 112.32,82.4 113.14,82.4 113.28,82.26 113.28,81.49 113.44,81.34 113.44,81.32 113.63,81.13 114.43,81.13 114.55,81.25 115.75,81.25 115.83,81.18 115.83,80.79 115.67,80.64 115.67,79.83 115.6,79.75 ; 1 cut-out
+VCCSA on TOP: 133.1,102.73 132.97,102.86 132.97,107.3 133.1,107.43 138.05,107.43 138.3,107.17 138.3,102.86 138.18,102.73 ; 7 cut-outs
+VCCSA on TOP: 115.85,82.79 115.75,82.89 115.75,84.97 116,85.23 117.14,85.23 117.2,85.18 117.2,84.39 116.92,84.11 116.92,83.47 117.2,83.2 117.2,82.87 117.09,82.87 117.02,82.79 ; 2 cut-outs
+VCCSA on BOTTOM: 117.14,71.21 115.62,72.74 115.62,80.12 115.35,80.38 114.53,80.38 114.45,80.46 114.45,81.83 114.55,81.93 115.21,81.93 115.39,82.11 115.39,82.85 115.49,82.95 115.59,82.95 115.86,83.22 116.11,83.22 116.27,83.06 116.57,83.06 116.78,83.28 117.12,83.28 117.3,83.1 117.55,83.1 117.73,83.28 117.98,83.28 118.31,82.94 118.55,82.94 118.93,82.56 118.93,81.83 118.61,81.51 118.3,81.51 117.98,81.83 117.63,81.83 117.4,81.6 117.4,80.48 116.93,80.01 116.93,77.19 116.38,76.64 116.38,75.02 117.34,74.06 117.34,72.71 117.75,72.31 117.75,72.26 118.47,71.54 118.47,71.31 118.36,71.21
+VCCSA on BOTTOM: 137.44,101.94 136.91,102.47 133.48,102.47 132.97,102.98 132.97,105.01 133.35,105.4 133.35,108.19 133.73,108.57 137.92,108.57 138.05,108.44 138.05,102.17 137.82,101.94 ; 5 cut-outs
+VCCSA on L2VCC: 115.27,80.44 114.87,80.84 114.87,83.85 116.4,85.38 116.4,88.93 130,102.54 131.65,102.54 134.19,105.08 136.57,105.08 136.97,104.68 136.97,103.32 134.03,100.38 129.33,100.38 121.73,92.77 121.73,90.74 118.3,87.31 118.3,84.49 118.94,83.85 118.94,81.73 117.65,80.44
+VCCSA on L3: 114.47,81.25 114.47,80.52 114.66,80.34 115.77,80.34 116.48,81.04 117.12,81.04 117.31,81.23 117.31,81.66 118.29,82.64 118.29,83.99 120.08,85.77 120.97,85.77 122.68,87.49 123.83,87.49 127,90.66 129.54,90.66 129.79,90.92 131.83,90.92 133.45,92.54 133.45,93.97 133.72,94.23 133.74,94.23 137.41,97.9 137.41,104.38 136.91,104.89 133.86,104.89 132.84,103.87 132.84,97.78 131.06,96 131.06,94.22 130.81,93.97 130.05,93.97 129.79,94.22 124.08,94.22 119,89.14 118.49,89.14 115.8,86.45 115.8,82.57
+VCCSA on L4: 114.45,83.74 114.45,80.82 115.03,80.25 117.17,80.25 117.42,80.5 117.42,83.39 116.86,83.96 114.67,83.96
+VCCSRAM_1P0 on BOTTOM: 120.1,77.28 120,77.37 120,77.77 120.36,78.12 121.36,78.12 121.44,78.03 121.44,77.49 121.23,77.28
+VCCSRAM_1P0 on L2VCC: 119.59,73.96 118.7,74.85 120.47,74.85 120.97,75.34 120.97,76.14 119.95,77.15 119.95,77.88 120.22,78.15 121.86,78.15 121.86,77.63 122.73,76.76 134.57,76.76 139.91,82.09 142.68,82.09 142.68,80.07 138.75,76.14 137.95,75.34 137.72,75.11 123.11,75.11 121.97,73.96
GND on TOP (solid shape): 89.73,112.51 78.47,112.51 78.47,113.96 78.19,113.96 78.19,115.68 86.4,115.68 86.4,128.33 78.41,128.33 78.41,117.93 76.37,117.93 76.37,113.96 75.27,113.96 75.27,112.51 73.93,112.51 73.93,129.16 87.76,129.16 87.76,130.16 89.73,130.16
GND on TOP: outline of 110 points within 2.36,96.84 210.95,128.74 ; 8 cut-outs
GND on TOP: 208.91,91.17 208.79,91.3 208.79,94.6 209.04,94.85 210.82,94.85 210.95,94.73 210.95,91.43 210.69,91.17
GND on TOP: 47.88,71.61 47.62,71.87 47.62,74.15 47.75,74.28 47.75,77.2 47.88,77.33 48.77,77.33 48.9,77.2 48.9,73.77 48.77,73.65 48.77,71.74 48.64,71.61 ; 2 cut-outs
GND on TOP: 78.69,49.52 77.43,50.77 77.46,50.8 77.46,52.3 77.72,52.56 78.49,52.56 78.87,52.18 78.87,51.67 79.5,51.04 80.57,51.04 80.95,50.66 82.4,50.66 82.6,50.86 82.6,52.06 82.15,52.51 81.37,52.51 81.15,52.72 81.15,54.47 81.79,55.1 84.2,55.1 84.45,54.85 84.45,53.45 84.44,53.45 84.44,49.63 84.33,49.52 ; 2 cut-outs
GND on TOP: 113.67,81.32 113.54,81.46 113.54,81.9 113.54,81.9 113.54,82.41 113.7,82.57 114.22,82.57 114.63,82.98 114.63,83.96 114.76,84.08 115.54,84.08 115.57,84.06 115.57,82.87 115.81,82.62 115.81,81.66 115.69,81.53 114.57,81.53 114.36,81.32 ; 2 cut-outs
GND on TOP: 59,55.03 58.85,55.18 58.85,60.61 60.71,62.47 64.01,62.47 65.28,61.2 65.28,57.31 63.91,55.94 61.21,55.94 60.3,55.03
GND on TOP: 178.69,100.82 178.44,101.08 178.44,106.03 178.82,106.41 179.71,106.41 179.83,106.28 179.83,102.22 179.58,101.97 179.58,100.95 179.45,100.82 ; 4 cut-outs
GND on TOP: 92.79,51.32 92.58,51.52 92.58,54.09 92.62,54.13 92.62,55.85 93.27,56.5 97.23,56.5 99.01,54.72 99.01,51.93 98.4,51.32 ; 2 cut-outs
GND on TOP: 93.09,64.63 92.58,65.14 92.58,65.52 90.93,67.17 87,67.17 84.96,69.2 84.96,74.31 87.35,76.69 87.35,80.6 88.77,82.03 89.53,82.03 89.66,81.9 89.66,81.63 89.66,81.63 89.66,80.44 89.7,80.41 89.66,80.38 89.66,75.41 89.68,75.41 90.04,75.04 90.3,75.04 90.42,74.92 90.42,74.03 90.81,73.65 90.81,70.83 91.54,70.09 95.5,70.09 95.76,70.34 95.76,71.23 95.89,71.36 99.06,71.36 99.31,71.61 99.31,71.87 99.44,71.99 99.82,71.99 99.95,71.87 99.95,70.34 97.41,67.8 97.41,65.9 97.16,65.64 96.27,65.64 95.89,66.03 94.36,66.03 93.85,65.52 93.85,64.76 93.73,64.63 ; 14 cut-outs
GND on TOP: 106.43,73.26 105.16,74.53 103.12,74.53 103,74.66 103,80.5 103.2,80.71 107.24,80.71 107.44,80.5 107.44,73.39 107.31,73.26 ; 10 cut-outs
GND on TOP: 144.45,9.92 144.35,10.02 144.35,10.98 144.42,11.06 145.72,11.06 146.35,11.69 148.26,11.69 148.34,11.62 148.34,11.59 148.89,11.03 163.17,11.03 163.27,10.93 163.27,10.2 163.02,9.94 148.87,9.94 148.69,10.12 148.69,10.17 148.01,10.86 146.86,10.86 145.92,9.92 ; 13 cut-outs
GND on TOP: 111,17.64 110.87,17.77 110.87,18.27 111,18.4 113.28,18.4 113.67,18.78 113.67,22.21 113.84,22.39 116.03,22.39 117.22,21.19 117.22,17.89 116.97,17.64 ; 10 cut-outs
GND on TOP: 231.09,25.23 230.84,25.49 230.84,27.54 231.9,28.61 231.9,31.48 231.39,31.99 231.39,32.29 230.34,33.35 230.34,33.42 230.33,33.44 230.33,34.1 230.63,34.4 231.19,34.4 231.36,34.24 231.36,33.83 232.31,32.88 233.55,32.88 234.19,32.24 234.19,27.67 231.75,25.23 ; 3 cut-outs
GND on TOP: 60.33,72.5 60.2,72.63 60.2,73.65 60.33,73.77 61.59,73.77 62.23,74.41 62.23,76.69 62.1,76.82 62.1,77.71 62.23,77.84 64.14,77.84 64.26,77.71 64.26,73.01 63.75,72.5 ; 3 cut-outs
GND on TOP: 102.11,123.56 101.73,123.94 101.73,125.72 101.98,125.97 105.41,125.97 105.54,125.84 105.54,123.81 105.28,123.56
GND on TOP: 66.67,56.75 66.42,57.01 66.42,60.95 66.55,61.07 67.56,61.07 67.82,60.82 67.82,56.88 67.69,56.75
GND on TOP: 43.31,93.33 42.29,94.35 42.29,96.25 42.55,96.51 44.96,96.51 45.62,95.84 45.97,95.84 46.1,95.72 46.1,93.97 45.47,93.33 ; 6 cut-outs
GND on TOP: 105.79,112.76 105.59,112.96 105.59,116.22 106.07,116.7 108.69,116.7 109.07,116.32 113.16,116.32 113.54,115.94 113.54,113.4 113.16,113.02 108.46,113.02 108.2,112.76
GND on TOP: 210.06,79.03 209.91,79.18 209.91,80.25 209.75,80.4 208.31,80.4 207.8,79.89 207.8,79.49 207.59,79.28 206.71,79.28 206.63,79.36 206.63,81.42 207.39,82.18 207.82,82.18 208.69,83.04 208.69,83.7 208.71,83.73 212.19,83.73 212.32,83.6 212.32,82.61 212.39,82.54 213.54,82.54 213.77,82.76 214.17,82.76 214.38,82.97 214.38,83.55 214.22,83.7 214.22,84.49 214.3,84.57 214.91,84.57 215.37,83.5 215.62,80.48 215.62,79.46 215.19,79.03 ; 4 cut-outs
GND on TOP: outline of 118 points within 2.36,19.42 25.76,80.19 ; 7 cut-outs
GND on TOP: 154.05,100.57 153.54,101.08 153.54,104.89 155.07,106.41 155.07,108.95 155.96,109.84 155.96,112.63 156.08,112.76 156.72,112.76 156.84,112.63 156.84,100.7 156.72,100.57 ; 13 cut-outs
GND on TOP: 39.95,28.05 38.46,29.55 38.46,30.08 38.61,30.24 38.99,30.24 39.32,29.91 40.23,29.91 40.39,30.06 40.39,30.57 40.54,30.72 41.96,30.72 42.16,30.52 42.16,28.18 42.04,28.05
GND on TOP: 112.29,73.01 112.09,73.21 112.09,80.3 112.24,80.45 113.03,80.45 113.21,80.27 113.21,79.73 113.49,79.45 116.78,79.45 117.05,79.18 117.05,78.6 116.89,78.44 116.84,78.44 116.75,78.34 116.71,78.34 116.71,77.2 116.59,77.07 116.08,77.07 115.87,76.87 115.87,75.06 116.07,74.86 117.5,74.86 117.6,74.76 117.6,74.4 117.35,74.15 117.35,74.15 116.03,74.15 116.03,74.19 115.99,74.23 113.49,74.23 113.28,74.03 113.28,73.14 113.16,73.01 ; 13 cut-outs
GND on TOP: 129.97,102.73 129.54,103.16 129.54,111.73 129.64,111.84 132.11,111.84 132.59,111.36 132.59,102.93 132.38,102.73 ; 10 cut-outs
GND on TOP: 185.29,61.58 185.04,61.83 185.04,64.25 185.29,64.5 198.5,64.5 198.75,64.25 198.75,61.96 198.37,61.58 ; 15 cut-outs
GND on TOP: 122.43,71.87 122.3,71.99 122.3,73.14 122.17,73.26 121.79,73.26 121.67,73.39 121.67,74.15 121.54,74.28 119,74.28 118.75,74.53 118.75,74.66 118.87,74.79 119.25,74.79 119.38,74.92 119.38,75.93 119.51,76.06 119.76,76.06 119.89,75.93 119.89,75.55 120.02,75.42 120.65,75.42 120.9,75.68 120.9,77.07 120.78,77.2 119.51,77.2 119.38,77.33 119.38,77.71 120.35,78.67 122.3,78.67 122.45,78.83 122.58,78.83 123.06,78.34 123.06,71.99 122.94,71.87 ; 13 cut-outs
GND on TOP: 119.56,50.48 119.05,50.99 119.05,52.11 120.12,53.17 120.57,53.17 120.75,52.99 120.75,50.79 120.45,50.48
GND on TOP: 183.24,79.49 183.13,79.59 183.13,81.57 183.24,81.67 183.74,81.67 183.91,81.51 183.91,79.65 183.74,79.49
GND on TOP: 54.61,52.66 54.61,53.58 54.46,53.73 53.47,53.73 53.44,53.76 53.44,54.54 53.49,54.6 56.39,54.6 56.54,54.44 57.53,54.44 57.61,54.37 57.61,53.93 57.4,53.73 54.94,53.73 54.81,53.6 54.81,52.66
GND on TOP: 213.89,66.66 213.13,67.42 209.3,67.42 209.04,67.68 209.04,70.72 209.3,70.98 215.14,70.98 215.26,70.85 215.26,67.32 214.6,66.66
GND on TOP: 105.18,99.1 104.62,99.65 99.54,99.65 99.38,99.82 99.38,102.16 99.82,102.6 99.82,103.62 99.95,103.74 104.01,103.74 104.39,104.13 104.39,105.4 104.52,105.52 105.56,105.52 105.92,105.17 105.92,100.72 106.65,99.98 106.65,99.17 106.58,99.1 ; 9 cut-outs
GND on TOP: 172.27,79.92 172.16,80.03 172.16,80.51 172.25,80.6 172.78,80.6 173.03,80.84 173.03,81.35 173.38,81.7 173.38,83.65 173.1,83.93 173.1,85.02 173.23,85.15 173.61,85.15 173.74,85.02 173.74,84.03 173.89,83.87 174.76,83.87 174.87,83.77 174.87,80.86 175.29,80.44 175.29,79.98 175.23,79.92 ; 6 cut-outs
GND on TOP: 61.72,67.17 61.59,67.3 61.59,67.42 61.47,67.55 58.93,67.55 58.55,67.93 58.55,68.82 58.67,68.95 59.18,68.95 59.31,68.82 59.31,68.44 59.44,68.31 62.74,68.31 62.74,68.18 62.99,67.93 65.02,67.93 65.28,67.68 65.28,67.42 65.15,67.3 64.9,67.3 64.64,67.55 62.99,67.55 62.87,67.42 62.87,67.3 62.74,67.17
GND on TOP: 115.7,11.29 115.57,11.42 115.57,15.99 115.7,16.11 116.97,16.11 117.6,15.48 117.6,11.8 117.09,11.29 ; 6 cut-outs
GND on TOP: 42.55,42.91 41.91,43.55 38.99,43.55 38.91,43.62 38.91,46.04 39.09,46.21 40.13,46.21 40.26,46.09 41.02,46.09 42.29,47.36 43.69,47.36 43.81,47.23 43.81,43.17 43.56,42.91 ; 3 cut-outs
GND on TOP: 40.13,20.56 40.01,20.69 40.01,23.86 40.13,23.99 41.94,23.99 42.6,23.33 42.6,22.34 41.91,21.65 41.91,20.81 41.66,20.56
GND on TOP: 129.92,51.04 129.67,51.29 129.67,54.34 130.15,54.82 134.01,54.82 134.87,53.96 134.87,51.17 134.75,51.04
GND on TOP: 225.68,17.97 225.45,18.2 224.82,18.2 224.74,18.27 224.74,19.25 224.74,19.25 224.74,19.62 224.53,19.83 223.18,19.83 223.09,19.92 223.09,23.56 223.77,24.24 223.77,25.39 224.03,25.64 226.82,25.64 226.95,25.51 226.95,24.12 227.84,23.23 227.84,18.37 227.43,17.97 ; 2 cut-outs
GND on TOP: 175.21,77.79 175.17,77.83 175.17,78.71 175.84,79.38 176.35,79.38 176.63,79.66 176.63,80.27 176.77,80.42 177.1,80.42 177.72,81.03 177.96,81.03 178.26,80.74 178.26,78.68 178.14,78.55 177.68,78.55 177.51,78.72 176,78.72 175.91,78.63 175.91,77.89 175.8,77.79 ; 1 cut-out
GND on TOP: 51.05,28.05 50.93,28.18 50.93,28.69 51.87,29.63 51.87,30.44 51.59,30.72 49.66,30.72 49.53,30.85 49.53,34.48 49.76,34.71 49.76,35.44 49.83,35.52 51.1,35.52 52.1,34.53 52.7,34.53 52.83,34.4 52.83,33.39 53,33.21 53,29.37 51.69,28.05 ; 1 cut-out
GND on TOP: 69.8,85.43 69.34,85.89 69.34,86.7 69.8,87.16 71.32,87.16 71.81,87.64 72.01,87.64 72.19,87.46 72.19,87.03 72.14,86.98 71.7,86.98 71.53,86.8 71.53,86.12 70.84,85.43 ; 3 cut-outs
GND on TOP: 73.15,55.1 72.14,56.12 72.14,56.75 72.39,57.01 72.39,62.09 72.64,62.34 73.53,62.34 73.79,62.09 73.79,55.36 73.53,55.1 ; 2 cut-outs
GND on TOP: 167.63,79.9 167.3,80.23 167.3,82.8 167.46,82.95 168.11,82.95 168.33,83.17 168.33,83.65 168.42,83.74 168.99,83.74 169.06,83.67 169.06,81.32 169.32,81.06 171.09,81.06 171.29,80.86 171.29,80.05 171.13,79.9 ; 4 cut-outs
GND on TOP: 195.71,101.33 195.58,101.46 195.58,110.6 195.71,110.73 195.71,116.37 193.22,118.86 191.9,118.86 191.77,118.98 191.77,119.75 191.9,119.87 196.85,119.87 196.98,119.75 196.98,118.48 198.5,116.95 198.5,116.32 199.26,115.56 199.26,108.24 198.37,107.35 198.37,103.11 196.6,101.33 ; 16 cut-outs
GND on TOP: 32.64,20.43 31.37,21.7 31.37,24.75 31.75,25.13 34.04,25.13 34.8,24.37 34.8,20.56 34.67,20.43
GND on TOP: 52.88,47.56 52.81,47.64 52.81,48.5 52.17,49.13 51,49.13 51,49.97 51.18,50.15 52.7,50.15 52.81,50.05 52.81,49.74 52.96,49.59 53.72,49.59 53.9,49.77 54.76,49.77 55.3,50.3 56.59,50.3 56.72,50.18 56.72,49.57 56.87,49.41 57.91,49.41 58.06,49.26 58.06,48.6 57.98,48.51 56.53,48.51 56.52,48.5 53.75,48.5 53.42,48.17 53.42,47.64 53.34,47.56 ; 6 cut-outs
GND on TOP: 23.5,35.8 23.37,35.93 23.37,39.1 25.15,40.88 30.48,40.88 31.62,39.74 31.62,36.82 30.61,35.8 ; 4 cut-outs
GND on TOP: 215.65,15.73 215.52,15.86 215.52,17.51 215.65,17.64 215.9,17.64 216.41,18.15 216.41,18.78 216.53,18.91 217.04,18.91 217.17,18.78 217.17,18.27 216.92,18.02 216.92,15.86 216.79,15.73
GND on TOP: 179.88,77.76 179.8,77.85 179.8,78.53 179.49,78.83 179.49,79.17 180.11,79.79 180.11,80.16 179.42,80.85 179.42,80.97 179.6,81.14 180.03,81.14 180.66,81.78 180.66,83.03 180.89,83.25 180.89,83.72 181,83.84 181.61,83.84 181.68,83.76 181.68,81.95 180.85,81.12 180.85,79.1 180.49,78.74 180.49,77.85 180.4,77.76 ; 2 cut-outs
GND on TOP: 105.77,106.67 105.54,106.89 105.54,108.82 105.79,109.08 106.3,109.08 107.06,108.32 108.2,108.32 108.46,108.06 108.46,106.92 108.2,106.67 ; 4 cut-outs
GND on TOP: 175.13,19.8 174.88,20.05 174.88,22.08 175.01,22.21 179.32,22.21 179.45,22.08 179.45,19.92 179.32,19.8 ; 7 cut-outs
GND on TOP: 20.83,33.39 20.45,33.77 16.89,33.77 15.75,34.91 15.75,35.16 17.14,36.56 21.08,36.56 21.72,35.93 21.72,33.64 21.46,33.39
GND on TOP: 164.47,9.92 164.31,10.07 164.31,10.75 164.49,10.93 168.25,10.93 168.4,10.78 168.4,9.99 168.33,9.92
GND on TOP: outline of 273 points within 32.13,0.77 292.04,67.59 ; 33 cut-outs
GND on TOP: 212.55,99.17 210.67,101.05 208.48,101.05 208.23,101.31 208.23,105.5 207.34,106.39 207.34,109.43 209.37,111.47 210.56,111.47 211.45,112.35 211.45,120.46 211.99,120.46 211.99,107.21 212,106.94 212.03,106.67 213.22,99.17 ; 3 cut-outs
GND on TOP: 16,80.25 15.75,80.5 15.75,81.65 16,81.9 20.7,81.9 21.08,81.52 21.08,80.63 20.7,80.25
GND on TOP: 178.78,81.51 178.34,81.95 176.48,81.95 176.41,82.03 176.41,82.48 176.52,82.59 179.27,82.59 179.34,82.53 179.34,81.77 179.08,81.51 ; 1 cut-out
GND on TOP: 138.68,102.73 138.56,102.86 138.56,106.41 138.81,106.67 140.08,106.67 140.84,105.9 140.84,103.19 140.39,102.73 ; 2 cut-outs
