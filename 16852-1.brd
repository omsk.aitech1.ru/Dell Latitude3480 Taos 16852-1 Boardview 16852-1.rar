# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
V0.85A_VID0: length 3.3
  TOP w0.254: TP2101.1 125.14,70.98 125.62,70.5 125.62,70.02 125.61,70.02 125.61,70.01 125.34,69.73 125.32,69.73 v1(125.15,69.56)
  BOTTOM w0.254: v1(125.15,69.56) 125.17,69.58 125.27,69.58 125.5,69.8 CPU1.AN11
V3D3_STB: length 9.9
  TOP w0.203: v1(19.62,11.12) 19.72,11.22 HDA27.20 ; R2712.1 v1(17.48,15.66)
  L4 w0.203: v1(19.62,11.12) 19,10.5 18.06,10.5 17.48,11.08 v1(17.48,15.66)
  BOTTOM w0.203: v2(19.08,11.39) 19.35,11.39 v1(19.62,11.12)
VCC_CORE: length 2.1
  BOTTOM w0.203: CPU1.A44 v1(106.78,87.3)
  BOTTOM w0.254: v3(114.17,87.54) 114.22,87.49 CPU1.A30
  vias: v1(108.73,82.98) v1(108.84,87.23) v1(108.86,71.85) v1(108.99,72.5) v1(109.32,80.83) v1(109.61,72.64) v1(109.61,71.72) v1(109.76,78.39) v1(109.75,77.25) v1(109.96,80.83) v1(110.07,72.18) v1(110.53,82.94) v1(110.55,72.66) v1(110.53,71.72) v1(110.99,72.18) v1(111.09,80.81) v1(111.44,71.72) v1(111.45,72.62) v1(111.78,80.84) v1(111.91,72.18) v1(112.36,82.94) v1(112.37,72.62) v1(112.36,71.72) v1(112.83,72.18) v1(113.27,71.72) v1(114.12,83.02) v1(118.47,100.45) v1(120.04,99.24) v2(117.89,99.08) v2(121.85,109.31) v2(126.64,110.2) v3(107.88,77.82) v3(108.58,77.33) v3(108.66,81.24) v3(109.22,78.93) v3(109.25,77.86) v3(109.22,76.62) v3(110.24,78.95) v3(110.24,77.84) v3(110.21,76.59) v3(110.49,88.89) v3(110.54,81.32) v3(110.89,77.11) v3(111.63,88.89) v3(111.65,77.59) v3(120.78,105.14) v3(120.78,104.25) v3(120.78,103.36) v3(121.28,106.03) v3(121.79,105.14) v3(121.79,104.25) v3(121.79,103.36) v3(122.3,106.03) v3(122.81,105.14) v3(122.81,104.25) v3(122.81,103.36) v3(123.32,106.03) v3(123.83,105.14) v3(123.83,104.25) v3(123.83,103.36) v3(124.33,106.03) v3(124.84,105.14) v3(124.84,104.25) v3(124.84,103.36) v3(125.35,106.03) v3(125.73,105.14) v3(125.73,104.25) v3(125.73,103.36) v3(126.36,106.03) v3(126.64,105.14) v3(126.62,104.25) v3(126.62,103.36) v3(127.38,106.03) v3(127.51,104.25) v3(127.51,103.36) v3(127.58,105.14)
VCC_OPC_1P8_H63: length 1.6
  TOP w0.102: v1(96.81,82.01) 96.77,81.97 TP704.1
  BOTTOM w0.102: CPU1.H63 96.63,82.1 96.73,82.01 v1(96.81,82.01)
VCC_SENSE: length 63.4
  TOP w0.254: v1(140.97,120.51) v2(140.97,118.32) ; R719.2 113,84.5 113.16,84.35 v1(113.18,84.35) 113.19,84.33 113.45,84.33 114.2,85.08 114.55,85.08 114.85,85.37 114.85,88.92 115.82,89.9 115.82,91.22 116.51,91.91 117.78,91.91 128.52,102.65 v1(128.52,103.24)
  L4 w0.254: v1(140.97,120.51) 141.05,120.58 141.05,121.32 139.37,123 136.09,123 134.42,121.32 130.89,121.32 128.78,119.21 128.78,114.87 129.45,114.2 129.45,111.83 128.52,110.91 v1(128.52,103.24)
  BOTTOM w0.254: v1(140.97,120.51) 141.15,120.69 PR4648.1 ; v1(113.18,84.35) 113.21,84.31 113.66,83.99 CPU1.E32
VCCGT_SENSE: length 141.6
  TOP w0.254: PR4617.1 152.78,109.33 153.29,108.82 v1(153.29,108.7) ; v1(95.38,118.6) 94.27,117.5 94.27,109.43 v2(94.48,109.23) 95.08,108.62 95.08,100.46 93.71,99.1 93.71,98.32 91.08,95.69 91.08,95.04 91.31,94.81 91.31,94.39 91.3,94.38 91.3,94.31 91.3,92.71 90.3,91.7 90.3,88.73 87.44,85.88 87.44,81.53 v1(87.63,81.34)
  L4 w0.254: v1(153.29,108.7) 153.29,109.08 153.59,109.38 153.59,110.41 154.78,111.59 154.83,111.59 156.49,113.25 156.49,120.18 155.24,121.44 154.46,121.44 151.58,124.32 151.58,125.31 150.39,126.5 149.4,126.5 148.17,127.73 133.89,127.73 131.61,125.46 119.17,125.46 117.6,123.89 117.6,121.73 115.61,119.75 106.93,119.75 106.74,119.94 106.74,120.3 106.95,120.51 106.95,120.87 106.59,121.23 106.24,121.23 106.02,121.02 105.66,121.02 105.3,121.38 105.3,121.73 105.52,121.95 105.52,122.31 105.16,122.67 104.8,122.67 104.59,122.45 104.23,122.45 103.25,123.43 100.71,123.43 99.52,122.24 99.27,122.24 99.25,122.22 99.17,122.22 98.53,121.58 98.17,121.58 97.58,122.17 97.22,122.17 96.86,121.81 96.86,121.45 97.45,120.86 97.45,120.5 97.09,120.14 96.73,120.14 96.01,120.86 95.65,120.86 95.29,120.5 95.29,120.14 96.01,119.42 96.01,119.06 95.63,118.68 95.45,118.68 v1(95.38,118.6)
  BOTTOM w0.089: CPU1.J70 91.81,81.83 91.66,81.68 91.42,81.57 88.39,81.57
  BOTTOM w0.254: R721.2 87.3,81.01 v1(87.63,81.34) 87.86,81.57 88.39,81.57
VCCRTCEXT: length 3.6
  TOP w0.254: v2(125.43,65.85) 125.46,65.81 C2112.1 125.46,64.37 v1(126.31,63.53)
  BOTTOM w0.089: CPU1.BB10 126.37,63.59 v1(126.31,63.53)
VCCSA_SENSE: length 60.8
  TOP w0.254: v1(120.59,82.36) 120.38,82.36 120.14,82.13 120.14,82.09 119.87,81.82 119.48,81.82 119.35,81.94 118.74,81.94 118.16,82.52 118.16,82.93 R735.2 117.79,83.68 118.34,84.23 118.34,84.74 117.66,85.43 117.66,88.44 120.62,91.41 120.62,92.72 128.99,101.08 146.05,101.08 149.11,104.14 151.48,104.14 v2(152.32,104.98) 153.8,106.45 153.8,109.05 154.99,110.25 v1(154.99,110.73)
  BOTTOM w0.254: v1(154.99,110.73) 154.99,111.08 155.26,111.35 PR4607.1 ; CPU1.H20 120.91,82.04 v1(120.59,82.36)
VCCSTG_EN: length 72.3
  L4 w0.127: v1(213.74,46.98) 212.53,48.18 208.93,48.18 208.38,48.73 208.38,51.17 206.14,53.41 194.84,53.41 193,55.25 192.21,55.25 192.04,55.42 189.29,55.42 188.81,55.9 187.42,55.9 187.2,55.69 186.38,55.69 184.67,53.97 179.57,53.97 179.24,54.3 171.34,54.3 170.67,54.96 166.97,54.96 162.79,59.15 160.7,59.15 v1(159.28,60.56)
  BOTTOM w0.127: R4014.1 159.96,61.19 159.33,60.56 v1(159.28,60.56) ; R4018.2 211.9,41.9 R9936.1 211.84,43.04 v2(211.99,43.19) 211.99,43.57 212.99,44.56 213.12,44.56 213.42,44.87 213.42,45.18 U4003.4 214.22,46.37 213.74,46.85 v1(213.74,46.98)
VCCSTG_EN_R: length 3.3
  BOTTOM w0.127: v2(159.97,60.49) 160.85,61.36 R4014.2 161.74,60.69 U4002.4
VCCSTU_EN: length 8.7
  BOTTOM w0.127: 152.27,85.46 152.86,84.87 v2(153.92,84.87) 154.08,84.87 154.69,85.48 R4023.2 ; 152.27,85.46 151.65,86.08 U4005.4 151.27,86.08 150.05,87.3 R4026.2 ; 152.27,85.46 151.45,84.63 EC4001.1 150.66,84.44 R4024.1
VCCSTU_EN_R: length 3.9
  BOTTOM w0.127: U4006.4 148.26,85.89 149.73,84.41 R4024.2 149.75,84.25 v2(150.5,83.5)
VDD10: length 5.5
  BOTTOM w0.203: LOM31.22 47.26,94.38 v1(47.57,94.69) ; v1(43.43,92.06) 43.6,92.22 LOM31.30 ; LOM31.8 41.2,97.29 40.56,97.29 v1(40.51,97.24) ; v1(41.02,94.64) 41.2,94.46 41.53,94.38 LOM31.3
  vias: v2(45.75,96.71)
VDDREG: length 3.9
  BOTTOM w0.508: C3107.1 48.53,93.16 v2(48.87,92.82) 49.15,92.54 R3103.2 C3116.1
VSS_AY71: length 6.8
  BOTTOM w0.254: R602.1 86.17,63.05 86.17,63.05 v2(86.17,63.41) 86.41,63.65 87.81,63.65 87.97,63.82 88.52,63.82 89.47,64.77 90.38,64.77 90.81,65.2 CPU1.AY71
VSS_MECH1: length 4.3
  BOTTOM w0.102: TP7701.1 162.16,91.27 165.26,91.27 165.36,91.37 165.7,91.37 165.94,91.6 GPU1.A32
VSS_MECH2: length 5.2
  TOP w0.102: TP7702.1 184.02,71.61 v1(184.28,71.87)
  BOTTOM w0.102: v1(184.28,71.87) 184.53,71.87 185.27,71.13 185.46,71.13 185.65,70.94 185.65,70.77 186.06,70.36 187.07,70.36 187.42,70 GPU1.AM1
VSS_MECH3: length 3.6
  BOTTOM w0.102: TP7703.1 165.72,70.37 166.09,70 GPU1.AM32
VSS_SENSE: length 63
  TOP w0.254: v2(141.48,119.54) 141.48,120.3 141.48,120.72 141.01,121.18 v1(140.46,121.18) ; v1(113.28,83.68) 113.41,83.68 114.36,84.63 R720.1 115.32,84.76 115.32,88.71 116.33,89.72 116.33,91.01 116.72,91.4 117.99,91.4 129.03,102.44 129.03,102.88 v1(129.31,103.16)
  L4 w0.254: v1(140.46,121.18) 139.16,122.49 136.3,122.49 134.63,120.81 131.1,120.81 129.29,119 129.29,115.08 129.96,114.41 129.96,111.62 129.03,110.7 129.03,103.44 v1(129.31,103.16)
  BOTTOM w0.254: v1(113.28,83.68) 113.28,83.68 113.16,83.68 CPU1.E33 ; v1(140.46,121.18) 140.49,121.21 142.57,121.21 143,120.78 PR4645.1
VSSGT_SENSE: length 138.3
  TOP w0.254: v1(94.61,118.6) 93.76,117.75 93.76,109.22 94.57,108.41 v2(94.57,107.83) 94.57,100.67 93.2,99.31 93.2,98.53 90.58,95.9 90.58,94.83 90.96,94.45 90.96,92.97 89.76,91.78 89.76,88.94 86.89,86.07 86.89,80.6 v1(87,80.5) ; v1(153.03,107.05) 153.23,107.24 PR4618.1
  L4 w0.254: v1(153.03,107.05) 152.78,107.3 152.78,109.33 153.03,109.58 153.03,110.57 154.57,112.1 154.62,112.1 155.98,113.46 155.98,119.97 155.03,120.93 154.67,120.93 154.25,120.93 151.08,124.1 151.08,125.1 150.18,125.99 149.19,125.99 147.95,127.23 134.1,127.23 131.83,124.95 131.4,124.95 119.38,124.95 118.11,123.68 118.11,121.52 115.82,119.24 106.68,119.24 103,122.92 100.97,122.92 99.76,121.71 99.38,121.71 99.32,121.65 95.76,118.1 95.12,118.1 v1(94.61,118.6)
  BOTTOM w0.089: CPU1.J69 92.4,81.83 92.14,81.57 91.9,81.57 91.47,81.39 88.96,81.39 88.8,81.23
  BOTTOM w0.254: R722.1 86.61,80.12 v1(87,80.5) 87.53,80.5 88.25,81.23 88.8,81.23
VSSRHA: length 2.7
  TOP w0.102: v1(177.83,84.72) 177.43,84.32 177.43,83.7 177.83,83.29 TP7801.1
  BOTTOM w0.102: GPU1.L16 177.36,85.2 v1(177.83,84.72)
VSSSA_SENSE: length 61.9
  TOP w0.254: v1(155.07,113.27) 154.48,112.68 154.48,111.9 154.76,111.62 155.17,111.62 155.19,111.59 155.2,111.59 155.5,111.3 155.5,110.04 154.31,108.84 154.31,106.24 v2(151.69,103.63) 149.32,103.63 146.26,100.57 129.2,100.57 121.13,92.51 121.13,91.2 118,88.06 118,85.57 118.69,84.88 118.69,84.09 118.24,83.64 118.24,83.34 118.5,83.07 118.5,82.66 118.69,82.47 R734.1 119.49,82.47 v1(119.67,82.29)
  BOTTOM w0.254: CPU1.H21 119.81,82.04 119.67,82.18 v1(119.67,82.29) ; PR4604.1 155.26,113.08 v1(155.07,113.27)
0D6V_PWR: length 3.4
  TOP w0.305: PC5124.1 59.83,53.74 PU5102.5 ; PU5102.3 62.83,54.54 62.53,54.85
  vias: v2(58.24,53.96)
0D6V_S0: length 196.8
  TOP w1.016: 42.09,14.83 42.09,16.65 44.3,18.86 45.87,18.86 49.58,22.57 49.58,24.04 v3(49.33,24.29)
  TOP w1.27: 58.93,48.93 59.11,48.75 59.11,44.08 60.13,43.05 v3(60.13,38.14)
  L4 w1.016: v1(114.1,13.47) 110.68,13.47 109.36,12.15 85.41,12.15 85.03,11.77 55.7,11.77 55.34,11.41 46.78,11.41 45.98,12.2 45,12.2 44.4,12.8 44.4,13.29 v3(43.89,13.8)
  L6 w1.27: v3(60.13,38.14) 60.13,37.55 60.13,37.54 60.13,36.74 53.72,30.33 53.72,29.57 53.16,29.01 52.81,29.01 49.33,25.53 v3(49.33,24.29)
  BOTTOM w0.305: DM2.258 187.97,10.21 ; DM1.258 110.97,12.79
  BOTTOM w0.508: 115.7,10.46 FC9713.2 116.52,9.45 117.03,9.95 123.65,9.95 123.74,10.04 131.34,10.04 131.87,9.52 177.22,9.52 180.15,6.59 C1324.1 186.11,6.44 C1227.1 C1223.1 C1327.1 C1224.1 187.01,9.65 187.38,10.02 187.78,10.02 187.97,10.21
  vias: v2(42.72,13.93) v3(113.92,15.61)
0D95V_VGA_EN: length 25.9
  TOP w0.127: PR8603.1 155.66,58.53 157.78,58.53 v2(159,57.31) 159.02,57.33 161.47,57.33 161.94,57.8 166.18,57.8 166.42,58.04 166.87,58.04 v1(167.73,58.9)
  L3 w0.127: v1(175.9,62.27) 172.93,62.27 172.32,62.88 170.66,62.88 168.33,60.54 168.33,59.49 v1(167.73,58.9)
  BOTTOM w0.127: v1(175.9,62.27) 175.74,62.11 PR8621.1 174.94,62.16 PR8625.2
0D95V_VGA_EN_R: length 24.8
  TOP w0.127: v1(167.08,57.32) 166.65,57.32 166.4,57.06 v2(164.9,57.06) 162.23,57.06 161.18,56 160.76,56 160.35,56.41 157.97,56.41 157.37,55.81 D8601.2
  L3 w0.127: v1(174.18,60.48) 173.91,60.76 169.23,60.76 168.87,60.4 168.87,57.94 168.04,57.11 167.29,57.11 v1(167.08,57.32)
  BOTTOM w0.127: PR8621.2 PC8607.1 174,60.66 v1(174.18,60.48) 174.18,60.02 174.78,59.42 PU8601.7
0D95V_VGA_S0: length 4.5
  TOP w0.508: R7705.1 177.6,68.9 v1(177.95,68.54)
  BOTTOM w0.508: L8003.1 163.44,80.19 164.57,79.06 v1(165.76,79.06)
  vias: v1(171.03,83.24) v1(171.48,82.06) v1(171.85,84.32) v1(171.83,83.22) v1(171.83,80.81) v1(171.86,79.66) v1(172.28,83.72) v2(170.97,66.56) v3(172.47,69.33) v3(173.48,69.33)
0D95V_VGA_S0_PG: length 78.9
  L3 w0.127: v1(209.35,116.7) 209.54,116.51 209.54,114.79 209.64,114.69 209.64,113.71 209.54,113.61 209.54,103.41 207.33,101.2 204.66,101.2 198.83,95.37 198.83,94.83 194.94,90.94 194.94,85.42 191.71,82.18 191.71,81.77 191.15,81.2 191.15,76.68 188.34,73.87 188.34,71.9 185.71,69.27 185.71,69.27 185.1,68.65 184.64,68.65 183.31,67.33 183.31,66.93 181.93,65.54 181.93,63.42 183.58,61.77 183.58,61.14 182.24,59.8 178.82,59.8 178.56,59.55 178.1,59.55 v1(178.05,59.5)
  BOTTOM w0.127: v2(209.52,116.14) 209.52,116.52 v1(209.35,116.7) PG8655.1 ; PU8601.2 177.28,59.42 177.98,59.42 v1(178.05,59.5) 178.1,59.55 178.63,59.55 PR8624.2
1D0V_PWR:
  vias: v2(37.06,19.87) v3(37.01,23.66) v3(36.98,22.64) v3(36.98,21.63) v3(37.92,23.66) v3(37.92,22.62) v3(37.92,21.6)
1D0V_S5: length 141.1
  TOP w0.305: XDP1.43 60,98.36 v1(59.94,98.41) ; v1(59.54,93.11) 59.54,92.59 60,92.13 XDP1.44
  L3 w0.508: v1(74.42,111.87) 72.01,109.46 72.01,106.39 70.94,105.32 63.83,105.32 62.74,106.41 61.09,106.41 60.43,105.75 60.43,98.89 v1(59.94,98.41) 60.27,98.08 60.27,93.89 59.54,93.16 v1(59.54,93.11) 59.54,92.99 59.56,92.98 59.56,90.06 59.8,89.82 59.8,88.28 60.86,87.23 60.86,85.2 v1(57.84,82.18)
  L4 w0.508: v3(147.52,89.52) 147.45,89.6 147.45,92.01 141.56,97.9 118.9,97.9 116.86,99.93 109.81,99.93 109.28,100.47 107.53,100.47 103.42,104.58 103.42,108.72 102.05,110.09 101.46,110.09 99.95,111.61 99.95,113.66 99.58,114.03 98.68,114.03 97.94,113.29 93.01,113.29 92.74,113.02 92.18,113.02 91.9,113.29 89.95,113.29 89.8,113.14 87.88,113.14 85.37,110.62 83.43,110.62 82.96,110.16 78.94,110.16 78.24,110.86 75.68,110.86 74.67,111.87 v1(74.42,111.87)
  BOTTOM w0.508: v1(57.84,82.18) 57.66,82.36 R9927.1
  vias: v1(148.26,89.42) v1(156.9,79.36) v1(165,61.1) v2(39.15,16.9) v2(146.43,88.3) v3(34.29,17.38) v3(35.18,17.38) v3(36.07,17.38) v3(36.96,17.38) v3(37.84,17.39) v3(146.63,89.11) v3(155.96,79.23) v3(156.62,78.57) v3(165.13,62.7) v3(165.18,61.83) v3(176.16,43.17) v3(177.09,43.17) v3(177.98,43.17) v3(178.87,43.17) v3(179.74,43.15)
1D0V_S5_PWRGD: length 2.1
  TOP w0.127: PR5305.1 49.15,26.47 v2(49.15,25.51) 49.97,25.51 R4029.1
1D2V_S3: length 276.1
  TOP w0.508: R505.1 v1(146.3,55.61) ; 86.11,57.64 81.79,57.64 v1(80.39,56.25)
  L3 w0.381: v1(185.05,25.26) 179.86,20.07 179.86,15.73 179.17,15.05 179.17,13.94 178.55,13.32 v1(178.53,13.32) ; v1(146.3,55.61) 146.39,55.52 146.54,55.52 146.88,55.19 146.88,51.84 146.44,51.4 146.44,46.91 v1(146.38,46.85)
  L6 w0.381: v1(185.05,25.26) 185.05,25.88 185.15,25.99 185.15,27.44 184.86,27.74 184.86,37.58 183.96,38.48 183.96,40.43 184.78,41.26 v1(184.78,41.49)
  BOTTOM w0.127: CPU1.BB47 105.48,64.4 105.48,63.12 v1(105.34,62.98) ; v1(114.19,63.38) 114.19,64.4 CPU1.BB32 ; CPU1.BB51 102.86,64.24 102.86,62.11 101.75,61 v1(101.75,60.72)
  BOTTOM w0.254: v1(108.84,62.05) 108.98,62.2 108.98,63.1 109.04,63.16 109.04,64.39 CPU1.BB41 ; CPU1.AU23 118.63,66.88 118.63,66.88 v1(118.68,66.83) ; DM2.123 152.23,19.6 152.23,18.05 152.22,18.05 ; CPU1.BB23 119.09,64.45 119.13,64.32 119.16,64.28 119.16,63.56 v1(119.36,63.36) ; v1(87.38,13.7) 87.04,13.7 86.6,13.26 86.6,12.38 86.59,12.37 86.59,12.3 86.47,12.18 DM1.160 ; v1(79.97,12.94) DM1.142 ; CPU1.AU28 115.48,67.2 v1(115.15,66.86) ; v1(72.01,12.94) 72.48,12.47 72.48,11.4 DM1.112 ; v1(149.15,16.19) 149.07,16.19 148.51,16.75 148.51,17.54 149.23,18.25 149.23,19.6 DM2.111 ; DM2.96 145.48,11.4 145.48,12.61 145.46,12.62 145.46,13.2 v1(145.41,13.25)
  BOTTOM w0.305: DM2.130 153.98,13.39 v1(153.97,13.4) ; v1(90.62,13.81) 90.74,13.68 90.74,12.76 90.97,12.53 DM1.178 ; v1(139.77,17.38) 139.9,17.38 140.23,17.71 140.23,17.93 140.23,17.94 140.23,18.36 140.23,18.36 DM2.75 ; v1(107.24,21.12) 106.72,20.6 DM1.241 ; DM2.141 156.73,20.11 156.66,20.17 156.66,20.72 156.44,20.94 155.39,20.94 v1(155.36,20.97) ; DM1.33 52.72,16.51 v1(52.2,15.99) ; DM1.12 47.47,14.69 v1(48.51,15.73) ; v1(159.64,16.95) 159.74,16.95 160.23,17.44 160.23,19.6 DM2.147 ; v1(74.6,16.04) 75.47,16.04 76.73,17.3 DM1.129 ; CPU1.AU35 111.76,67.2 v1(111.43,67.53) ; DM2.117 150.73,18.17 150.57,18.01 150.57,17 150.99,16.57 v1(151.11,16.57) ; 152.22,18.05 152.11,17.94 152.11,17.49 152.55,17.05 v1(152.63,17.05) ; v1(107.8,66.87) 107.91,66.87 CPU1.AU42 ; v1(74.96,13.57) 75.03,13.5 75.1,13.5 75.47,13.12 DM1.124 ; DM2.159 163.22,18.15 163.47,17.9 163.47,17.05 v1(164,16.52) 164.56,17.08 164.56,18.12 164.22,18.46 DM2.163 ; DM2.33 129.72,18.21 129.81,18.13 129.81,16.81 v1(130.58,16.04) ; v1(154.93,17.13) 155.17,17.13 155.47,17.43 155.47,18.26 155.23,18.5 155.23,19.6 DM2.135 ; v1(156.76,13.07) 156.77,13.07 156.98,12.86 DM2.142 ; DM2.153 v1(161.73,21.07) ; DM2.112 149.47,12.54 148.79,13.22 v1(148.79,13.33) ; DM1.136 78.48,11.4 78.48,12.98 v1(78.48,13.09) ; v1(73.08,17.79) 73.08,18.01 73.59,18.53 73.59,18.55 73.73,18.69 DM1.117 73.73,20.58 73.91,20.77 74.97,20.77 75.22,20.52 DM1.123 ; v1(119.49,70.89) 119.47,70.89 119.43,70.93 CPU1.AL23 ; DM1.147 83.16,19.54 83.16,16.65 84.48,15.33 v1(84.68,15.33) ; DM2.148 160.48,11.4 160.48,13.32 v1(160.47,13.32) ; DM1.130 76.97,12.42 77.04,12.48 77.04,13.15 76.61,13.57 v1(76.56,13.57) ; v1(79.76,16.37) 80.39,17 80.39,17.89 79.73,18.56 DM1.141 ; DM2.220 178.48,13.26 v1(178.53,13.32) ; v1(134.96,13.14) 134.98,13.12 DM2.54 ; DM2.136 155.47,12.48 155.52,12.53 155.52,15.03 154.94,15.61 v1(154.94,15.62) ; v1(161.97,13.06) 161.98,13.06 DM2.154 ; v1(151.94,13.75) 152.02,13.75 152.47,13.3 DM2.124 ; DM2.129 153.73,16.04 153.21,15.53 v1(152.57,15.53) ; DM2.241 183.73,20.8 182.44,22.08 174.65,22.08 173.22,20.66 DM2.199 173.22,18.15 173.23,18.14 173.23,17.72 173.22,17.72 173.22,17.56 172.92,17.26 v1(172.79,17.26) ; DM2.178 167.98,12.75 167.95,12.78 167.95,13.33 168.35,13.73 v1(168.5,13.73) ; v1(58.69,13.09) 57.97,12.38 DM1.54 ; DM1.135 78.22,17.8 78.64,17.38 78.64,16.9 v1(77.98,16.24) ; DM2.118 150.98,13.27 150.48,13.76 v1(150.36,13.76) ; v1(68.47,13.09) DM1.96 ; DM1.111 v1(72.22,20.9) ; DM1.220 101.48,12.83 101.4,12.91 101.4,13.6 v1(101.32,13.68) ; v1(83.36,12.94) 83.36,12.91 83.48,12.8 83.48,11.4 DM1.148 ; v1(124.15,14.32) 124.15,13.22 124.21,13.16 124.21,12.86 124.47,12.6 DM2.12 ; DM1.154 v1(84.97,12.94) ; DM1.118 73.97,13.13 73.41,13.7 v1(73.28,13.7) ; DM1.159 86.22,16.99 87.19,16.02 87.31,16.02 v1(87.43,15.89) ; DM2.160 163.47,12.56 163.52,12.61 v1(163.52,13.07) ; DM1.75 63.22,20.55 62.88,20.89 v1(62.88,20.95) ; v1(84.63,17.28) 84.78,17.43 84.79,17.43 85.09,17.73 85.09,17.76 85.11,17.78 85.11,18.21 84.73,18.6 DM1.153 ; DM1.163 87.22,17.45 87.46,17.21 v1(87.46,17.21) ; v1(95.89,16.62) 96.22,16.96 DM1.199
  BOTTOM w0.356: 85.09,53.4 85.22,53.4 85.42,53.59 RN1301.1
  BOTTOM w0.381: 85.09,53.4 83.24,53.4 v2(81.22,55.42) v1(80.39,56.25) ; v1(146.38,46.85) 146.51,46.85 149.28,44.08 166.35,44.08 166.7,44.44 168.02,44.44 168.05,44.46 171.86,44.46 172.67,43.65 172.9,43.65 173.63,42.91 173.63,42.91 175.85,40.69 178.64,40.69 179.18,41.23 184.51,41.23 184.76,41.49 v1(184.78,41.49)
  BOTTOM w0.508: C1319.1 109.21,54.35 v1(108.04,55.51)
  vias: v1(70.89,16.03) v1(72.01,14.21) v1(73.03,16.42) v1(74.62,17.31) v1(74.96,14.84) v1(81.1,15.92) v1(81.1,13.78) v1(98.5,55.76) v1(98.68,58.02) v1(99.97,59.4) v1(100.15,57.36) v1(100.15,55.43) v1(101.87,58.18) v1(102.07,55.64) v1(104.06,60.34) v1(104.11,58.36) v1(104.21,56.45) v1(106.41,56.58) v1(106.47,59.92) v1(106.47,57.97) v1(108.04,60.06) v1(108.04,58.76) v1(108.04,57.45) v1(132.91,15.12) v1(147.11,16.5) v1(148.16,14.42) v1(150.57,15.33) v1(152.81,14.59) v1(153.9,14.72) v1(156.69,15.07) v1(157.73,15.73) v1(159.69,15.61) v1(160.52,15.76) v1(161.87,17.05) v1(161.9,15.73) v1(161.95,14.39) v2(72.17,25.4) v2(94.41,47.43) v2(99.2,25.34) v2(109.28,49.9) v2(126.62,24.54) v2(167.88,20.6) v3(58.8,24.62) v3(58.8,23.73) v3(58.93,25.51) v3(59.69,25.89) v3(59.69,25) v3(66.93,52.82) v3(67.94,52.82) v3(67.94,51.93) v3(68.83,51.93) v3(69.09,52.82) v3(69.82,51.97) v3(70.23,52.82) v3(70.74,47.36) v3(71.63,48.12)
1D2V_VTT_PWRGD: length 208.2
  TOP w0.127: v1(57.18,66.81) 57.4,67.04 57.73,67.04 PG5114.1 ; v1(168.5,31.54) 167.07,31.54 166.78,31.84 v2(165.07,31.84) 156.99,31.84 149.16,39.67 146.02,39.67 125.24,39.67 119.55,33.98 118.24,33.98 57.26,33.98 57.05,34.19 57,34.24 55.78,34.24 v1(55.37,34.64)
  L3 w0.127: v1(168.5,31.54) 168.6,31.44 184.38,31.44 184.41,31.42 189.76,31.42 v1(189.94,31.6)
  L4 w0.127: v1(57.18,66.81) 57.4,67.04 58.93,67.04 64.9,61.07 64.9,58.28 62.89,56.27 61.47,56.27 60.7,55.51 60.7,55.11 61.34,54.47 61.34,51.29 61.37,51.27 61.37,48.31 62.08,47.6 62.08,45.42 62.13,45.37 62.13,43.9 62.13,43.9 62.13,43.65 61.72,43.24 60.93,43.24 60.6,42.91 60.6,40.57 56.64,36.61 56.36,36.61 55.44,35.69 55.44,34.82 55.37,34.76 v1(55.37,34.64)
  BOTTOM w0.127: R4011.1 192.53,10.68 191.62,11.59 191.62,16.11 191.07,16.66 191.07,24.99 191.11,25.03 191.11,29.96 191.07,29.99 191.07,30.61 190.09,31.59 189.94,31.59 v1(189.94,31.6)
1D5V_VGA_S0: length 115.7
  TOP w0.305: 183.81,103.29 183.83,103.29 VRAM4.C9 ; 183.81,103.29 VRAM4.D9 ; 183.81,103.29 182.85,103.29 v1(182.77,103.21) ; v1(169.47,113.29) 168.67,112.5 VRAM1.R1 ; v1(166.92,106.5) VRAM1.H2 v1(167.72,107.3) ; v1(190.22,107.3) VRAM4.H2 v1(189.42,106.5) ; VRAM1.K8 v1(162.12,108.1) ; VRAM1.E9 161.51,104.5 161.41,104.61 160.6,104.61 160.32,104.89 v1(160.27,104.89) ; v1(160.32,113.29) 161.12,112.5 VRAM1.R9 ; v1(183.01,106.96) 183.06,106.9 VRAM4.H9 v1(184.62,107.3) ; VRAM4.F1 190.98,104.94 191.69,104.94 v1(191.77,105.01) ; VRAM1.N1 168.67,110.9 v1(169.47,111.69) ; v1(182.77,104.89) 182.82,104.89 183.1,104.61 183.91,104.61 183.93,104.59 184.13,104.59 VRAM4.E9 ; v1(182.82,111.69) 183.62,110.9 VRAM4.N9 ; VRAM4.K8 v1(184.62,108.1) ; v1(169.09,103.19) 168.8,102.9 VRAM1.C1 VRAM1.D2 ; v1(191.18,101.18) 191.06,101.3 VRAM4.A1 ; v1(162.12,107.3) VRAM1.H9 v1(160.2,106.9) ; v1(191.62,103.24) 191.28,102.9 VRAM4.C1 VRAM4.D2 ; VRAM1.F1 168.48,104.94 v1(168.83,104.94) ; v1(191.97,111.69) 191.17,110.9 VRAM4.N1 ; VRAM1.A1 v1(168.72,101.3) ; VRAM1.K2 v1(167.72,108.1) ; 161.23,103.21 v1(160.27,103.21) ; 161.23,103.21 161.41,103.21 VRAM1.C9 ; 161.23,103.21 VRAM1.D9 ; VRAM4.R1 191.17,112.5 v1(191.97,113.29) ; VRAM1.N9 161.12,110.9 v1(160.32,111.69) ; v1(184.62,101.7) 184.86,101.46 VRAM4.A8 ; VRAM1.B2 v1(166.92,101.7) ; v1(189.43,101.69) 189.49,101.74 189.49,101.77 VRAM4.B2 ; VRAM4.G7 v1(185.42,106.5) ; VRAM4.K2 v1(190.22,108.1) ; VRAM1.A8 v1(162.12,101.7) ; VRAM4.R9 183.62,112.5 v1(182.82,113.29) ; VRAM1.G7 v1(162.92,106.5)
  TOP w0.508: R7817.1 165.69,81.95 164.82,82.81 v1(163.73,82.81)
  L3 w0.508: v1(163.73,82.81) 163.93,82.61 164.64,82.61 165.33,83.3 168.4,83.3 170.65,85.54 v1(171.36,85.54)
  L4 w0.508: v1(168.72,101.3) 168.55,101.47 168.5,101.47 168.28,101.7 v1(166.92,101.7) ; v1(160.27,103.21) 160.27,102.09 161.06,101.3 v1(161.11,101.3)
  L6 w0.508: v1(191.18,101.18) 191.06,101.3 190.93,101.3 190.55,101.69 v1(189.43,101.69) ; v1(184.62,108.1) v1(184.62,107.3) ; v1(183.61,101.3) VRAM3.A1 v1(184.62,101.7) 184.62,101.97 183.38,103.21 v1(182.77,103.21) ; v1(190.22,108.1) v1(190.22,107.3) ; v1(167.72,108.1) v1(167.72,107.3) ; v1(162.12,108.1) v1(162.12,107.3)
  BOTTOM w0.305: v1(160.27,104.89) 160.6,105.22 161.64,105.22 VRAM2.F1 ; VRAM4.N9 183.62,110.9 v1(182.82,111.69) ; v1(191.97,111.69) 191.17,110.9 VRAM4.N1 ; v1(191.87,107.33) 191.44,106.9 VRAM3.H9 v1(190.22,107.3) ; v1(184.62,107.3) VRAM3.H2 v1(185.42,106.5) ; VRAM3.B2 v1(184.62,101.7) ; v1(166.92,101.7) 167.18,101.44 VRAM2.A8 ; v1(182.82,113.29) 183.62,112.5 VRAM4.R9 ; VRAM1.K2 v1(167.72,108.1) ; v1(160.32,113.29) 161.12,112.5 VRAM1.R9 ; v1(169.22,106.98) 169.14,106.9 VRAM2.H9 v1(167.72,107.3) ; VRAM3.D2 VRAM4.C9 183.91,103.21 v1(182.77,103.21) ; VRAM3.A8 v1(189.43,101.69) ; VRAM3.F1 184.14,105.22 183.1,105.22 v1(182.77,104.89) ; VRAM4.C1 191.28,102.9 v1(191.62,103.24) 191.5,103.36 191.19,103.36 191.18,103.36 190.96,103.36 VRAM3.D9 ; VRAM2.E9 168.4,104.5 v1(168.83,104.94) ; VRAM4.K2 v1(190.22,108.1) ; v1(191.97,113.29) 191.17,112.5 VRAM4.R1 ; v1(161.11,101.3) VRAM2.A1 v1(162.12,101.7) VRAM2.B2 ; VRAM3.G7 v1(189.42,106.5) ; v1(162.92,106.5) VRAM2.H2 v1(162.12,107.3) ; GPU1.H13 179.76,87.44 179.34,87.44 v1(179.33,87.43) ; VRAM1.R1 168.67,112.5 v1(169.47,113.29) ; VRAM1.N1 168.67,110.9 v1(169.47,111.69) ; VRAM1.N9 161.12,110.9 v1(160.32,111.69) ; VRAM2.G7 v1(166.92,106.5) ; GPU1.H16 177.69,87.6 v1(178,87.91) ; v1(160.27,103.21) 160.58,102.9 VRAM1.C9 162.12,103.3 VRAM2.D2 ; VRAM4.K8 v1(184.62,108.1) ; VRAM1.K8 v1(162.12,108.1) ; v1(191.77,105.01) 191.41,105.01 191.2,104.8 190.92,104.8 VRAM3.E9 ; VRAM2.D9 168.34,103.7 168.86,103.19 v1(169.09,103.19) 168.8,102.9 VRAM1.C1 ; VRAM3.A1 v1(183.61,101.3)
  BOTTOM w0.356: GPU1.J10 182.12,86.76 v1(181.71,86.35) 182.06,86 GPU1.K10 ; GPU1.J9 182.53,86.41 v1(182.53,86.39) 182.53,86.39 GPU1.K9 ; GPU1.L13 179.51,85.39 v1(179.82,85.39) 180.07,85.39 180.2,85.25 180.28,85.2 GPU1.L12 ; v1(175.75,87.12) 175.24,87.51 175.21,87.51 GPU1.H19 ; v1(181.81,85.45) 181.56,85.2 GPU1.L11
  BOTTOM w0.508: R7810.1 v1(163.73,82.81)
  vias: v1(171.32,86.4) v1(172.09,85.55) v1(173,85.53) v1(173.42,110.47) v1(174.02,85.45) v1(189.61,119.62) v1(190.5,121.14) v1(190.5,120.38) v1(190.5,119.62) v2(171.16,91.16) v2(176.17,101.39) v2(177.02,111.16) v2(179,125.01) v2(180.75,117.34) v2(181.72,91.03) v3(170.81,118.86) v3(172.09,118.86) v3(173.35,118.86) v3(174.62,118.86)
1D8V_EN#: length 4.5
  BOTTOM w0.127: R2733.1 42.31,5.64 R2715.2 42.27,5 41.75,5 v2(41.42,4.67) 41.24,4.49 Q2702.D
1D8V_EN_R#: length 12.1
  BOTTOM w0.127: C2722.2 43.33,5.77 R2733.2 43.21,6.59 42.14,6.59 v2(41.57,6.02) 41.19,5.64 37.97,5.64 37.26,6.34 37.26,6.84 36.92,7.17 35.4,7.17 Q2701.G
1D8V_PWR:
  vias: v2(164.36,51.98)
1D8V_S0: length 14.6
  TOP w0.508: R2726.1 v1(29.66,5.12) ; v1(34.77,5.32) 34.59,5.5 34.59,6.06 v2(34.19,6.46) 34.19,6.59 33.36,7.41 R2713.1
  BOTTOM w0.508: v1(29.66,5.12) 29.66,4.79 30.38,4.07 33.96,4.07 34.99,3.04 C2725.1 35.93,4.17 Q2701.D 35.6,4.49 v1(34.77,5.32)
1D8V_S5: length 250.8
  TOP w0.508: PR8650.1 149.48,54.47 PC8635.1 148.49,54.47 148.2,54.18 148.2,54.14 PQ8607.S 148.12,52.16 150.73,52.16 152.58,54.01 158.17,54.01 v3(159,54.85)
  L3 w0.508: v1(45.47,5.73) 45.77,5.42 64.32,5.42 64.4,5.34 66.01,5.34 68.33,3.03 111.62,3.03 114.28,5.7 114.81,5.7 115.06,5.45 117.81,5.45 118.35,4.91 119.41,3.85 131.36,3.85 132.69,5.18 132.69,5.37 134.67,7.35 137.67,7.35 138.52,8.21 144.29,8.21 145.53,9.44 175.4,9.44 175.7,9.14 183.97,9.14 184.27,9.44 188.15,9.44 188.71,10.01 188.71,11.28 189.03,11.59 192.87,11.59 193.24,11.96 193.24,12.49 192.06,13.68 187.55,13.68 186.79,14.44 186.79,18.19 186.76,18.21 186.76,21.6 v1(187.12,21.96) ; v3(159,54.85) 159,53.54 166.38,46.16 167.28,46.16 168.99,44.46 170.05,44.46 170.84,43.67 171.71,43.67 173.49,41.89 v1(173.49,41.64)
  L6 w0.508: v1(187.12,21.96) 186.82,21.96 182.28,26.5 182.28,28.9 182.21,28.97 182.21,29.22 178.31,33.12 178.31,33.13 176.28,35.16 176.28,39.1 173.74,41.64 v1(173.49,41.64)
  BOTTOM w0.508: v1(45.47,5.73) 45.47,5.12 v2(45.11,4.76) 44.71,4.35 44.32,4.35 C2724.1 43.38,4.23 C2722.1 43.3,4.15 R2715.1 41.35,3.19 38.4,3.19 36.6,4.99 Q2701.S ; v3(159.26,55.87) 158.88,56.25 158.88,58.61 R1139.1
  vias: v2(164.67,55.67) v3(162.81,54.09) v3(163.68,54.01)
1D8V_S5_PWROK: length 2.2
  TOP w0.127: PR5414.1 159.7,40.82 v2(159.64,40.75) 159.64,40.5 160.15,39.99 R4030.1
1D8V_VGA_EN: length 6.5
  TOP w0.127: D8601.1 155.4,56.04 154.55,56.89 PQ8608.G 153.56,58 PC8612.1 154.14,58.58 PR8603.2 154.72,59.51 v2(154.74,59.52)
1D8V_VGA_EN#: length 4.6
  TOP w0.127: PR8651.1 150.61,56.25 151.86,54.99 PQ8608.D ; PR8651.1 PR8650.2 ; PR8651.1 v2(150.37,57.24)
1D8V_VGA_EN_R#: length 3.3
  TOP w0.127: PQ8607.G 149.98,53.11 v2(150.29,53.43) 150.37,53.5 PC8634.2 PR8651.2
1D8V_VGA_S0: length 130.5
  TOP w0.381: R7704.1 182.41,74.47 182.41,76.35 182.75,76.69 183.64,76.69 v1(184.12,77.18)
  TOP w0.508: C8017.1 174.61,77.31 v1(174.19,76.9) ; PR8546.1 v1(205.61,56.5)
  TOP w0.635: v1(184.12,77.18) 183.77,77.53 183.77,77.53 R7930.1 ; PQ8607.D 153.84,51.21 155.73,53.09 159.71,53.09 161.21,54.6 v2(161.29,54.6) 161.59,54.6 163.45,56.45 164.63,56.45 164.64,56.44 165.15,56.44 165.17,56.45 167.92,56.45 168.45,56.98 168.45,59.98 165.93,62.51 165.93,63.03 165.48,63.47 165.48,68.47 v1(166.55,69.54) 166.88,69.87 169.79,69.87 v1(170.15,69.5) ; 175.77,73.77 176.02,74.02 177.26,74.02 177.49,74.24 178.72,74.24 178.83,74.13 182.06,74.13 R7704.1
  L3 w0.508: v1(195.45,72.58) v1(191.39,72.58)
  L3 w0.635: v1(201.65,88.94) 201.63,88.91 199.75,88.91 193.23,82.39 193.23,79.96 192.41,79.13 192.41,73.59 v1(191.39,72.58) ; v1(175.13,69.23) 173.82,70.53 170.95,70.53 170.15,69.73 v1(170.15,69.5) ; v1(175.78,75.33) 174.21,76.9 v1(174.19,76.9)
  L4 w0.508: v1(195.45,72.58) 195.45,66.48 196.85,65.09 196.85,62.5 197.77,61.58 202.47,61.58 203.59,60.46 203.76,60.46 204.62,59.6 204.62,58.18 205.61,57.19 v1(205.61,56.5)
  L4 w0.635: v1(184.12,77.18) 184.45,77.5 186.29,77.5 186.44,77.65 188.7,77.65 191.01,75.34 191.01,72.96 v1(191.39,72.58)
  BOTTOM w0.305: RN7905.3 191.84,72.8 191.62,72.58 v1(191.39,72.58) 191.19,72.78 RN7905.4
  BOTTOM w0.356: v1(166.55,69.54) GPU1.AM30 ; GPU1.AD17 176.31,74.8 v1(175.78,75.33)
  BOTTOM w0.508: L8001.1 202.76,89.57 202.12,88.94 v1(201.65,88.94) ; L8001.1 L8002.1 ; L8001.1 203.94,89.77 C8002.1
2D5V_S3:
  vias: v1(112.01,22.21) v1(112.06,21.42) v1(112.09,20.58) v1(112.06,19.82) v1(188.85,20.66) v1(188.82,20) v1(188.8,19.31) v2(66.17,5.83) v3(65.28,7.1) v3(66.12,7.07) v3(112.75,11.26) v3(113.66,11.27)
3D3V_AUX_KBC_33: length 10.6
  TOP w0.203: KBC24.54 206.72,37.79 206.88,37.96 206.88,38.34 v1(206.76,38.47)
  BOTTOM w0.508: R2462.1 210.25,41.58 v2(209.93,41.9) 209.11,42.72 C2423.1 207.65,41.86 207.65,39.42 207.54,39.31 207.54,39.26 206.76,38.48 v1(206.76,38.47)
3D3V_AUX_KBC_R: length 4.1
  TOP w0.305: DB3.1 282.6,44.16
  TOP w0.508: v2(280.95,44.71) 281.52,44.71 v1(281.62,44.82) 281.94,44.82 282.6,44.16
  BOTTOM w0.508: R2476.1 v1(281.62,44.82)
3D3V_AUX_S5: length 424
  TOP w0.356: PG4507.1 56.69,41.7 v1(56.62,41.77)
  TOP w0.508: v1(211.38,20.05) 211.24,19.91 R2467.1 ; v1(46.74,51.93) 46.91,52.11 R4004.1 ; R6211.1 87.25,108.95 87.38,109.08 v1(87.38,109.97) ; PR4420.1 229.54,21.12 v1(229.49,21.07) ; PR4421.1 v1(238.61,22.21) ; R6102.1 49.03,66.21 v1(49.4,65.84)
  L3 w0.508: v1(152.22,72.83) 152.22,73.15 150.34,75.03 149.87,75.03 ; 149.87,75.03 149.56,75.35 149.56,75.43 149.18,75.8 148.62,75.8 146.08,78.35 146.08,81.19 143.64,83.62 v1(143.64,86.15) ; 149.87,75.03 149.87,72.37 150.24,71.99 150.24,69.61 152.2,67.65 152.2,66.33 v1(151.89,66.03) ; v1(225.7,42.45) 227.89,40.26 231.62,40.26 233.3,38.58 233.3,36.68 233.33,36.65 233.33,33.56 235.33,31.57 235.33,30.81 238.61,27.53 238.61,25.59 238.96,25.23 238.96,24.67 238.61,24.32 v1(238.61,22.21) ; v1(74.68,110.6) 75.44,109.84 75.44,107.81 75.69,107.55 75.69,104.13 73.41,101.84 73.41,99.83 69.14,95.56 69.14,94.09 67.97,92.93 67.97,92.33 67.6,91.96 67.19,91.96 65,89.77 65,89.02 65.7,88.33 66.59,87.43 66.59,86.07 59.44,78.91 59.44,75.81 57.98,74.35 57.98,73.83 58.35,73.45 58.82,73.45 59.41,72.87 59.41,71.96 57.91,70.46 v1(57.91,68.44)
  L4 w0.508: v1(225.7,42.45) 225.7,43.07 224.79,43.99 223.39,43.99 218.47,48.91 215.49,48.91 210.55,53.85 195.03,53.85 193.18,55.7 192.39,55.7 192.23,55.87 191.34,55.87 191.15,56.06 190.56,56.06 189.56,57.06 187.95,57.06 187.02,56.13 185.31,56.13 184.28,55.1 179.06,55.1 178.7,54.74 171.74,54.74 171.07,55.41 167.41,55.41 160.63,62.19 159.16,62.19 156.92,64.43 156.92,65.16 156.05,66.03 v1(151.89,66.03) ; v1(74.68,110.6) 74.79,110.6 75.17,110.22 77.97,110.22 77.98,110.21 77.98,110.2 78.66,109.51 78.69,109.51 79.53,108.67 83.54,108.67 84.84,109.97 85.62,109.97 85.75,110.09 87.25,110.09 v1(87.38,109.97) 87.38,110.36 87.93,110.91 89.97,110.91 91.44,112.38 94.07,112.38 96.36,110.09 99.07,110.09 99.7,109.46 101.79,109.46 102.74,108.5 102.74,104.21 107.12,99.83 109.02,99.83 109.55,99.3 116.6,99.3 118.63,97.27 141.29,97.27 145.39,93.17 145.39,89.8 143.64,88.05 v1(143.64,86.15) ; v1(49.4,65.84) 49.4,65.23 48.04,63.87 47.43,63.87 46.01,62.44 42.48,62.44 41.25,61.21 41.25,59.49 42.69,58.05 45.48,58.05 46.91,56.61 46.91,52.11 v1(46.74,51.93) 48.67,51.93 50.72,49.87 56.08,49.87 58.47,47.48 58.47,46.44 57.53,45.5 57.53,42.68 v1(56.62,41.77)
  L6 w0.508: v1(211.38,20.05) 212.01,20.69 212.71,20.69 213.08,20.31 213.08,18.68 213.26,18.5 213.26,17.91 214.33,16.84 214.33,16.05 214.7,15.68 215.72,15.68 218.44,12.96 218.44,12.96 218.81,12.58 218.82,12.58 219.98,11.43 225.04,11.43 226.57,9.9 226.57,9.75 227.52,8.8 229.21,8.8 229.59,9.18 v1(230.35,9.18) ; v1(49.4,65.84) 49.85,65.39 52.2,65.39 54.51,67.7 57.15,67.7 57.89,68.44 v1(57.91,68.44)
  BOTTOM w0.508: R1737.1 152.22,72.15 v1(152.22,72.83) ; v1(151.89,66.03) 151.89,66.34 R1727.1 152.67,66.33 154.86,66.33 155.19,66.66 R1726.2 ; D2501.1 228.06,40.1 226.62,41.54 v1(225.7,42.45) ; v1(229.49,21.07) 229.69,20.86 236.76,20.86 238.11,22.21 v1(238.61,22.21) 238.61,12.66 236.96,11.01 236.96,9.48 236.58,9.1 235,9.1 234.37,9.74 234.37,11.42 234.09,11.69 231.9,11.69 230.73,10.53 230.73,9.56 v1(230.35,9.18) 230.35,8.09 v2(229.37,7.1) 228.04,5.78 R2472.2
3D3V_CAMERA_S0: length 11.8
  TOP w0.508: v1(43.56,77.96) 43.56,78.53 FC5503.1
  BOTTOM w0.305: LCD1.32 44.15,76.48 43.81,76.82 43.81,77.58 43.56,77.84 v1(43.56,77.96)
  BOTTOM w0.508: R5532.2 44.5,84.24 v2(44.37,84.11) 44.37,82.98 C5539.1 44.22,78.76 43.69,78.23 43.69,78.09 v1(43.56,77.96)
3D3V_CPM_Z32H: length 24.9
  TOP w0.305: v1(85.72,8.77) 85.6,8.64 U9102.25 ; U9102.20 86.06,5.55 87.22,5.55 v1(87.25,5.57) ; v1(82.17,2.39) 82.1,2.46 U9102.9
  TOP w0.508: v1(82.17,2.39) 82.79,1.76 87.76,1.76 88.66,2.66 R9123.1 88.66,5.08 89.05,5.47 C9107.1 ; C9107.1 88.37,5.98 88.14,6.21 87.63,6.21 87.25,5.83 v1(87.25,5.57) ; C9107.1 88.9,6.13 88.9,7.16 R9122.1 88.71,8.35 v2(88.5,8.57) 88.19,8.88 85.83,8.88 v1(85.72,8.77)
  BOTTOM w0.508: v1(82.17,2.39) 82.17,3.4 C9108.1 ; v1(87.25,5.57) 87.04,5.57 86.8,5.34 C9109.1 ; v1(85.72,8.77) 85.98,8.52 85.98,8.07 C9110.1
3D3V_LAN_S5: length 5
  TOP w0.508: v1(49.91,92.7) C3120.1
  BOTTOM w0.203: v1(41.66,93.03) 42.17,93.03 42.2,93.02 LOM31.32 ; LOM31.11 43.6,97.91 43.58,97.93
  BOTTOM w0.508: v1(43.43,98.54) 43.58,98.39 43.58,97.93 ; R3103.1 50.47,92.14 v1(49.91,92.7)
  vias: v2(48.79,98.13)
3D3V_MSATA_S0:
  vias: v2(250.44,19.16)
3D3V_RUN_FFS: length 20.8
  TOP w0.305: 106.15,5.98 106.02,5.98 v1(105.69,6.31) ; 106.15,5.98 U6701.2 ; 106.15,5.98 106.15,5.97 106.15,5.62 106.29,5.48 U6701.3 ; U6701.9 109.52,5.98 C6703.1
  TOP w0.406: C6703.1 110.04,6.54 U6701.10
  TOP w0.508: v1(103.48,5.4) 103.48,5.88 v2(104.04,6.44) 105.56,6.44 v1(105.69,6.31) ; C6703.1 v1(110.06,7.3)
  L4 w0.508: v1(103.48,5.4) 102.34,6.54 102.34,7.68 102.95,8.29 105.92,8.29 106.1,8.11 106.8,8.11 106.85,8.06 107.37,8.06 107.4,8.04 109.17,8.04 109.91,7.3 v1(110.06,7.3)
3D3V_S0: length 937.6
  TOP w0.127: RN2002.2 132.03,76 132.18,75.85 132.18,75.47 132.06,75.35 131.67,75.35
  TOP w0.203: RN2002.2 131.34,76 131.23,75.9 131.23,75.49 131.37,75.35 RN2002.1
  TOP w0.305: R2049.2 R2048.2 131.35,74.5 131.35,75.04 RN2002.1 132.13,74.89 134.77,74.89 134.79,74.92 135.92,74.92 136.04,74.79 ; U5601.7 259.96,31.6 259.22,32.35 257.74,32.35 v1(257.61,32.22) ; v1(143.71,69.91) 143.28,70.34 137.54,70.34 137.16,69.96 136.69,69.96 135.03,71.63 133.78,71.63 133.49,71.34 132.62,71.34 132.39,71.56 131.54,71.56 131.03,71.04 131.03,71 R2050.1 ; U5601.10 260.44,30.1 260.12,29.78 259.77,29.78 v1(259.74,29.8) ; U9103.2 v1(71.51,5.24) ; U5601.20 265.82,32.1 266.32,32.6 v1(266.47,32.6) ; v1(138.05,84.69) 138.05,84.4 136.01,82.36 133.57,82.36 132.41,81.19 RN2008.3 ; R2023.1 v1(152.51,68.63)
  TOP w0.33: 213.87,40.65 214.43,40.65 214.62,40.84 215.24,40.84 R2430.2
  TOP w0.356: v1(80.39,5.34) 80.39,4.94 80.04,4.59 U9103.6
  TOP w0.508: v1(241.36,32.24) 241.24,32.37 240.38,32.37 Q9101.G ; v1(148.16,59.03) 148.07,59.03 147.95,58.91 147.49,58.91 147.2,58.91 146.63,58.91 R2017.1 ; R6704.1 107.52,9.99 107.32,10.2 105.08,10.2 ; v1(147.17,72.2) 147.02,72.35 138.48,72.35 136.04,74.79 ; 89.6,9.23 R9122.2 ; 89.6,9.23 89.6,10.12 89.97,10.5 R1211.2 ; 89.6,9.23 89.62,9.25 92.78,9.25 94.03,10.5 99.89,10.5 100.16,10.23 101.46,10.23 101.76,10.53 104.75,10.53 105.08,10.2 ; 138.26,49.77 140.21,49.77 140.65,50.21 R2006.1 R1818.2 ; 105.08,10.2 105.08,8.24 105.36,7.96 ; v1(73.13,50.28) 73.13,50.4 74.34,51.61 R506.1 ; v1(196.11,16.77) 192.68,16.77 191.96,17.49 190.78,17.49 190.31,17.02 v1(188.58,17.02) ; R1609.1 EC9737.1 194.92,8.72 194.56,8.37 193.42,8.37 192.51,9.28 R6517.1 191.85,9.31 v1(191.13,10.02) 191.13,10.91 190.37,11.67 189.93,11.67 R1302.2 ; v1(138.05,84.69) 137.79,84.95 137.79,84.95 135.32,87.42 135.32,89.55 135.14,89.73 135.14,94.16 135.03,94.27 v1(135.03,94.34) ; v1(22.61,80.64) 23.76,80.64 24.27,81.15 FC9705.1 25.42,81.15 28.73,84.46 32.87,84.46 33.93,83.4 ; v1(111.86,16.74) 111.91,16.74 112.29,17.13 112.97,17.13 C1328.1 C1228.1 114.67,17.19 C1329.1 116.43,16.83 R1216.1 117.05,16.83 118.51,15.37 118.51,10.13 119.76,8.87 119.76,6.53 119.39,6.16 115.32,6.16 v1(115.26,6.22) 114.76,6.72 R1208.2 R1204.2 ; v1(24.35,74.66) 23.37,74.66 22.91,75.12 21.13,75.12 v1(20.32,74.31) ; v1(216.03,41.13) 215.65,40.75 R2430.2 ; 105.36,7.96 105.03,7.96 v1(104.47,7.4) ; 105.36,7.96 106.26,8.86 106.6,8.86 R6702.1 ; v1(127.81,51.52) 128.03,51.29 128.78,51.29 129.44,50.63 133.11,50.63 133.21,50.53 134.64,50.53 134.67,50.56 v1(134.67,50.56) ; R1310.2 163.86,10.32 163.73,10.2 v1(163.73,10.17) ; R2731.1 19.56,21.07 v1(19.81,21.32) ; 213.87,40.65 213.36,41.16 213.36,44.54 211.61,46.29 211.61,46.43 211.13,46.91 R2429.2 210.95,47.22 210.91,47.26 210.91,47.52 v1(211.07,47.69) ; DB1.1 287.21,22.01 286.23,22.01 285.65,22.59 285.65,24.1 v1(282.4,27.35) ; v3(19.28,37.55) 20.04,37.55 23.62,41.13 v3(24,41.13)
  L3 w0.508: v1(82.7,95.77) 82.7,96.76 82.07,97.39 78.61,97.39 76.5,95.29 76.5,92.95 v1(75.83,92.27) 76.17,91.93 76.17,89.6 v1(74.96,88.38) ; v1(44.55,6.97) 45.47,6.97 46.33,6.11 64.54,6.11 64.66,5.98 70.76,5.98 v1(71.51,5.24) 71.79,5.24 73.05,3.97 79.02,3.97 v1(80.39,5.34) 80.9,5.34 81.97,4.28 85.97,4.28 86.37,4.68 90.73,4.68 90.83,4.58 100.61,4.58 102.36,6.34 103.62,6.34 104.14,6.86 104.14,7.07 v1(104.47,7.4) ; v1(147.01,50.72) 148.05,51.76 148.05,56.02 145.87,58.21 v1(145.87,61.01) ; v1(152.81,120.89) 155.7,117.99 155.7,115.45 154.15,113.9 154.15,110.82 142.22,98.89 139.58,98.89 v1(135.03,94.34) ; v1(198.56,12.49) 201.59,9.47 204.3,9.47 206.02,11.19 211.06,11.19 212.45,9.8 212.45,9.73 212.82,9.36 212.96,9.36 214.26,8.06 223.76,8.06 225.6,6.22 225.6,6.21 226.97,4.84 234.62,4.84 235.58,5.8 235.61,5.8 235.88,6.07 237.6,6.07 241.63,10.09 244.58,10.09 245.75,11.26 245.75,16.11 249.17,19.54 249.17,23.28 v3(249,23.45) ; v1(134.67,50.56) 136.89,50.56 138.43,52.11 139.09,52.11 140.09,53.11 140.09,53.49 141.73,55.13 v1(141.73,55.23) ; v1(188.09,54.95) v1(195.33,54.95) 195.33,55.18 195.88,55.74 196.6,55.74 197.1,55.23 197.1,53.88 200.32,50.67 205.8,50.67 208.86,47.61 211,47.61 v1(211.07,47.69) ; v1(20.32,74.31) 20.65,74.64 20.65,77.53 22.61,79.49 v1(22.61,80.64) ; v1(71.3,90.03) 70.69,90.64 70.69,93.41 v1(71.82,94.54) ; v3(19.28,37.55) 18.67,36.94 18.67,22.3 19.65,21.32 v1(19.81,21.32) ; v1(147.17,72.2) 146.38,71.41 145.21,71.41 v1(143.71,69.91) 144.65,69.91 147.6,66.96 148.26,66.96 v1(148.46,67.17)
  L3 w0.635: v1(147.17,72.2) 147.17,72.27 144.74,74.71 144.74,75.47 v1(144.27,75.93) 144.27,80.49 142.43,82.33 141.3,82.33 v1(139.32,84.31)
  L4 w0.508: v1(147.01,50.72) 146.13,51.61 145.72,51.61 142.1,55.23 v1(141.73,55.23) ; v3(39.37,72.2) 39.37,68.79 37.06,66.48 37.06,63.7 37.08,63.68 37.08,58.27 36.96,58.14 36.96,52.03 35.94,51.01 35.94,48.83 35.2,48.09 33.66,48.09 32.41,49.34 27.47,49.34 24.51,46.38 24.51,41.64 v3(24,41.13) ; v1(143.71,69.91) 143.46,69.91 142.37,68.82 142.37,66.42 145.87,62.91 v1(145.87,61.01) 145.87,60.11 146.95,59.03 v1(148.16,59.03) ; v1(115.26,6.22) 115.35,6.13 119.63,6.13 122.02,8.52 129.87,8.52 130.89,9.54 162.81,9.54 163.45,10.17 v1(163.73,10.17) 164.36,9.54 178.71,9.54 180.21,11.03 185.22,11.03 186.84,12.66 186.84,15.48 188.38,17.02 v1(188.58,17.02) ; v3(36.3,83.68) 36.8,84.19 43.05,84.19 44.3,85.43 45.98,85.43 47.4,86.85 47.41,86.85 47.78,87.22 47.78,87.23 48.91,88.36 48.91,90.79 50.74,92.62 50.74,93.89 51.63,94.78 v1(52.12,94.78) ; v1(73.13,50.28) 73.13,51.26 70.34,54.05 66.59,54.05 v1(65.02,55.61)
  L4 w0.635: v1(52.12,94.78) 53.8,94.78 54.42,94.16 56.17,94.16 56.9,93.42 56.9,92.39 59.26,90.03 v1(71.3,90.03)
  L6 w0.305: v1(74.96,88.38) 74.67,88.09 73.24,88.09 v1(71.3,90.03)
  L6 w0.508: v1(198.56,12.49) 198.48,12.41 198.48,12.18 197.72,11.42 196.74,11.42 196.41,11.75 195.7,11.75 193.97,10.02 v1(191.13,10.02) ; v1(188.09,54.95) 186.92,53.78 179.8,53.78 179.54,54.04 171.46,54.04 170.2,55.3 168.39,55.3 167.47,56.22 166.42,56.22 165.61,57.03 160.33,62.32 155.88,62.32 154.86,61.3 153.1,61.3 152.26,62.14 152.26,63.85 148.95,67.17 v1(148.46,67.17) ; v1(282.4,27.35) 280.13,27.35 277.9,29.58 275.34,29.58 275.08,29.32 v1(268.99,29.32)
  BOTTOM w0.178: v1(145.87,61.01) 145.87,60.26 145.06,59.45 144.19,59.45 143.85,59.11 143.85,58.45 144.16,58.15 Q1801.2
  BOTTOM w0.254: DM2.255 187.22,18.25
  BOTTOM w0.305: 110.38,18.22 110.23,18.37 110.23,18.55 110.23,18.55 110.23,19.29 110.22,19.29 DM1.255 ; 141.79,55.29 141.79,55.77 141.96,55.94 RN1810.2 ; 141.79,55.29 RN1810.1 ; 141.79,55.29 v1(141.73,55.23) ; R804.1 138.19,80.76 138.52,81.09 139.37,81.09 139.76,80.69 R803.1 ; IOBD4.2 191.64,53.9 ; v1(24.35,74.66) RN801.1 24.95,72.7 25.06,72.59 25.06,72.18 24.93,72.05 RN801.2 ; v1(82.7,95.77) 82.09,96.38 80.04,96.38 C2601.1 79.21,97.2 C2602.1 78.31,97.35 THM26.1
  BOTTOM w0.406: v1(141.73,55.23) 141.25,55.23 140.97,55.51 140.97,57.06 142.06,58.15 Q1801.5 ; Q2601.2 75.51,92.62 75.83,92.3 v1(75.83,92.27) 75.51,91.96 Q2601.5 ; Q5702.5 v1(20.32,74.31) Q5702.2
  BOTTOM w0.508: v1(257.61,32.22) 257.21,32.22 256.84,31.85 256.84,29.75 256.79,29.7 v1(256.79,28.46) 256.31,27.98 255.02,27.98 254.83,28.17 R9120.2 254.83,29.04 R9145.1 ; v1(257.61,32.22) 257.63,32.22 258.17,32.75 R5617.1 ; v1(257.61,32.22) 256.31,33.51 R9102.2 ; R9937.1 215.07,42.09 v1(216.03,41.13) ; v1(115.26,6.22) 115.26,4.15 114.6,3.49 113.8,3.49 ; 113.8,3.49 R6703.1 ; 113.8,3.49 112.84,3.49 ; v1(65.02,55.61) 64.64,55.99 58.72,55.99 56.82,57.9 55.66,57.9 54.08,56.32 54.08,55.13 53.08,54.14 v3(52.7,54.14) ; R5529.2 53.28,85.52 ; Q5703.C 21.44,80.64 v1(22.61,80.64) ; R3107.1 50.57,95.37 FC9706.1 51.52,95.37 v1(52.12,94.78) ; PR8619.1 PC8601.1 184.09,64.6 PQ8609.S 184.64,64.05 184.64,61.45 185.11,60.98 PR8601.1 186.52,60.98 187.02,60.49 187.02,56.02 v1(188.09,54.95) 189.14,53.9 191.64,53.9 ; IOBD3.16 282.35,27.3 v1(282.4,27.35) ; v1(144.27,75.93) 143.7,76.5 R2005.1 142.75,76.5 R2002.1 ; v1(104.47,7.4) 104.07,7.4 103.53,6.87 R6701.1 102.84,5.83 102.84,4.65 104.33,3.16 108.08,3.16 108.41,3.49 112.84,3.49 ; R5532.1 46.1,85.51 R5521.1 ; v1(148.46,67.17) 148.52,67.17 149.02,67.68 149.86,67.68 150.81,68.63 v1(152.51,68.63) ; R1838.1 127.07,52.26 v1(127.81,51.52) ; PR4614.1 152.81,120.14 v1(152.81,120.89) ; R414.1 141.73,53.39 v1(141.73,55.23) ; 110.38,18.22 v1(111.86,16.74) ; v1(71.51,5.24) 71.54,5.24 71.77,5.01 73.89,5.01 75.08,3.82 78.76,3.82 79.44,4.5 C9111.1 80.14,4.68 80.39,4.94 v1(80.39,5.34) ; R2051.1 71.83,90.56 v1(71.3,90.03) ; 187.22,18.25 187.45,18.03 187.57,18.03 v1(188.58,17.02) 189.65,17.02 190.7,15.96 190.7,14.29 189.87,13.45 189.87,11.29 v1(191.13,10.02) 191.13,9.76 190.69,9.32 R1306.2 191.26,9.13 191.52,8.88 R4005.1 ; EC9735.1 240.47,32.24 v1(241.36,32.24) ; v1(134.67,50.56) 134.67,50.56 134.67,50.61 133.86,51.42 v2(133.86,51.8) ; R5617.1 258.57,32.84 258.57,33.36 258.98,33.77 C5622.1 260.67,34.15 261.22,34.71 264.27,34.71 FC9708.1 264.3,34.71 265.1,34.71 265.45,34.35 265.45,33.05 ; R5617.1 R5614.2 ; R2729.1 44.45,7.06 v1(44.55,6.97) ; R6520.2 196.2,16.69 v1(196.11,16.77) ; R5612.2 C5621.1 261.56,28.52 v1(261.65,28.43) ; R6401.1 v1(198.56,12.49) ; 112.84,3.49 FC9707.1 ; FC6002.1 234.69,33.74 v1(234.69,31.3) ; R2603.1 v1(71.82,94.54)
  vias: v2(39.85,82.54) v2(55.75,87.16) v3(34.92,83.3) v3(36.4,81.93) v3(37.67,81.9) v3(44.12,55.64) v3(45.06,55.61) v3(46.09,55.6) v3(51.82,54.11) v3(51.84,53.25) v3(52.73,53.27) v3(52.78,52.41) v3(52.86,86.38) v3(53.42,87.46) v3(248.06,23.48)
3D3V_S5: length 811.1
  TOP w0.254: PC5110.1 64.42,65.69 v1(64.14,65.97) 64.14,66.03 63.87,66.29 PU5101.15
  TOP w0.305: Q2418.5 Q2418.2 ; RN2406.4 206.28,46.12 205.16,44.99 204.48,44.99 v1(204.02,45.45) 204.21,45.63 204.72,45.63 205.18,46.09 205.18,46.8 205.68,47.3 RN2406.3 ; Q2417.5 Q2417.2 v1(200.91,12.56) ; v1(150.77,62.04) 150.55,62.04 149.96,62.62 R1711.1
  TOP w0.508: R507.1 75.63,50.09 75.06,49.52 73.36,49.52 v1(73.33,49.49) ; v1(32.64,62.34) 33.15,62.34 34.1,61.39 PD4302.2 35.08,61.96 35.88,61.96 PR4304.1 ; 197.79,10.32 196.85,10.32 196.7,10.17 v1(196.47,10.17) 196.56,10.08 196.56,8.69 197.96,7.29 198.06,7.22 199.44,7.22 ; R9612.2 78.7,78.85 78.8,78.75 v1(78.97,78.75) ; v1(89.66,3.8) 89.66,4.3 89.55,4.42 R9123.2 ; C3121.1 36.12,95.22 36.12,94.68 35.76,94.32 34.82,94.32 34.34,94.8 R3109.1 ; C3121.1 37.24,95.24 Q3104.S ; C3121.1 36.07,95.55 v1(36.07,96.05) 36.14,96.12 C3122.1 ; R2413.2 90.74,107.34 v1(90.47,107.07) ; v1(157.35,116.06) 156.91,116.06 156.53,115.68 155.3,115.68 154.26,116.72 153.89,116.72 LIDSW1.2 ; v1(159.05,40.5) 159.05,42.45 159.26,42.66 PR5409.1 ; R2443.1 202.2,15.99 R2442.1 202.45,15.73 203.02,15.73 v1(203.07,15.68) 203.1,15.66 203.1,15.56 203.2,15.45 203.2,14.93 C2421.1 C2416.1 203.05,13.87 C2415.1 ; v1(125.35,50.66) 123.44,52.56 123.44,54.45 122.41,55.48 121.88,55.48 118.62,52.22 118.62,51.36 118.11,50.85 R1504.1 117.03,50.85 109.73,43.55 v1(64.31,43.55) ; v1(213.62,52.44) 213.61,52.44 213.61,52.5 PR8539.2 ; v1(52.07,48.63) 52.27,48.43 PR4508.1 ; R1711.1 149.61,63.55 R1714.1 ; PR5104.1 v1(57.4,66.14) ; v1(247.4,11.16) 247.27,11.16 246.62,11.81 PR4450.2 ; v1(136.02,89.55) 136.86,88.71 137.05,88.67 140.41,88.67 140.61,88.71 141.02,89.11 v1(141.6,89.11) ; R9909.1 53.89,98.59 53.77,98.59 v3(53.75,98.56)
  TOP w0.635: PU5401.3 162.32,44.04 164.22,42.15 165.48,42.15 v1(165.61,42.02) 166.12,41.51 PC5408.1
  L3 w0.508: v1(90.47,107.07) 90.47,107.05 90.07,106.64 90.07,106.08 90.45,105.7 90.45,101.66 89.89,101.1 v1(89.89,99.96) ; v1(185.93,68.21) 185.64,67.93 184.81,67.93 184.15,67.28 184.15,66.6 182.75,65.2 182.75,63.76 184.4,62.11 184.4,60.8 182.42,58.81 v1(180.87,58.81) ; v1(150.77,62.04) 150.84,62.04 155.7,57.18 155.7,53.68 157.23,52.16 v1(157.23,46.8) ; 213.61,52.44 v1(213.62,52.44) ; 213.61,52.44 213.54,52.37 213.54,51.08 216.5,48.12 v1(216.76,48.12) ; 213.61,52.44 212.83,53.22 210.81,53.22 209.82,54.21 208.09,54.21 207.45,54.86 207.45,56.33 206.64,57.14 203.53,57.14 v1(202.87,56.47) ; v1(208.79,40.5) 208.79,44.05 v1(208.53,44.31) 208.38,44.46 208.38,44.74 207.62,45.5 206.82,45.5 206.77,45.45 v1(204.02,45.45) ; v1(208.85,119.03) 208.85,118.67 207.52,117.33 202.18,117.33 202.16,117.31 v1(201.68,117.31) ; v1(66.89,78.73) 67.31,78.31 67.31,75.93 66.75,75.37 v1(66.66,75.37)
  L3 w0.635: v1(256.39,32.29) 257.39,33.3 263.82,33.3 267.21,36.69 271.53,36.69 274.76,33.45 281.09,33.45 284.01,30.53 284.01,27.98 282.12,26.08 274.89,26.08 273.88,25.07 v1(273.88,24.56) 272.15,26.29 265.99,26.29 264.34,24.63 264.34,24.6 263.8,24.06 263.78,24.06 262.43,22.72 260.99,22.72 259.46,21.19 255.07,21.19 v1(255.02,21.24) 255.02,21.07 247.46,13.51 247.46,11.22 v1(247.4,11.16)
  L4 w0.508: v1(202.87,56.47) 202.87,56.8 201.38,58.29 200.9,58.29 200.28,58.91 197.99,58.91 197.78,59.12 195.02,59.12 193.6,60.54 182.6,60.54 v1(180.87,58.81) ; v1(185.93,68.21) 190.92,68.21 192.79,70.08 192.79,70.94 195.2,73.35 195.2,79.69 193.8,81.09 193.8,84.28 200.26,90.74 203.08,90.74 205.73,93.39 205.73,97.26 207.65,99.18 v1(207.65,109.84) 205.99,111.49 205.99,113.76 202.93,116.83 202.16,116.83 v1(201.68,117.31) 191.9,117.31 190.7,118.5 181.2,118.5 179.35,120.36 161.65,120.36 v1(157.35,116.06) 157.35,111.62 154.56,108.82 154.56,107.04 153.03,105.51 153.03,103.62 154.69,101.97 154.69,90.76 v1(153.38,89.45) ; v1(51.44,74.41) 55.45,78.42 57.61,78.42 60.65,81.46 66.48,81.46 67.94,80 ; v1(32.64,62.34) 30.6,62.34 29.53,61.27 29.53,57.96 26.42,54.85 26.42,52.18 v3(24.89,50.66) ; v1(66.89,78.73) 67.18,78.73 67.94,79.49 67.94,80 ; v1(208.81,35.55) 208.81,36.13 209.68,36.99 214.86,36.99 215.06,36.79 217.2,36.79 219.4,38.99 221.78,38.99 222.83,37.93 226.57,37.93 227.03,37.48 227.03,35.34 233.15,29.22 233.76,29.22 234.49,29.96 240.44,29.96 240.84,30.36 251.13,30.36 252.05,29.44 253.53,29.44 256.38,32.29 v1(256.39,32.29) ; v1(196.47,10.17) 195.15,10.17 193.55,11.77 v1(193.55,13.85) 193.75,14.06 193.84,14.06 194.5,14.72 196.15,14.72 197.65,13.22 199.11,13.22 199.77,12.56 v1(200.91,12.56) 203.07,14.72 v1(203.07,15.68) ; 67.94,80 73.71,80 v1(74.04,79.66) 74.65,79.06 78.5,79.06 78.8,78.75 v1(78.97,78.75)
  L4 w0.635: v1(247.4,11.16) 246.11,9.88 241.9,9.88 237.69,5.67 235.07,5.67 233.43,7.31 233.43,8.85 231.99,10.28 227.65,10.28 225.8,8.43 210.45,8.43 209.93,7.91 204.47,7.91 203.95,8.43 202.43,8.43 200.04,10.82 198.64,10.82 197.99,10.17 v1(196.47,10.17)
  L6 w0.508: v1(196.11,19.9) 194.56,18.35 194.56,16.52 194.11,16.06 194.11,15.53 194.21,15.43 194.21,14.31 193.75,13.85 v1(193.55,13.85) ; v1(141.6,89.11) 143.03,90.54 152.76,90.54 153.38,89.92 v1(153.38,89.45) ; v1(208.79,40.5) 208.79,35.93 208.8,35.92 208.8,35.56 v1(208.81,35.55) ; v1(50.42,64.37) 50.7,64.65 52.43,64.65 53.91,66.14 v1(57.4,66.14)
  BOTTOM w0.254: PU8651.15 203.95,119.17 203.26,118.48 202.71,117.55 PC8655.1
  BOTTOM w0.305: v1(74.04,79.66) 71.91,79.66 71.6,79.36 R9603.1
  BOTTOM w0.381: v1(66.89,78.73) 66.89,78.57 R9604.2 67.36,78.08 67.36,77.21 R9606.2
  BOTTOM w0.508: R2434.1 v1(273.88,24.56) ; v1(255.02,21.24) 255.02,22.24 254.03,23.23 254.03,23.64 253.49,24.18 R9143.1 ; v3(51.96,55.2) 51.66,55.2 51.08,54.62 51.08,52.61 52.07,51.62 v1(52.07,48.63) ; PR8624.1 179.9,59.42 179.96,59.42 180.47,58.91 180.77,58.91 v1(180.87,58.81) ; v1(153.38,89.45) 153.59,89.45 154.6,88.44 C4014.1 ; v1(193.55,13.85) 193.55,13.24 193.73,13.07 R4031.1 ; R9101.2 255.75,31.66 v1(256.39,32.29) ; v1(208.85,119.03) 208.9,118.98 PR8673.1 ; R3106.2 49.6,93.97 49.9,93.66 50.73,93.66 FC2402.1 51.64,92.94 52.07,93.37 v1(52.07,93.71) ; PC8655.1 201.92,117.55 v1(201.68,117.31) ; 215.9,48.12 215.7,48.32 210.81,48.32 210.1,47.61 208.33,47.61 207.56,46.84 207.56,45.37 208.03,44.9 208.03,44.79 208.38,44.44 208.41,44.44 v1(208.53,44.31) ; R9805.1 206.82,110.67 v1(207.65,109.84) ; R9929.1 54.06,88.47 v3(54,88.4) ; v1(185.93,68.21) 184.56,68.21 184.4,68.06 182.02,68.06 181.42,67.46 PR8606.1 PC8603.1 ; R9610.2 R9608.2 66.85,74.53 66.66,74.72 v1(66.66,75.37) ; RN1701.5 125.09,55.11 125.09,51.83 125.4,51.52 125.4,50.71 v1(125.35,50.66) ; R6521.2 196.53,20.5 196.11,20.08 v1(196.11,19.9) ; R1610.1 v1(136.02,89.55) ; v1(64.14,65.97) 57.57,65.97 v1(57.4,66.14) ; v3(53.49,2.32) 53.49,2.25 54.06,1.68 62.03,1.68 62.24,1.46 65.3,1.46 65.52,1.68 80.85,1.68 81,1.52 84.95,1.52 85.19,1.76 87.38,1.76 89.41,3.8 v1(89.66,3.8) ; v1(73.33,49.49) 71.62,49.49 65.68,43.55 v1(64.31,43.55) ; v1(78.97,78.75) 78.8,78.75 78.44,79.12 R9601.1 76.64,79.16 R9602.1 ; v1(208.81,35.55) 208.81,35.38 209.18,35.01 R2438.2
  vias: v1(51.44,60.69) v1(155.17,46.82) v1(155.91,46.82) v1(156.59,46.82) v1(166.6,39.86) v2(24.93,48.72) v2(31.88,49.13) v3(15.62,39.23) v3(15.62,38.21) v3(18.16,20.18) v3(18.41,19.16) v3(22.61,48.63) v3(23.37,50.79) v3(23.5,49.39) v3(23.5,48.5) v3(24.13,50.15) v3(24.26,49.01) v3(24.89,49.77) v3(52.25,56) v3(52.32,89.65) v3(52.45,2.4) v3(52.64,56.77) v3(52.83,98.66) v3(52.87,55.28) v3(53.09,88.5) v3(53.23,56.14) v3(53.34,89.65) v3(53.37,97.8) v3(90.65,99.88) v3(91.26,99.22) v3(91.87,99.88) v3(174.9,55.94) v3(175.9,55.97)
