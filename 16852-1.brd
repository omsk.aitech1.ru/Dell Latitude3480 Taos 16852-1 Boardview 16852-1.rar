# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KSO12: length 37.6
  TOP w0.102: KB1.12 196.52,30.3 196.36,30.46 196.36,31.39 196.34,31.41 v1(196.34,31.43) 195.45,32.32 195.45,33.62 194.82,34.25 190.12,34.25 189.91,34.46 185.21,34.46 184.81,34.86 184.45,34.86 184.42,34.82 182.11,34.82 181.53,34.25 180.62,34.25 AFTP6233.1 179.07,34.78 175.39,34.78 174.88,35.29 RN2404.6 ; v1(203.08,30.72) 202.63,31.18 202.23,31.18 202.19,31.14 KBC24.75
  L3 w0.102: v1(203.08,30.72) 202.67,30.31 202.07,30.31 200.41,31.96 198.25,31.96 197.71,31.43 v1(196.34,31.43)
KSO13: length 35.1
  TOP w0.102: v1(202.41,30.74) 202.38,30.74 202.38,30.74 KBC24.76 ; KB1.9 196.39,32.7 196.37,32.73 v1(196.34,32.73) 196.34,33.91 196.24,34.01 196.24,35.2 195.01,36.43 193.88,36.43 193.12,37.2 AFTP6203.1 179.27,36.89 175.18,36.89 174.64,37.44 RN2403.5
  L3 w0.102: v1(202.41,30.74) 200.99,32.17 196.9,32.17 v1(196.34,32.73)
KSO14: length 32.2
  TOP w0.102: RN2403.6 174.75,38.09 175.41,37.42 175.41,37.3 175.62,37.09 175.92,37.09 176.14,37.32 AFTP6216.1 177.9,37.55 193.14,37.55 194.01,36.68 195.06,36.68 196.45,35.3 196.45,34.09 197.04,33.5 KB1.8 198.03,33.5 198.88,32.65 198.88,31.12 199.34,30.67 199.72,30.29 200.08,30.29 200.13,30.34 KBC24.77
KSO15: length 34.8
  TOP w0.102: KBC24.86 201.14,26.77 200.08,26.77 200.08,26.77 199.68,26.77 198.65,27.8 198.65,31.46 198.21,31.9 KB1.10 197.09,31.9 196.69,32.29 196.16,32.29 195.91,32.55 195.91,33.87 195.04,34.75 190.35,34.75 188.61,36.48 181.47,36.48 181.33,36.62 180.97,36.62 180.83,36.48 176.71,36.48 AFTP6229.1 174.87,36.45 RN2404.8
KSO16: length 37.1
  TOP w0.102: KBC24.92 201.14,24.37 199.49,24.37 199.01,24.85 199.01,25.21 199.09,25.28 199.09,27.01 198.45,27.65 198.45,30.75 198.09,31.1 KB1.11 196.96,31.1 196.84,31.22 196.84,31.56 196.42,31.98 196.19,31.98 195.71,32.46 195.71,33.75 195,34.46 190.2,34.46 188.97,35.68 184.22,35.68 183.63,36.28 181.85,36.28 181.33,35.76 180.97,35.76 180.86,35.87 180.57,35.87 180.32,35.62 179.96,35.62 179.93,35.65 178.69,35.65 178.36,35.32 177.8,35.32 177.7,35.42 AFTP6225.1 177.39,35.42 177.19,35.21 176.83,35.21 176.68,35.37 176.5,35.37 176.45,35.42 176.14,35.42 175.92,35.19 175.62,35.19 175.01,35.8 RN2404.7
L_BKLT_CTRL: length 268.8
  TOP w0.114: v1(126.18,78.14) 126.21,78.14 126.61,78.54 127.46,78.54 127.57,78.65 129.97,78.65 130.7,79.37 130.7,80.43 130.71,80.45 130.71,80.46 131.37,81.12 131.37,82.03 131.56,82.22 131.56,85.94 131.58,85.96 131.58,87.54 131.81,87.76 131.81,87.91 132.35,88.45 v1(132.37,88.45) ; v1(163.7,36.56) 163.23,36.09 157.67,36.09 156.92,36.85 156.69,37.08 156.5,37.27 156.09,37.67 150.83,42.91 150.76,42.98 147.39,42.98 147.39,42.98 143.87,42.98 143.87,42.98 123.48,42.98 122.02,41.51 117.8,37.3 63.85,37.3 v2(62.97,38.18) 62.97,38.54 62.23,39.28 v1(61.9,39.28)
  L3 w0.114: v1(60.73,43.93) 60.28,43.48 60.28,43.2 60.28,43.2 60.28,40.87 61.8,39.36 61.82,39.36 v1(61.9,39.28) ; v1(181.15,36.19) 181.11,36.19 180.54,35.61 179.2,35.61 178.58,36.23 165.84,36.23 165.08,37 164.14,37 v1(163.7,36.56) ; v1(132.37,88.45) 133.37,89.45 134.29,89.45 135.25,88.49 135.25,88.12 136.34,87.04 144.07,87.04 145.23,85.88 145.23,83.42 147.07,81.58 147.07,79.51 151.78,74.81 152.3,74.81 153.14,73.97 153.14,70.85 152.96,70.67 152.96,67.72 153.45,67.23 153.45,64.61 154.6,63.46 155.09,63.46 155.78,62.77 156.25,62.77 157.71,61.31 157.71,53.96 166.13,45.55 167.03,45.55 168.73,43.84 169.52,43.84 172.23,41.13 179.3,41.13 179.39,41.21 179.63,41.21 180.43,42.02 v1(180.93,42.02)
  L4 w0.114: v1(60.73,43.93) 60.6,44.05 60.6,44.61 60.62,44.63 60.62,48.07 59.87,48.83 59.87,51.67 60.45,52.26 60.45,54.09 59.87,54.67 59.87,58.86 56.39,62.34 54.9,62.34 51.31,65.94 v1(51.31,66.91)
  L6 w0.114: v1(180.93,42.02) 180.93,41.94 181.23,41.64 181.23,36.31 181.15,36.23 v1(181.15,36.19)
  BOTTOM w0.114: v1(51.31,66.91) 51.31,67.04 50.42,67.93 50.42,70.28 R5530.1 ; CPU1.R11 125.95,78.5 126.18,78.28 v1(126.18,78.14)
L_BKLT_EN: length 127.3
  L3 w0.102: v1(125.52,78.16) 125.52,77.82 126.01,77.33 126.01,77.22 127.03,76.2 131.24,76.2 131.44,76.4 134.69,76.4 138.89,72.21 138.89,69.33 141.57,66.65 141.57,59.06 v1(140.81,58.3)
  L4 w0.102: v1(196.01,46.67) 195.05,45.71 192.57,45.71 191.93,45.07 184.37,45.07 183.82,45.62 181.63,45.62 181.14,45.12 168.87,45.12 168.13,45.87 152.87,45.87 150.95,47.8 144.7,47.8 140.36,52.14 140.36,57.85 v1(140.81,58.3)
  L6 w0.102: v1(196.01,46.67) 195.45,46.11 195.45,39.72 196.95,38.22 196.95,34.5 197.79,33.66 197.79,30.85 197.34,30.4 197.34,27.52 198.47,26.39 198.63,26.39 v1(198.65,26.38)
  BOTTOM w0.102: CPU1.R12 125.3,78.48 125.52,78.26 v1(125.52,78.16) ; v1(198.65,26.38) v2(197.87,27.16) 197,27.16 196.35,26.52 R2480.1 196.29,26.27 195.86,25.84 195.86,24.93 196.02,24.77 197.4,24.77 R2435.2
L_BKLT_EN_EC: length 223.4
  TOP w0.102: R2422.1 72.1,70.57 73.68,70.57 74.57,69.68 74.96,69.68 75.87,70.6 78.49,70.6 v1(78.5,70.61) ; v1(167.26,32.24) 156.92,32.24 149.26,39.91 146.12,39.91 125.14,39.91 119.45,34.22 119.07,34.22 57.36,34.22 57.15,34.43 56.9,34.68 v1(56.61,34.68) ; KBC24.91 200.45,24.74 199.9,25.3 v1(199.9,25.64)
  L3 w0.102: v1(167.26,32.24) 168.96,32.24 169.52,31.68 184.48,31.68 184.51,31.66 189.18,31.66 189.55,32.03 190.12,32.03 190.61,31.54 190.61,28.31 191.47,27.44 192.61,27.44 193.98,26.08 198.34,26.08 198.78,25.64 v1(199.9,25.64)
  BOTTOM w0.102: v1(78.5,70.61) 78.5,67.96 75.3,64.76 75.3,55.36 72.39,52.45 71.96,52.45 66.79,47.28 60.58,47.28 v2(59.95,47.91) 57.71,50.15 56.97,50.15 56.7,49.88 56.7,45.34 58.93,43.11 58.93,41.01 55.6,37.68 55.6,35.95 56.39,35.16 56.39,34.91 v1(56.61,34.68) ; R2435.1 R2436.1 198.82,25.64 v1(199.9,25.64)
L_CPM_CLK: length 15.1
  TOP w0.14: U9102.22 86.58,6.55 v1(86.87,6.84)
  BOTTOM w0.14: R9126.2 76.67,8.14 79.07,8.14 79.73,7.48 v2(81,7.48) 81,7.38 81.28,7.1 84.07,7.1 84.45,6.72 86.74,6.72 v1(86.87,6.84)
L_CPM_CLK_R: length 6
  TOP w0.14: v1(76.07,5.9) 76.07,5.78 74.88,4.59 U9103.3 71.73,4.59 v2(71.58,4.43)
  BOTTOM w0.14: v1(76.07,5.9) 76,5.83 75.25,5.83
LAN_DISABLE#: length 4.3
  BOTTOM w0.102: 48.45,94.92 48.45,95.76 v2(48.46,95.77) 48.55,95.85 49.21,95.85 R3107.2 ; 48.45,94.92 R3105.1 ; 48.45,94.92 48.02,95.35 47.2,95.35 47.04,95.18 LOM31.20
LAN_EN: length 20.2
  TOP w0.127: v1(214.81,23.91) 215.22,23.49 215.89,23.49 215.94,23.54 KBC24.3
  BOTTOM w0.127: v1(214.81,23.91) 215.52,23.2 215.52,17.89 217.12,16.29 v2(217.12,14.55) 217.12,11.66 R2491.1
LAN_ENABLE_R_C: length 6.2
  TOP w0.127: R3110.1 R3109.2 33.22,96.76 32.74,96.28 30.7,96.28 Q3101.D 30.57,96.15 v2(29.24,96.15)
LAN_MDI0N: length 29.7
  BOTTOM w0.089: 41.1,86.7 41.1,89.06 40.86,89.29 40.86,93.42 41.42,93.98 LOM31.2 ; 41.1,86.7 v2(40.92,86.7) ; 41.1,86.7 41.1,85.33 40.81,85.04 40.81,84.72 40.65,84.57 ED3201.9 ED3201.2 40.65,82.78 40.78,82.65 40.78,82.29 39.84,81.35 33.19,81.35 30.45,84.08 29.18,84.08 28.89,84.38 EC3102.2 28.51,84.38 28.35,84.21 28.04,84.21 27.25,85 XF3103.11
LAN_MDI0P: length 29.5
  BOTTOM w0.089: LOM31.1 41.33,93.58 41.08,93.33 41.08,89.38 41.31,89.15 41.31,85.61 ; 41.31,85.61 41.31,85.24 41.02,84.95 41.02,84.68 41.13,84.57 ED3201.10 ED3201.1 41.13,82.77 41,82.64 41,82.2 39.93,81.14 33.1,81.14 30.36,83.87 29.21,83.87 EC3101.2 28.32,84 XF3103.12 ; 41.31,85.61 v2(41.48,85.61)
LAN_MDI1N: length 32
  BOTTOM w0.089: XF3103.8 27.7,88 27.79,87.91 27.79,87.7 27.88,87.61 28.5,87.61 EC3104.2 29.57,87.2 29.93,86.83 29.93,85.88 33.07,82.74 37.19,82.74 ; 37.19,82.74 38.27,82.74 38.94,82.07 39.12,82.07 39.25,82.2 39.25,82.94 ED3201.5 ED3201.6 39.13,85.19 39.4,85.46 40.25,86.31 40.25,88.86 40.15,88.96 40.15,94.67 40.84,95.36 41.25,95.36 41.43,95.18 LOM31.5 ; 37.19,82.74 v2(37.19,82.94)
LAN_MDI1P: length 31.8
  BOTTOM w0.089: 40.47,88.86 40.47,88.95 40.37,89.05 40.37,94.58 40.93,95.15 41.16,95.15 41.53,94.78 LOM31.4 ; 40.47,88.86 v2(40.61,88.86) ; 40.47,88.86 40.47,86.22 39.61,85.37 ED3201.7 ED3201.4 39.47,82.91 39.47,82.11 39.21,81.85 38.85,81.85 38.18,82.52 32.98,82.52 29.72,85.79 29.72,86.74 29.41,87.04 29.22,87.24 29.03,87.24 EC3103.2 28.48,87.39 27.88,87.39 27.79,87.3 27.79,87.09 27.7,87 XF3103.9
LAN_MDI2N: length 20.5
  BOTTOM w0.089: LOM31.7 41.51,95.98 41.36,96.12 39.17,96.12 ; v2(39.17,96.28) 39.17,96.12 ; 39.17,96.12 37.16,96.12 36.25,95.22 33.55,95.22 33.42,95.35 ED3202.9 ED3202.2 31.36,95.35 31.22,95.21 30.84,95.21 29.59,93.97 29.59,92.82 29.41,92.64 28.94,92.64 EC3106.2 28.38,92.57 28.19,92.57 27.94,92.31 27.94,90.66 27.88,90.61 27.7,90.61 27.3,91 XF3103.5
LAN_MDI2P: length 20.7
  BOTTOM w0.089: XF3103.6 27.17,90 27.56,90.39 27.97,90.39 28.16,90.57 28.16,92.22 28.28,92.35 28.35,92.35 EC3105.2 29.13,92.43 29.5,92.43 29.81,92.73 29.81,93.88 30.93,94.99 31.19,94.99 31.31,94.87 ED3202.1 ED3202.10 33.42,94.87 33.55,95 36.34,95 37.25,95.91 37.85,95.91 ; LOM31.6 41.6,95.58 41.27,95.91 37.85,95.91 ; 37.85,95.91 v2(37.85,95.74)
LAN_MDI3N: length 21.6
  BOTTOM w0.089: 34.42,96.74 33.55,96.74 33.42,96.87 ED3202.6 ED3202.5 31.38,96.87 31.22,96.71 30.63,96.71 30.37,96.44 EC3108.2 28.38,96.12 28.07,96.12 27.86,95.92 27.86,93.71 27.76,93.61 27.56,93.61 27.17,94 XF3103.2 ; 34.42,96.74 v2(34.42,96.91) ; 34.42,96.74 35.21,96.74 36.75,98.28 42.72,98.28 43.01,97.99 43.01,97.7 43.2,97.52 LOM31.10
LAN_MDI3P: length 21.4
  BOTTOM w0.089: LOM31.9 42.8,97.07 42.8,97.9 42.63,98.07 36.84,98.07 36.02,97.24 ; v2(36.14,97.11) 36.02,97.24 ; 36.02,97.24 35.3,96.52 33.55,96.52 33.42,96.39 ED3202.7 ED3202.4 31.32,96.39 31.22,96.49 30.72,96.49 30.46,96.23 29.38,96.23 EC3107.2 28.35,95.91 28.16,95.91 28.08,95.83 28.08,93.62 27.85,93.39 27.67,93.39 27.28,93 XF3103.3
LAN_REGOUT: length 1.5
  TOP w0.508: v2(47.24,93.46) 47.12,93.46 v1(46.74,93.08)
  BOTTOM w0.203: v1(46.74,93.08) 46.74,93.33 46.48,93.58 LOM31.24
  vias: v1(46.1,93.08) v1(47.37,89.01) v1(48,89.19)
LAN_RSET: length 2.5
  BOTTOM w0.127: LOM31.31 43.2,92.46 42.57,91.83 v2(42.57,91.63) 42.42,91.48 41.67,91.48 R3108.1
LANXIN: length 6
  BOTTOM w0.114: LOM31.28 44.4,91.91 v2(44.63,91.68) 44.72,91.59 C3112.1 44.72,90.35 44.35,89.98 44.35,89.07 X3101.1
LANXOUT: length 3.9
  BOTTOM w0.114: LOM31.29 44,91.71 43.83,91.54 C3110.1 43.83,90.4 43.33,89.9 X3101.3
LCD_BRIGHTNESS: length 3.6
  TOP w0.114: v1(50.55,74.41) 50.7,74.25 50.77,74.25 51.18,73.85 v2(51.56,73.85) 51.66,73.75 51.66,73.47 51.69,73.45 RN5503.2
  BOTTOM w0.114: LCD1.20 50.16,75.54 50.16,74.79 v1(50.55,74.41)
LCD_MIC_CBL_DET#: length 132.5
  TOP w0.127: RN2002.3 130.46,76.23 130.85,76.62 v2(133.02,76.62) 133.1,76.62 133.12,76.64 133.65,76.64 134.15,76.15 134.15,75.73 v1(134.08,75.66)
  L4 w0.127: v1(134.08,75.66) 134.08,78.44 133.32,79.19 133.32,79.53 134.39,80.6 134.39,83.58 134.87,84.06 134.87,84.65 136.51,86.29 136.51,88.54 136.18,88.87 135.74,88.87 133.93,90.68 133.93,90.88 132.4,92.41 132.21,92.61 128.53,92.61 127,94.13 125.73,94.13 125.12,94.74 118.39,94.74 118.39,94.74 118.09,94.74 117,93.65 110.94,93.65 108.98,95.61 108.98,97.05 108.14,97.89 101.71,97.89 94.79,90.97 88.36,90.97 87.97,90.57 84.22,90.57 81.23,87.58 76.43,87.58 75.65,86.8 74.57,86.8 72.86,85.09 72.47,85.09 72.01,84.63 70.77,84.63 69.4,86 67.69,86 67.03,86.66 67.03,86.66 65.47,88.22 64.31,88.22 64.17,88.08 63.34,88.08 62.68,87.42 62.29,87.42 61.71,87.42 61.26,87.87 60.16,87.87 60.05,87.98 56.44,87.98 56.29,87.84 56.29,87.84 50.44,81.99 47.79,81.99 v1(45.47,84.31)
  BOTTOM w0.127: R5539.2 45.21,84.06 v1(45.47,84.31) ; CPU1.W4 130.19,76.57 130.51,76.26 132.22,76.26 132.26,76.22 133.69,76.22 134.06,75.86 134.06,75.68 v1(134.08,75.66)
LCD_MIC_CBL_DET#_R: length 9.7
  BOTTOM w0.127: LCD1.23 48.65,78.61 47.6,79.66 45.98,79.66 45.02,80.62 45.02,81.68 v2(45.01,81.7) 45.02,81.71 45.02,82.52 45.21,82.71 R5539.1
LCD_TST: length 246.9
  TOP w0.102: v1(52.02,66.91) 52.02,67.37 52.17,67.52 D5503.2 52.12,68.29 52.12,71.67 RN5503.8 ; v1(61.54,38.21) 61.72,38.21 63.35,36.58 117.5,36.58 118.1,36.58 122.73,41.22 123.78,42.26 144.16,42.26 150.38,42.26 157.53,35.11 165.53,35.11 165.61,35.19 165.96,35.19 166.04,35.11 v1(166.32,35.11) ; KBC24.26 v1(215.14,32.74)
  L3 w0.102: v1(166.32,35.11) 166.41,35.02 167.88,35.02 168.45,34.45 183.89,34.45 185.19,35.75 194.06,35.75 194.39,36.08 195.18,36.08 195.75,35.51 201.61,35.51 201.99,35.88 204.89,35.88 208.64,32.14 214.54,32.14 v1(215.14,32.74) ; v1(61.54,38.21) 61.54,38.28 59.44,40.39 59.44,44.71 59.46,44.74 59.46,46.97 58.86,47.57 54.76,47.57 52.45,49.88 50.81,49.88 49.84,50.86 46.29,50.86 45.67,51.48 40.38,51.48 36.98,54.88 36.98,60.82 32.77,65.03 v1(32.77,69.58)
  BOTTOM w0.102: v1(52.02,66.91) 52.02,66.86 51.51,66.36 50.87,66.36 50.62,66.61 49.58,66.61 47.65,68.54 47.65,72.15 47.02,72.78 v2(46.63,72.78) 43.21,72.78 41.85,71.42 R2419.1 34.61,71.42 v1(32.77,69.58)
LCD_TST_C: length 5.5
  TOP w0.102: RN5503.1 52.34,73.89 v1(52.32,73.9)
  BOTTOM w0.102: LCD1.10 55.15,75 54.62,74.47 52.9,74.47 v1(52.32,73.9) v2(52.32,73.29)
LCD_VCC_TEST_EN: length 61.9
  TOP w0.102: D5502.2 36.26,70.91 37.34,71.99 v1(37.72,71.99) ; v1(76.02,75.42) 75.95,75.35 U9601.13
  L4 w0.102: v1(37.72,71.99) 37.97,71.99 39.55,73.57 40.54,73.57 41.05,73.06 52.37,73.06 53.92,74.61 53.95,74.61 55.95,76.62 58.83,76.62 59.36,77.15 61.29,77.15 61.99,76.45 61.99,74.04 62.36,73.67 65.96,73.67 66.88,74.58 68.74,74.58 v1(69.39,73.93) 69.46,74 74.78,74 76.02,75.25 v1(76.02,75.42)
  BOTTOM w0.102: v1(37.72,71.99) 37.4,72.31 v2(36.63,72.31) R2419.2 ; v1(69.39,73.93) 69.37,73.91 69.37,72.48 69.65,72.2 70.13,72.2 70.38,71.94 70.38,71.59 70.61,71.36 72.77,71.36 73.53,70.6 75.69,70.6 76.27,70.02 RN9601.2
LCDVDD:
  vias: v2(62.36,85.79)
LCDVDD_EN: length 49.4
  TOP w0.102: v1(30.92,72.95) 31.8,72.07 v2(32.16,72.07) 33.07,72.07 34.78,70.36 34.85,70.33 35,70.23 35.13,70.1 35.23,69.95 35.24,69.93 35.48,69.69 36.81,69.69 38.16,71.04 D5502.3
  L4 w0.102: v1(61.16,88.63) 60.97,88.63 60.62,88.98 60.26,88.98 59.82,88.54 56.36,88.54 56.3,88.48 56.25,88.43 56.25,88.43 56.11,88.28 56.1,88.28 54.67,86.85 53.2,86.85 52.94,87.11 52.1,87.11 51.38,87.82 49.02,87.82 46.18,84.97 44.45,84.97 43.23,83.75 41.14,83.75 34.66,77.27 34.66,76.68 v1(30.92,72.95)
  BOTTOM w0.102: U5501.1 60.83,88 61.16,88.33 v1(61.16,88.63) 60.52,89.27 R5506.2
LCDVDD_LCD: length 1.4
  TOP w0.508: FC5501.1 59.31,76.72 58.93,77.01 58.48,77.01 v4(58.42,77.07)
  vias: v2(59.63,81.87)
LDO1_CAP: length 4.1
  TOP w0.203: v2(22.23,7.3) 22.23,7.56 22.53,7.86 HDA27.27
  TOP w0.305: v2(22.23,7.3) 22.23,6.92 21.57,6.27 C2702.2 20.57,6.27 R2711.2
LDO2_CAP: length 3.6
  TOP w0.203: C2712.2 28.4,8.94 28.4,9.94 v2(28.31,10.03) 27.92,10.42 HDA27.39
LDO3_CAP: length 3.4
  TOP w0.203: HDA27.7 23.73,15.75 23.62,15.86 23.62,16.37
  TOP w0.254: 23.62,16.37 23.62,16.5 v2(23.16,16.95) 23.11,17 C2718.1
LED0: length 3.1
  BOTTOM w0.102: LOM31.27 44.8,92.1 45.47,91.43 45.97,91.43 46.48,90.92 TP3103.1
LED1: length 5.5
  BOTTOM w0.102: LOM31.26 45.2,92.2 45.77,91.63 46.06,91.63 46.41,91.27 46.76,91.27 v2(48.05,89.98) 48.24,89.79 48.24,89.68 R3104.1
LED2: length 2.9
  BOTTOM w0.102: LOM31.25 47.45,91.3 47.8,91.3 TP3101.1
LID_CL_SIO#: length 175.9
  TOP w0.102: v1(210.51,49.55) 210.5,49.55 209.61,48.66 209.61,47.54 AFTP7001.1 ; AFTP7001.1 209.37,47.3 RN2406.2 ; AFTP7001.1 210.06,46.72 210.06,44.37 R7001.1 210.38,44.05 210.95,44.05 211.96,43.04 D2402.K 211.26,41.58 EC7001.1 C7001.1 211.91,38.96 KBC24.41 ; v1(158.5,126.48) 156.46,124.45 156.46,118.22 155.92,117.67 LIDSW1.3
  L3 w0.102: v1(201.42,56.88) 201.42,56.87 201.42,54.85 202.26,54.01 205.83,54.01 206.69,53.15 208.81,53.15 210.51,51.45 v1(210.51,49.55)
  L4 w0.102: v1(210.95,115.17) 211.05,115.28 211.05,116.65 209.96,117.74 208.61,117.74 206.43,119.92 206.43,125.13 206.21,125.35 206.21,125.36 204.63,126.93 192.02,126.93 191.08,127.87 159.89,127.87 v1(158.5,126.48)
  L6 w0.102: v1(201.42,56.88) 201.42,57.34 200.74,58.02 200.74,60.26 200.1,60.89 200.1,63.21 197.61,65.69 197.61,68.18 196.16,69.63 196.16,81.37 196.27,81.47 196.27,81.85 196.65,82.23 196.65,86.4 198.27,88.02 198.27,99.86 204.32,105.9 204.32,114.54 v1(204.11,114.74)
  BOTTOM w0.102: v1(204.11,114.74) 205.56,114.74 205.92,114.39 208.1,114.39 209.22,115.5 210.62,115.5 v1(210.95,115.17)
LINE1-L_C: length 1
  TOP w0.254: C2907.2 17.27,7.35 R2922.1
LINE1-L_R: length 0.9
  TOP w0.254: C2908.2 17.3,8.49 R2921.1
LINE1_L: length 5
  TOP w0.203: 20.07,10.15 20.34,10.42 HDA27.22
  TOP w0.254: 20.07,10.15 20.07,9.12 19.56,8.63 19.56,7.88 19.71,7.73 v2(19.71,7.45) 19.53,7.28 C2907.1
LINE1_R: length 3.7
  TOP w0.203: C2908.1 18.72,8.55 19.56,9.38 v2(19.56,9.76) 19.56,10.27 20.11,10.82 HDA27.21
LINE1_VREFO_L: length 3.5
  TOP w0.203: R2912.1 24.4,5.73 24.4,6.7 v2(24.38,6.72) 24.13,6.97 HDA27.31
LINE1_VREFO_R: length 4.9
  TOP w0.203: HDA27.30 23.73,7.46
  TOP w0.254: 23.73,7.46 23.75,7.43 23.75,7.01 23.73,6.99 23.73,6.11 v1(23.72,6.11)
  BOTTOM w0.254: R2913.1 23.7,4.18 v2(23.7,4.91) 23.7,6.08 v1(23.72,6.11)
LOM_CABLE_DETECT#: length 142
  L3 w0.127: v1(42.34,63.46) 39.75,66.05 39.75,66.18 38.39,67.54 38.39,72.2 37.33,73.26 37.33,74.28 37.33,77.17 37.17,77.33 37.17,78.63 36.36,79.44 36.36,80.07 35.13,81.3 35.05,81.3 33.79,82.56 33.79,83.91 34.96,85.08 37.47,85.08 38.43,86.04 41.18,86.04 42.2,85.02 45.27,85.02 47.12,86.86 47.12,87.46 v1(47.14,87.49)
  L4 w0.127: v1(42.34,63.46) 42.34,63.56 43.03,64.25 46.57,64.25 48.34,66.03 48.57,66.03 49.7,67.15 49.7,67.99 51,69.29 52.6,69.29 57.91,74.6 60,74.6 60.26,74.34 60.26,73.75 62.39,71.63 71.49,71.63 72.88,70.23 73.21,70.23 73.61,69.84 v1(73.71,69.84)
  L6 w0.127: v1(127.9,70.22) 127.52,70.22 127.12,70.62 123.78,70.62 123.26,71.14 120.18,71.14 119.77,71.55 117.78,71.55 116.1,73.23 103.02,73.23 102.99,73.2 98.33,73.2 95.59,75.94 90.08,75.94 89.74,75.6 85.29,75.6 84.62,74.93 81.24,74.93 75.99,69.67 73.88,69.67 v1(73.71,69.84)
  BOTTOM w0.127: v1(47.14,87.49) 47.35,87.49 v2(47.82,87.96) 48.23,88.38 R2052.2 48.9,88.38 49.59,89.08 R3104.2 ; CPU1.AN7 128.31,69.8 127.9,70.22 v1(127.9,70.22)
LOM_TCT: length 7.9
  BOTTOM w0.508: C3119.1 v1(25.73,97.93)
  BOTTOM w0.61: XF3103.1 v1(24.53,95) ; XF3103.7 v1(24.51,89) ; XF3103.4 v1(24.53,92) ; XF3103.10 v1(24.53,86)
  vias: v2(25.15,93.61)
LPC_FRAME#_DEBUG: length 125.4
  TOP w0.14: DB1.6 287.23,28.26 289.46,28.26 v1(289.56,28.36)
  L6 w0.114: v1(289.56,28.36) 289.56,27.16 284.04,21.64 279.47,21.64 278.9,21.07 258.02,21.07 256.87,19.92 253.19,19.92 244.56,11.29 241.7,11.29 240.42,10.01 237.81,10.01 235.81,8.01 230.82,8.01 230.45,7.64 226.29,7.64 225.92,8.01 225.36,8.01 224.17,9.2 223.59,9.2 222.53,10.27 219.46,10.27 215.21,14.52 214.22,14.52 213.16,15.57 213.16,16.09 212.08,17.17 212.08,18.02 211.61,18.5 210.7,18.5 209.32,19.88 209.32,21.06 210.06,21.81 210.06,23.18 208.75,24.49 208.75,25.67 208.19,26.23 208.19,26.89 208.03,27.05 208.03,28.04 208.28,28.29 208.28,32.34 206.38,34.24 206.38,36.69 204.78,38.29 204.78,38.66 205.29,39.17 205.29,39.53 204.78,40.04 204.78,40.82 204.57,41.03 203.45,42.15 v1(203.45,42.28)
  BOTTOM w0.127: v2(203.05,41.82) 203.43,42.2
  BOTTOM w0.14: 203.43,42.2 203.43,42.25 v1(203.45,42.28) 203.14,42.59 R6801.2
LPC_LAD0: length 97.3
  TOP w0.14: KBC24.59 204.72,38.52 203.52,39.72 203.22,39.72 203,39.94 203,39.94 v1(202.82,40.12) 202.67,40.27 202.19,40.27 202.18,40.27 RN6801.4
  BOTTOM w0.14: 202.81,40.11 v1(202.82,40.12) ; 202.81,40.11 202.31,39.61 198.82,39.61 R9154.2 ; 202.81,40.11 202.77,40.14 195.52,40.14 195.24,39.86 194.39,39.86 190.06,35.53 184.08,35.53 183.52,36.08 182.38,36.08 182.04,35.74 180.5,35.74 180.36,35.6 179.64,35.6 179.23,35.2 176.14,35.2 175.77,35.57 168.87,35.57 167.29,37.15 143.6,37.15 v2(128.16,52.59) 127.6,53.15 RN1806.8
LPC_LAD0_C: length 124.3
  TOP w0.14: v1(202.69,42.28) 203.12,41.84 203.12,41.36 v2(203.07,41.31) 203,41.23 202.07,41.23 RN6801.5 ; v1(289.43,21.96) 288.12,23.27 DB1.2
  L6 w0.114: v1(202.69,42.28) 204.42,40.55 204.42,38.14 206.01,36.54 206.01,34.09 207.91,32.18 207.91,28.44 207.66,28.19 207.66,26.9 207.82,26.74 207.82,26.08 208.39,25.52 208.39,24.34 209.15,23.57 209.15,21.59 208.1,20.54 208.1,19.64 209.2,18.53 210.05,18.53 210.46,18.13 211.46,18.13 211.72,17.87 211.72,17.02 212.79,15.94 212.79,15.42 214.06,14.15 215.06,14.15 219.31,9.9 222.37,9.9 223.44,8.83 223.96,8.83 225.15,7.64 225.77,7.64 226.14,7.27 230.61,7.27 230.97,7.64 236.05,7.64 237.8,9.39 240.32,9.39 241.85,10.93 244.72,10.93 253.33,19.54 257.01,19.54 258.17,20.71 279.05,20.71 279.62,21.27 288.75,21.27 v1(289.43,21.96)
LPC_LAD0_CPM: length 146.1
  TOP w0.14: v1(84.18,8.75) 84.6,8.33 U9102.27
  L6 w0.114: v1(192.34,36.76) 191.79,36.76 190.91,35.88 190.91,32.79 190.67,32.55 190.67,30.18 190.16,29.67 190.16,24.41 190.36,24.22 190.36,17.63 190.1,17.37 190.1,16.2 190.15,16.15 190.22,16.09 190.32,15.94 190.38,15.78 190.42,15.74 190.42,14.42 189.86,13.86 188.75,13.86 186.21,11.31 163.21,11.31 162.8,10.9 160.01,10.9 159.6,11.31 143.7,11.31 143.68,11.33 124.28,11.33 122.33,9.38 121.38,9.38 119.68,7.68 119.68,7.38 119.68,7.38 119.68,6.73 119.31,6.35 118.88,6.35 117.17,8.06 117.17,9.54 114.76,11.95 112.53,11.95 111.52,10.93 103.16,10.93 102.95,10.72 86.04,10.72 84.18,8.85 v1(84.18,8.75)
  BOTTOM w0.14: R9154.1 196.82,39.23 v2(196.63,39.04) 195.58,37.99 193.49,37.99 192.39,36.89 192.39,36.81 v1(192.34,36.76)
LPC_LAD0_R: length 10.5
  BOTTOM w0.089: 126.27,60.88 124.35,62.79 124.35,64.17 124.38,64.25 124.39,64.31 124.39,64.52 124.35,64.66 124.35,64.9 124.42,65.16 124.49,65.23 124.49,65.26 CPU1.AY13
  BOTTOM w0.114: 127.41,57.73 126.34,58.8 126.34,60.03 v2(126.32,60.05) 126.34,60.07 126.34,60.8 126.27,60.88
  BOTTOM w0.14: RN1806.1 127.6,57.54 127.41,57.73
LPC_LAD1: length 99.5
  TOP w0.14: KBC24.60 204.32,38.24 203.58,38.97 v1(203.45,38.97) 203.13,39.3 203.05,39.3 202.82,39.52 202.68,39.67 201.62,39.67 201.42,39.86 RN6801.3
  BOTTOM w0.14: R9155.2 199.04,37.45 199.45,37.86 199.5,37.86 200.29,38.65 202.12,38.65 202.15,38.68 202.74,38.68 203.03,38.97 v1(203.45,38.97) 203.69,39.21 203.69,40.48 203.31,40.86 203.18,40.99 195.18,40.99 194.89,40.69 194.04,40.69 189.71,36.36 184.42,36.36 183.72,37.06 179.92,37.06 179.47,36.62 176.75,36.62 176.54,36.41 169.24,36.41 167.56,38.09 164.8,38.09 163.93,38.95 143,38.95 130.52,51.43 v2(130.51,51.43) 128.75,53.19 RN1806.6
LPC_LAD1_C: length 126.1
  TOP w0.14: DB1.3 288.14,24.52 v1(289.43,23.23) ; RN6801.6 201.42,41.76 v1(201.93,42.28)
  L6 w0.114: v1(201.93,42.28) 201.93,42.15 204.05,40.03 204.05,37.99 205.64,36.39 205.64,33.93 207.55,32.03 207.55,29.26 207.45,29.17 207.45,28.5 207.3,28.34 207.3,26.75 207.45,26.59 207.45,25.93 208.02,25.36 208.02,24.39 208.01,24.38 208.01,22.43 207.87,22.29 207.87,20.83 207.49,20.45 207.49,19.3 209.36,17.43 210.64,17.43 212.43,15.64 212.43,15.27 213.91,13.78 214.9,13.78 219.16,9.53 222.22,9.53 223.29,8.46 223.81,8.46 225,7.27 225.62,7.27 225.98,6.9 230.76,6.9 231.13,7.27 236.2,7.27 237.95,9.02 240.47,9.02 242,10.56 244.87,10.56 253.4,19.09 257.07,19.09 258.32,20.34 288.43,20.34 289.87,21.77 289.87,22.46 289.43,22.9 v1(289.43,23.23)
  BOTTOM w0.14: v1(201.93,42.28) 201.85,42.28 v2(201.44,41.86)
LPC_LAD1_CPM: length 141.5
  TOP w0.14: v1(87.1,8.24) 86.64,8.24 86.36,7.96 86.05,7.65 U9102.24
  L6 w0.114: v1(87.1,8.24) 87.87,9.01 97.43,9.01 98.85,10.42 103.48,10.42 103.77,10.72 109.04,10.72 109.31,10.44 114.7,10.44 115.22,9.92 115.22,9.49 118.73,5.99 119.46,5.99 120.05,6.58 120.05,7.23 121.84,9.01 122.48,9.01 124.45,10.98 159.41,10.98 159.86,10.54 162.95,10.54 163.39,10.98 186.39,10.98 188.91,13.49 190.01,13.49 190.79,14.27 190.79,15.89 190.69,15.99 190.64,16.11 190.51,16.31 190.5,16.32 190.47,16.35 190.47,17.22 190.73,17.48 190.73,24.37 190.53,24.57 190.53,29.52 191.04,30.02 191.04,32.39 191.27,32.63 191.27,35.73 191.66,36.12 193.2,36.12 v1(193.29,36.21)
  BOTTOM w0.14: R9155.1 197.07,37.45 196.77,37.15 v2(195.4,37.15) 195.15,37.15 194.6,36.6 193.68,36.6 193.29,36.22 v1(193.29,36.21)
LPC_LAD1_R: length 10.1
  BOTTOM w0.089: CPU1.BA13 124.88,64.48 124.88,62.96 127.11,60.72 127.11,59.5 127.47,59.15
  BOTTOM w0.14: RN1806.3 128.75,57.87 v2(128.39,58.23) 127.47,59.15
LPC_LAD2: length 98.5
  TOP w0.14: KBC24.61 203.92,37.88 202.91,38.88 202.87,38.88 202.65,39.1 v1(201.93,39.1) 201.59,39.1 200.92,39.77 RN6801.2
  BOTTOM w0.14: RN1806.7 128.25,53.09 v2(129.29,52.06) 139.38,41.96 139.4,41.96 143.78,37.58 167.46,37.58 168.71,36.33 168.71,36.32 169.04,35.99 175.94,35.99 176.13,35.8 176.53,35.8 176.93,36.2 179.65,36.2 180.09,36.64 183.55,36.64 184.25,35.95 189.89,35.95 194.22,40.28 195.06,40.28 195.36,40.57 203.01,40.57 203.27,40.3 203.27,39.93 202.44,39.1 v1(201.93,39.1) 200.15,39.1 199.32,38.28 198.95,38.28 198.89,38.34 R9156.2
LPC_LAD2_C: length 128.9
  TOP w0.14: v2(200.92,42.96) 200.92,42.81 200.92,42.81 v1(200.92,42.28) RN6801.7 ; v1(289.31,24.5) 289.31,24.8 288.34,25.77 287.22,25.77 DB1.4
  L6 w0.114: v1(289.31,24.5) 290.24,23.56 290.24,21.62 288.59,19.97 258.48,19.97 257.21,18.7 253.54,18.7 245.02,10.19 242.16,10.19 240.62,8.65 239.77,8.65 237.65,6.53 225.22,6.53 223.66,8.09 223.13,8.09 222.07,9.16 219,9.16 214.75,13.42 213.76,13.42 212.06,15.11 212.06,15.49 210.49,17.06 209.21,17.06 207.12,19.15 207.12,20.6 207.5,20.98 207.5,22.45 207.64,22.59 207.64,25.22 206.93,25.93 206.93,28.49 207.09,28.65 207.09,29.32 207.18,29.41 207.18,31.88 205.28,33.78 205.28,36.24 202.74,38.78 202.74,39.45 202.25,39.93 202.25,40.94 v1(200.92,42.28)
LPC_LAD2_CPM: length 143.9
  TOP w0.14: U9102.21 86.84,6.05 87.5,6.72 88.01,6.72 v1(88.14,6.84)
  L6 w0.114: v1(88.14,6.84) 88.14,7.48 88.93,8.27 99.36,8.27 100.52,9.43 107.53,9.43 108.23,10.13 108.59,10.13 109.16,9.55 112.38,9.55 114.32,7.61 114.94,7.61 116.44,6.11 116.72,6.11 117.58,5.25 119.77,5.25 120.79,6.27 120.79,6.92 122.14,8.27 123.42,8.27 125.03,6.66 127.49,6.66 130.45,9.62 186.08,9.62 189.22,12.75 190.31,12.75 191.53,13.97 191.53,16.2 191.32,16.41 191.3,16.46 191.3,16.89 191.47,17.06 191.47,24.68 191.27,24.87 191.27,29.21 191.77,29.72 191.77,32.09 192.01,32.33 192.01,34.98 v1(192.34,35.31)
  BOTTOM w0.14: R9156.1 197.13,38.34 v2(196.61,37.82) 196.36,37.57 193.75,37.57 192.79,36.61 192.79,36.58 192.34,36.13 v1(192.34,35.31)
LPC_LAD2_R: length 9.3
  BOTTOM w0.089: 126.19,61.3 124.62,62.87 CPU1.BB13
  BOTTOM w0.114: 127.89,57.95 v2(127.01,58.84) 126.73,59.11 126.73,60.75 126.19,61.3
  BOTTOM w0.14: 127.89,57.95 128.25,57.6 RN1806.2
LPC_LAD3: length 101
  TOP w0.14: RN6801.1 200.27,39.45 201.51,38.21 v1(202.56,38.21) 202.95,38.21 203.51,37.64 KBC24.62
  BOTTOM w0.14: RN1806.5 v2(129.4,54.09) 129.4,53.13 130.68,51.85 130.69,51.85 132.1,50.45 133.03,50.45 133.29,50.18 133.29,49.51 143.43,39.37 164.11,39.37 164.97,38.5 167.98,38.5 169.66,36.83 176.37,36.83 176.58,37.04 179.3,37.04 179.74,37.48 183.9,37.48 184.6,36.78 189.54,36.78 193.87,41.11 194.72,41.11 195.01,41.41 203.35,41.41 204.11,40.65 204.11,38.99 203.33,38.21 v1(202.56,38.21) 200.44,38.21 199.67,37.44 199.62,37.44 198.74,36.56 R9157.2
LPC_LAD3_C: length 132.2
  TOP w0.14: v1(290.07,25.77) 288.82,27.01 287.22,27.01 DB1.5 ; RN6801.8 v1(200.27,42.28)
  L6 w0.114: v1(290.07,25.77) 290.61,25.23 290.61,21.47 288.74,19.6 258.83,19.6 257.52,18.3 253.65,18.3 245.18,9.82 242.31,9.82 240.77,8.28 239.92,8.28 237.8,6.16 225.06,6.16 223.5,7.73 222.98,7.73 221.91,8.79 218.85,8.79 214.6,13.05 213.6,13.05 211.38,15.27 211.38,15.65 210.33,16.69 209.06,16.69 206.75,19 206.75,20.75 207.13,21.13 207.13,22.6 207.27,22.74 207.27,23.1 206.4,23.97 206.4,25.06 206.56,25.21 206.56,28.65 206.72,28.81 206.72,29.47 206.81,29.56 206.81,31.73 204.91,33.63 204.91,35.25 202.13,38.03 202.13,38.39 202.37,38.63 202.37,39.3 201.66,40.01 201.66,40.39 200.27,41.78 v1(200.27,42.28)
  BOTTOM w0.14: v2(199.8,41.86) 199.85,41.86 v1(200.27,42.28)
LPC_LAD3_CPM: length 140.8
  TOP w0.14: v1(87.88,5.57) 87.88,5.45 87.38,4.94 87,4.94 86.88,5.05 U9102.19
  L6 w0.114: v1(87.88,5.57) 87.94,5.57 90.27,7.9 99.51,7.9 100.67,9.07 111.74,9.07 111.86,9.19 112.22,9.19 112.74,8.67 113.24,8.17 113.24,7.13 115,5.37 116.88,5.37 117.37,4.88 129.12,4.88 131.21,6.98 133.26,6.98 135.53,9.25 186.23,9.25 189.37,12.39 190.47,12.39 191.92,13.84 191.92,15.62 192.19,15.89 192.19,24.48 191.76,24.9 191.64,25.03 191.64,29.06 192.24,29.66 192.24,32.03 192.38,32.17 192.38,33.92 v1(193.77,35.31)
  BOTTOM w0.14: R9157.1 v2(196.65,36.56) 195.16,36.56 194.78,36.18 194.64,36.18 v1(193.77,35.31)
LPC_LAD3_R: length 11.4
  BOTTOM w0.089: CPU1.AY12 125.19,65.54 124.9,65.26 124.9,64.7 125.05,64.55 125.05,63.17 126.77,61.45 126.77,61.36
  BOTTOM w0.114: 126.77,61.36 127.5,60.63 127.5,59.71 128.13,59.08
  BOTTOM w0.14: RN1806.4 v2(129.4,57.36) 129.4,57.81 128.13,59.08
LPC_LFRAME#: length 97.8
  TOP w0.14: KBC24.58 205.12,38.24 205.06,38.29 205.06,38.98 205.04,39.01 205.04,39.17 v1(204.85,39.35)
  BOTTOM w0.14: R9158.2 198.68,35.67 200.79,37.78 202.36,37.78 202.38,37.76 203.47,37.76 204.85,39.14 v1(204.85,39.35) 204.85,40.72 203.9,41.67 203.9,42.46 203.6,42.77 203.6,43.34 203.43,43.51 202.72,43.51 R6801.1 200.39,43.04 199.25,41.9 194.91,41.9 194.54,41.53 193.7,41.53 189.36,37.2 184.77,37.2 184.07,37.9 173.03,37.9 171.68,39.25 171.68,40.68 171.35,41.01 169.62,41.01 167.69,39.08 164.99,39.08 164.28,39.79 143.61,39.79 133.85,49.54 v2(133.85,50) 133.85,50.41 132.82,51.45 132.82,51.5 R1801.2
LPC_LFRAME#_CPM: length 140.9
  TOP w0.14: v1(87.91,8.24) 87.17,7.5 86.77,7.5 86.31,7.05 U9102.23
  L6 w0.114: v1(194.76,35.65) 194.67,35.75 191.81,35.75 191.64,35.58 191.64,32.48 191.4,32.24 191.4,29.87 190.9,29.37 190.9,24.72 191.1,24.52 191.1,17.25 190.84,16.99 190.84,16.48 190.97,16.29 191.01,16.2 191.11,16.1 191.16,16.05 191.16,14.12 190.16,13.12 189.06,13.12 188.78,12.84 186.54,10.61 163.55,10.61 163.11,10.17 159.7,10.17 159.26,10.61 130.92,10.61 128.95,8.64 121.99,8.64 120.42,7.07 120.42,6.43 119.61,5.62 118.2,5.62 113.75,10.08 109.16,10.08 108.74,10.49 104.07,10.49 103.62,10.04 100.61,10.04 99.21,8.64 88.78,8.64 88.38,8.24 v1(87.91,8.24)
  BOTTOM w0.14: v1(194.76,35.65) 194.78,35.67 v2(195.68,35.67) R9158.1
LPC_LFRAME#_R: length 16.4
  BOTTOM w0.089: CPU1.BA12 125.27,64.97 125.27,63.2 126.94,61.53 126.94,61.48 127.14,61.29
  BOTTOM w0.14: R1801.1 130.99,52.14 130.87,52.27 130.85,52.27 129.9,53.22 129.9,57.92 v2(128.16,59.66) 127.9,59.92 127.9,60.58 127.51,60.97 127.46,60.97 127.14,61.29
LPSS_UART2_CTS#: length 20
  TOP w0.114: TP2009.1 130.05,74.41 v1(129.69,74.76) 129.91,74.98 130.81,74.98 130.94,75.11 130.94,75.99 131.27,76.33 132.51,76.33 132.61,76.23 133.4,76.23 133.68,75.95 133.68,75.49 133.91,75.26 134.36,75.26 137.83,78.73 140.46,78.73 v1(142.75,81.01)
  BOTTOM w0.114: v1(129.69,74.76) 129.69,74.21 CPU1.AD4 ; R2046.1 142.49,80.76 v1(142.75,81.01)
LPSS_UART2_RXD: length 115.7
  TOP w0.114: R2048.1 132,74.04 v1(133.13,74.04) 133.54,74.45 135.58,74.45 138.27,71.76 147.47,71.76 147.83,72.12 150.75,72.12 150.87,72.24 152.84,72.24 154.33,70.75 154.33,69.82 154.59,69.56 155.2,68.95 156.06,68.95 v2(156.13,68.87) 156.13,67.44 157.29,66.29 157.29,64.71 159.64,62.36 160.1,62.36 162.5,59.97 165.75,59.97 166.52,59.19 v1(166.65,59.19)
  L3 w0.114: v1(166.65,59.19) 167.58,60.13 167.58,60.85 170.86,64.12 172.21,64.12 172.85,64.76 175.01,64.76 175.47,64.29 175.98,64.29 176.02,64.25 176.51,64.25 179.1,66.84 179.94,66.84 180.68,67.57 182.45,67.57 184.45,69.57 184.63,69.57 187.44,72.37 187.44,74.56 190.12,77.24 190.12,81.13 189.92,81.33 189.92,82.03 190.03,82.14 190.03,82.23 190.45,82.65 190.74,82.95 190.74,86.35 191.05,86.66 191.05,88.43 197.86,95.23 197.86,95.78 205.3,103.22 205.31,103.22 205.96,103.87 208.03,103.87 v1(208.28,104.13)
  BOTTOM w0.114: CPU1.AD1 133.01,73.92 v1(133.13,74.04) ; DB2.3 208.51,103.9 v1(208.28,104.13)
LPSS_UART2_TXD: length 117.3
  TOP w0.114: R2049.1 132.44,73.26 132.51,73.34 v2(132.79,73.34) 132.89,73.44 133.25,73.44 v1(133.86,74.05) 135.46,74.05 138.12,71.39 147.73,71.39 148.08,71.74 151,71.74 151.13,71.87 151.26,71.87 151.26,71.87 152.68,71.87 153.97,70.59 153.97,69.66 154.33,69.3 155.64,67.99 155.64,67.42 156.92,66.13 156.92,64.55 159.48,61.99 159.95,61.99 162.34,59.6 165.56,59.6 v1(166.67,58.48)
  L3 w0.114: v1(208.41,103.24) 208.15,103.49 206.1,103.49 205.46,102.85 205.45,102.85 198.23,95.62 198.23,95.08 191.42,88.27 191.42,86.51 191.11,86.2 191.11,82.79 190.48,82.16 190.48,82.16 190.24,81.92 190.24,81.58 190.25,81.57 190.25,81.53 190.49,81.29 190.49,77.06 187.83,74.4 187.83,72.15 184.76,69.08 184.46,69.08 182.62,67.25 180.87,67.25 180.09,66.47 179.26,66.47 176.66,63.88 175.87,63.88 175.82,63.92 175.32,63.92 174.85,64.39 173,64.39 172.36,63.75 171.01,63.75 167.95,60.69 167.95,59.76 v1(166.67,58.48)
  BOTTOM w0.089: v1(133.86,74.05) 133.46,73.65 132.87,73.65 131.83,73.66 131.72,73.71 131.49,73.71 CPU1.AD2
  BOTTOM w0.114: DB2.2 208.54,103.1 v1(208.41,103.24)
M_A_A0: length 66.8
  L4 w0.114: 102.07,48.51 v1(102.07,55)
  L4 w0.178: v1(80.04,13.65) 78.99,14.69 78.99,17.99 78.51,18.48 78.51,22.08 81.88,25.45 81.91,25.45 81.91,25.45 83.74,25.45 101.09,42.81 101.09,47.54 102.07,48.51
  BOTTOM w0.089: 103.19,59.68 103.14,59.73 103.14,61.05 103.94,61.85 103.94,63.65 104.14,63.84 104.14,64.73 103.7,65.17 CPU1.AY50
  BOTTOM w0.152: 103.19,59.68 v2(103.19,56.45) 103.19,56.12 v1(102.07,55)
  BOTTOM w0.216: DM1.144 80.47,13.34 80.16,13.65 v1(80.04,13.65)
M_A_A1: length 68.1
  TOP w0.216: v2(77.34,17.05) 77.34,17.05 v1(77.98,17.05)
  L4 w0.114: v1(101.93,56.91) 101.68,56.91 101.44,56.67 101.44,54.51 101.37,54.44 101.37,49.34
  L4 w0.178: 101.37,49.34 99.36,47.33 99.36,46.26 99.47,46.16 99.88,46.16 100.08,45.96 100.08,45.35 99.88,45.14 99.3,45.14 99.1,44.94 99.1,44.52 99.97,43.65 99.97,43.09 99.49,42.61 99.01,42.61 98.88,42.73 98.88,43.55 98.76,43.67 98.09,43.67 97.97,43.55 97.97,41.12 83.32,26.47 81.21,26.47 77.47,22.73 77.47,17.41 77.83,17.05 v1(77.98,17.05)
  BOTTOM w0.089: v1(101.93,56.91) 102.24,56.91 102.57,57.24 102.57,61 103.48,61.91 103.48,63.55 103.56,63.77 103.59,63.8 CPU1.BB50
  BOTTOM w0.216: DM1.133 77.73,18.53 77.47,18.27 77.47,17.26 77.67,17.05 v1(77.98,17.05)
M_A_A2: length 71.6
  TOP w0.216: v1(76.66,14.23) 76.58,14.23 76.23,14.59 v2(76.2,14.59)
  L4 w0.102: v1(101.9,57.55) 101.23,56.88 101.23,54.73 101.07,54.57 101.07,49.79
  L4 w0.178: v1(76.66,14.23) 77.28,13.61 77.63,13.61 77.77,13.75 77.77,14.69 76.96,15.5 76.96,22.94 81,26.98 83.1,26.98 97.46,41.33 97.46,44.39 98.86,45.78 98.86,47.58 101.07,49.79
  BOTTOM w0.089: CPU1.AY51 103.43,65.36 103.43,64.67 103.47,64.54 103.47,64.31 103.41,64.04 103.29,63.92 103.29,61.98 102.39,61.08 102.39,58.03 v1(101.9,57.55)
  BOTTOM w0.216: v1(76.66,14.23) 76.96,14.54 77.88,14.54 78.18,14.23 78.18,13.74 77.47,13.03 DM1.132
M_A_A3: length 68.6
  TOP w0.216: v1(78,15.25) v2(78,14.64)
  L4 w0.114: v1(101.95,56.28) 101.66,55.98 101.66,48.84
  L4 w0.178: v1(78,15.25) 78.05,15.25 78.46,15.66 78.46,17.46 77.98,17.94 77.98,22.27 81.67,25.96 83.53,25.96 100.59,43.02 100.59,47.77 101.66,48.84
  BOTTOM w0.089: 102.82,59.44 102.82,61 103.76,61.94 103.76,63.72 103.96,63.92 103.96,64.64 103.86,64.74 CPU1.BA50
  BOTTOM w0.152: v1(101.95,56.28) 102.82,57.15 102.82,59.44
  BOTTOM w0.216: DM1.131 77.22,18.54 77.09,18.4 77.09,16.7 76.68,16.29 76.68,15.23 76.81,15.1 77.88,15.1 78,15.23 v1(78,15.25)
M_A_A4: length 68.2
  TOP w0.216: v1(76.53,12.94) 76.53,12.38 v2(76.5,12.35)
  L4 w0.102: 100.81,50.25 100.81,54.73 100.97,54.89 100.97,58.23 101.56,58.82 v1(101.88,58.82)
  L4 w0.178: v1(76.53,12.94) 76.3,12.94 76.1,13.14 76.1,14.34 76.46,14.69 76.46,23.15 80.79,27.48 82.89,27.48 95.17,39.76 95.17,40.52 96.88,42.22 96.88,43.69 96.88,44.19 96.14,44.92 96.14,45.35 96.44,45.65 98.04,45.65 98.35,45.96 98.35,47.79 100.81,50.25
  BOTTOM w0.089: 101.05,60.65 101.05,60.89 102.37,62.21 CPU1.BB52
  BOTTOM w0.152: v1(101.88,58.82) 101.87,58.82 101.05,59.63 101.05,60.65
  BOTTOM w0.216: v1(76.53,12.94) 76.47,12.88 DM1.128
M_A_A5: length 69.3
  TOP w0.216: v1(74.95,14.21) 74.55,14.21 v2(74.4,14.06)
  L4 w0.102: 100.08,54.57 100.56,55.06 100.56,58.85 v1(101.8,60.08)
  L4 w0.178: v1(74.95,14.21) 74.97,14.21 75.72,14.96 75.72,19.77 75.44,20.05 75.44,23.58 80.36,28.5 82.47,28.5 93.98,40.01 93.98,41.17 95.45,42.65 95.45,42.8 95.45,44.06 95,44.52 95,45.93 100.08,51.01 100.08,54.57
  BOTTOM w0.089: CPU1.BA51 103.25,64.78 103.25,64.63 103.3,64.51 103.3,64.33 103.25,64.15 103.07,63.97 103.07,62.01 102.21,61.15 102.21,60.5 v1(101.8,60.08)
  BOTTOM w0.216: DM1.126 75.97,14.26 75.67,14.56 75.33,14.56 74.98,14.21 v1(74.95,14.21)
M_A_A6: length 70
  L4 w0.102: 99.39,51.85 99.54,52 99.54,56.32 99.92,56.7 v1(100.16,56.7)
  L4 w0.178: v1(74.6,16.68) 74.64,16.68 75.11,17.14 75.11,18.33 74.42,19.01 74.42,24 79.94,29.52 82.05,29.52 90.89,38.35 90.89,40.45 91.2,40.76 91.61,40.76 92.18,40.19 92.6,40.19 92.9,40.49 92.9,40.91 92.33,41.48 92.33,41.9 93.35,42.92 93.94,42.92 94.23,43.22 94.23,43.64 93.94,43.94 93.01,43.94 92.71,44.24 92.71,45.17 99.39,51.85
  BOTTOM w0.089: CPU1.BA52 102.1,64.46 102.1,62.19 100.86,60.95 100.86,60.75 100.84,60.73 v2(100.84,57.82) 100.84,57.39 v1(100.16,56.7)
  BOTTOM w0.216: v1(74.6,16.68) 75.59,16.68 76.23,17.31 76.23,19.6 DM1.127
M_A_A7: length 70.2
  TOP w0.216: v2(74.55,12.53) 74.94,12.92 v1(74.94,12.94)
  L4 w0.102: v1(101.83,59.45) 101.55,59.45 100.77,58.66 100.77,54.97 100.56,54.76 100.56,50.76
  L4 w0.178: 100.56,50.76 95.5,45.71 95.5,44.77 96.37,43.9 96.37,42.43 95.53,41.59 95.11,41.59 94.49,40.96 94.49,39.8 82.68,27.99 80.57,27.99 75.95,23.36 75.95,20.27 76.02,20.2 76.02,14.69 75.74,14.41 75.74,13.14 75.54,12.94 v1(74.94,12.94)
  BOTTOM w0.089: 101.29,60.77 101.29,60.88 102.66,62.24 102.66,64.96 102.76,65.28 102.76,65.75 CPU1.AW52
  BOTTOM w0.152: v1(101.83,59.45) 101.62,59.45 101.29,59.78 101.29,60.77
  BOTTOM w0.216: v1(74.94,12.94) 74.94,12.26 74.97,12.23 DM1.122
M_A_A8: length 69.4
  TOP w0.216: v2(75.21,18.2) 74.96,17.95 v1(74.65,17.95)
  L4 w0.102: v1(100.03,58.13) 99.95,58.13 99.75,57.92 99.75,56.93 99.34,56.53 99.34,54.47 99.24,54.37
  L4 w0.178: 99.24,54.37 99.24,52.44 92.2,45.4 92.2,42.5 89.72,40.02 89.72,39.59 90.38,38.94 90.38,38.56 90.04,38.22 89.66,38.22 89,38.88 88.59,38.88 88.28,38.57 88.28,38.16 88.98,37.46 88.98,37.13 88.66,36.8 88.33,36.8 87.62,37.51 87.24,37.51 86.89,37.17 86.89,35.08 82.23,30.41 80.12,30.41 73.92,24.21 73.92,18.4 74.37,17.95 v1(74.65,17.95)
  BOTTOM w0.089: v1(100.03,58.13) 100.3,58.13 100.64,58.47 100.64,58.91 100.43,59.12 100.43,59.35 100.64,59.57 100.64,59.8 100.43,60.01 100.43,60.24 100.64,60.46 100.64,60.99 101.92,62.26 101.92,64.76 102.47,65.31 CPU1.AY52
  BOTTOM w0.216: v1(74.65,17.95) 74.67,17.97 75.29,17.97 75.73,18.41 DM1.125
M_A_A9: length 67.9
  TOP w0.216: v2(73.56,15.45) 73.51,15.4 73.2,15.4 v1(72.97,15.63)
  L4 w0.102: v1(100,58.76) 100,58.68 99.54,58.23 99.54,57.03 99.14,56.63 99.14,54.88 98.91,54.65 98.91,52.86
  L4 w0.178: v1(72.97,15.63) 73.18,15.63 73.74,16.19 73.74,18.02 73.41,18.35 73.41,24.42 79.91,30.92 80.75,30.92 80.75,30.92 81.59,30.92 81.59,30.92 81.74,30.92 86.39,35.57 86.39,37.4 91.7,42.71 91.7,45.65 98.91,52.86
  BOTTOM w0.089: v1(100,58.76) 99.53,59.23 99.53,60.42 101.34,62.23 CPU1.BB54
  BOTTOM w0.216: v1(72.97,15.63) 73.69,15.63 74.12,16.06 74.12,18.08 74.73,18.69 DM1.121
M_A_A10: length 69.7
  TOP w0.216: v2(82.63,15.91) 82.63,15.76 v1(83.01,15.38)
  L4 w0.089: 104.7,65.36 104.7,65.98 104.19,66.49 103.97,66.49 103.74,66.72 103.74,67.16 103.39,67.52 v1(103.24,67.52)
  L4 w0.178: 104.7,65.36 104.7,62.24 105.31,61.63 105.31,53.88 105,53.58 105,41.35 90.09,26.44 82.4,18.75 82.4,15.76 82.78,15.38 v1(83.01,15.38)
  BOTTOM w0.216: DM1.146 82.97,12.49 81.79,13.68 81.79,14.84 82.3,15.35 82.98,15.35 v1(83.01,15.38) ; CPU1.AT50 103.58,67.85 v1(103.24,67.52)
M_A_A11: length 68.7
  L4 w0.102: 99.54,51.19 99.75,51.39 99.75,55.66 v1(100.15,56.07)
  L4 w0.178: 99.54,51.19 93.9,45.55 93.9,44.89 94.95,43.85 94.95,43.01 94.35,42.42 93.78,42.42 93.47,42.11 93.47,40.22 82.26,29.01 80.15,29.01 74.93,23.79 74.93,19.8 75.41,19.32 75.41,15.81 74.98,15.38 74.68,15.38 v1(74.65,15.4)
  BOTTOM w0.089: v1(100.15,56.07) 99.27,56.95 v2(99.27,57.62) 99.27,60.43 101.07,62.22 101.07,64.11 101.19,64.58 CPU1.BA54
  BOTTOM w0.216: DM1.120 74.47,13.54 73.91,14.11 73.91,14.77 74.55,15.4 v1(74.65,15.4)
M_A_A12: length 69.9
  TOP w0.216: v1(73.03,17.1) 73.23,17.1 73.53,17.41 v2(73.58,17.41)
  L4 w0.102: 98.65,53.33 98.65,54.68 98.93,54.96 98.93,57.06 99.19,57.31 99.19,59.29 v1(99.92,60.03)
  L4 w0.178: v1(73.03,17.1) 72.85,17.1 72.62,17.33 72.62,17.99 72.9,18.27 72.9,20.96 72.29,21.58 72.29,22.01 72.42,22.13 72.8,22.13 72.9,22.24 72.9,22.9 72.77,23.02 72.42,23.02 72.29,23.15 72.29,24.02 79.7,31.43 80.96,31.43 81.38,31.43 83.9,33.95 83.9,35.65 84.07,35.82 84.51,35.82 84.98,35.35 85.4,35.35 85.7,35.65 85.7,36.07 85.23,36.54 85.23,36.96 91.19,42.92 91.19,45.86 98.65,53.33
  BOTTOM w0.089: CPU1.AW54 101.55,65.74 101.55,64.96 101.69,64.82 101.69,62.31 99.97,60.6 99.97,60.08 v1(99.92,60.03)
  BOTTOM w0.216: v1(73.03,17.1) 73.2,16.93 73.49,16.93 73.8,17.23 73.8,18.21 74.23,18.63 74.23,19.6 DM1.119
M_A_A13: length 73.7
  TOP w0.216: v2(85.27,16.62) 85.25,16.64 v1(84.63,16.64)
  L4 w0.102: 107.39,54.98 107.39,61.88 106.73,62.55 106.73,63.94 106.12,64.55 106.12,66.61 105.99,66.74 v1(105.99,66.89)
  L4 w0.178: v1(84.63,16.64) 85.32,17.32 85.32,17.99 91.03,23.71 93.01,23.71 97.15,27.85 97.15,28.13 96.45,28.83 96.45,29.19 96.81,29.55 97.17,29.55 97.87,28.85 98.16,28.85 98.59,29.28 98.59,29.57 97.9,30.26 97.9,30.64 98.24,30.98 98.53,30.98 99.04,30.47 99.4,30.47 99.76,30.83 99.76,31.19 99.25,31.7 99.25,31.99 107.57,40.31 107.57,54.8 107.39,54.98
  BOTTOM w0.216: v1(105.99,66.89) 105.86,66.89 105.55,67.2 CPU1.AU46 ; v1(84.63,16.64) 85.03,16.64 86.06,15.61 86.06,12.41 85.97,12.33 DM1.158
M_A_A14: length 70.7
  TOP w0.216: v2(83.97,17.94) 84.23,17.94 84.23,17.94 v1(84.58,17.94)
  L4 w0.102: v1(106.01,67.52) 105.82,67.71 105.42,67.71 105.12,67.41 105.12,66.95 105.92,66.15 105.92,64.42 106.53,63.82 106.53,62.37 107.08,61.81 107.08,55.76 107.06,55.74
  L4 w0.178: 107.06,55.74 107.06,40.52 95.3,28.76 95.3,28.49 96.01,27.78 96.01,27.42 95.66,27.06 95.3,27.06 94.61,27.74 94.25,27.74 93.9,27.38 93.9,27.02 94.55,26.37 94.55,25.96 94.24,25.65 93.83,25.65 93.16,26.32 92.87,26.32 92.44,25.89 92.44,25.61 93.1,24.95 93.1,24.53 92.8,24.23 92.38,24.23 91.72,24.89 91.43,24.89 84.58,18.04 v1(84.58,17.94)
  BOTTOM w0.216: DM1.151 84.23,19.6 84.23,18.35 84.58,17.99 v1(84.58,17.94) ; CPU1.AT46 105.8,67.55 105.98,67.55 v1(106.01,67.52)
M_A_A15: length 70.3
  TOP w0.216: v2(82.8,14.46) 83.06,14.21 v1(83.34,14.21)
  L4 w0.102: v1(104.13,66.88) 104.94,66.07 104.94,62.81 105.31,62.44
  L4 w0.178: 105.31,62.44 105.61,62.14 105.61,53.76 105.51,53.65 105.51,41.26 105.49,41.23 105.49,41.15 90.56,26.23 90.56,26.23 89.72,25.39 84.33,20 84.33,20 83.01,18.68 83.01,17.92 83.41,17.51 83.41,16.96 83.04,16.58 83.04,16.08 83.52,15.61 83.52,14.39 v1(83.34,14.21)
  BOTTOM w0.216: v1(83.34,14.21) 83.35,14.21 83.84,13.73 84.33,13.73 84.78,14.18 84.85,14.18 85.06,14.39 85.44,14.39 85.74,14.08 85.74,12.93 85.47,12.66 DM1.156 ; v1(104.13,66.88) 104.28,66.88 104.59,67.18 CPU1.AU48
M_A_A16: length 69.3
  TOP w0.216: v2(84.4,13.52) 84.6,13.72 v1(84.97,13.72)
  L4 w0.102: v1(104.09,67.52) 104.09,67.5 104.65,66.94 104.65,66.71 105.36,66 105.36,64.27 105.61,64.02
  L4 w0.178: v1(84.97,13.72) 84.97,13.59 84.66,13.27 84.12,13.27 83.82,13.57 83.82,18.73 91.1,26.02 106.02,40.93 106.02,56.33 105.95,56.39 105.95,63.68 105.61,64.02
  BOTTOM w0.216: DM1.152 84.48,11.4 84.48,13.42 84.77,13.72 v1(84.97,13.72) ; CPU1.AU50 103.77,67.2 v1(104.09,67.52)
M_A_ACT_N: length 70.3
  TOP w0.216: v2(72.64,14.59) 72.31,14.59 v1(72.06,14.84)
  L4 w0.178: v1(98.73,59.37) 98.68,59.37 96.42,57.11 96.42,54.81 88.65,47.04 88.65,44.06 68.69,24.1 68.69,16.99 70.84,14.84 v1(72.06,14.84)
  BOTTOM w0.089: v1(98.73,59.37) 99.01,59.65 99.01,60.42 100.89,62.3 100.89,64.13 100.96,64.42 100.96,64.78 CPU1.BA55
  BOTTOM w0.216: v1(72.06,14.84) 72.69,14.21 72.69,12.91 72.97,12.63 DM1.114
M_A_ALERT_N: length 73.9
  TOP w0.216: v1(73.28,13.07) 73.28,13.04 72.92,12.69 v2(72.92,12.63)
  L4 w0.178: v1(104.09,65.77) 104.09,61.63 104.7,61.02 104.7,54.13 103.96,53.4 103.96,41.92 81.61,19.57 81.61,13.64 80.45,12.48 73.86,12.48 v1(73.28,13.07)
  BOTTOM w0.216: CPU1.AW50 103.9,66.04 104.09,65.85 v1(104.09,65.77) ; v1(73.28,13.07) 73.47,12.87 DM1.116
M_A_BA0: length 68.7
  TOP w0.216: v1(83.33,13.57) 83.16,13.57 82.83,13.24 v2(82.8,13.24)
  L4 w0.102: 104.38,65.12 104.38,65.51 104.48,65.61 104.48,65.93 104.19,66.23 103.87,66.23 v1(103.22,66.88)
  L4 w0.178: 104.38,65.12 104.38,61.75 105,61.13 105,54.01 104.47,53.47 104.47,41.5 89.61,26.64 89.32,26.35 89.11,26.35 81.99,19.23 81.99,14.08 82.5,13.57 v1(83.33,13.57)
  BOTTOM w0.216: DM1.150 83.97,12.98 83.38,13.57 v1(83.33,13.57) ; CPU1.AU52 102.89,67.2 v1(103.22,66.88)
M_A_BA1: length 71.4
  TOP w0.216: v1(84.66,14.69) 85.24,14.69 v2(85.27,14.67)
  L4 w0.102: v1(104.13,68.18) 104.93,67.38 104.93,66.73 105.64,66.02 105.64,64.37 106.32,63.69 106.32,62.3 106.88,61.75 106.88,56.09 106.65,55.87
  L4 w0.178: v1(84.66,14.69) 84.12,15.23 84.12,18.3 106.53,40.7 106.53,55.74 106.65,55.87
  BOTTOM w0.216: v1(84.66,14.69) 84.56,14.69 82.59,16.65 82.59,18.58 82.73,18.71 DM1.145 ; v1(104.13,68.18) 104.46,67.85 CPU1.AT48
M_A_BG0: length 70.3
  TOP w0.216: v2(70.46,15.02) 70.48,15.02 70.86,15.4 v1(70.94,15.4)
  L4 w0.178: v1(70.94,15.4) 70.88,15.4 69.86,16.42 69.86,18.27 69.2,18.93 69.2,23.8 89.16,43.76 89.16,46.83 96.9,54.58 96.9,56.91 98.65,58.66 v1(98.68,58.66)
  BOTTOM w0.089: v1(98.68,58.66) 98.23,59.1 98.23,60.22 100.46,62.44 100.46,64.19 100.42,64.32 100.42,64.49 100.46,64.63 100.46,64.83 100.45,64.85 100.44,64.91 100.42,64.97 100.42,65.55 CPU1.AY55
  BOTTOM w0.216: DM1.115 73.23,19.6 73.23,18.68 72.4,17.86 72.4,16.86 v1(70.94,15.4)
M_A_BG1: length 70.7
  TOP w0.216: v2(70.26,16.67) 70.26,16.67 v1(70.86,16.67)
  L4 w0.102: 97.3,54.26 97.41,54.37 97.41,56.23 v1(98.58,57.4)
  L4 w0.178: v1(70.86,16.67) 70.77,16.67 70.37,17.07 70.37,18.46 70.61,18.7 71.09,18.7 71.27,18.88 71.27,19.26 70.97,19.57 70.13,19.57 69.72,19.97 69.72,23.61 89.66,43.55 89.66,46.62 97.3,54.26
  BOTTOM w0.089: v1(98.58,57.4) 98.06,57.92 98.06,60.29 100.28,62.51 100.28,64.17 100.24,64.3 100.24,64.51 100.27,64.63 100.28,64.66 100.28,64.8 100.27,64.87 100.23,64.94 100.16,65.01 100.14,65.02 99.93,65.07 99.76,65.21 99.76,65.55 99.93,65.71 100.14,65.71 100.43,66 100.7,66 101.24,65.45 CPU1.AY54
  BOTTOM w0.216: DM1.113 72.73,18.74 72.04,18.06 72.04,17.77 71.02,16.74 70.94,16.74 v1(70.86,16.67)
M_A_CKE0: length 72.5
  TOP w0.216: v1(70.87,17.3) 71.32,17.3 v2(71.42,17.41)
  L4 w0.178: v1(98.53,56.4) 98.15,56.4 97.79,56.04 97.79,53.96 90.17,46.34 90.17,43.34 82.4,35.56 82.4,35.14 82.81,34.73 82.81,34.31 82.51,34.01 82.09,34.01 81.66,34.45 81.3,34.45 80.94,34.09 80.94,33.73 81.37,33.29 81.37,32.87 81.08,32.57 80.66,32.57 80.24,32.99 79.82,32.99 71.23,24.4 71.23,23.54 70.94,23.24 70.55,23.24 70.26,22.94 70.26,22.52 70.55,22.23 71.12,22.23 71.25,22.1 71.25,21.22 71.12,21.09 70.54,21.09 70.23,20.79 70.23,20.25 70.46,20.03 71.48,20.03 71.83,19.67 71.83,17.61 71.52,17.3 v1(70.87,17.3)
  BOTTOM w0.089: 97.43,59.42 97.43,60.22 99.75,62.55 99.75,64.18 99.83,64.35 99.91,64.52 99.91,64.62 CPU1.BA56
  BOTTOM w0.152: v1(98.53,56.4) 98.22,56.09 97.54,56.09 97.43,56.2 97.43,59.42
  BOTTOM w0.216: v1(70.87,17.3) 70.87,17.31 70.87,17.34 70.91,17.3 71.13,17.3 71.73,17.9 DM1.109
M_A_CKE1: length 72.4
  TOP w0.216: v2(71.45,13.35) 71.78,13.35 v1(72.01,13.57)
  L4 w0.178: v1(72.01,13.57) 72.21,13.57 72.52,13.88 72.52,15.27 72.21,15.58 72.21,20.23 71.74,20.7 71.74,21.1 71.75,21.11 71.75,24.2 79.49,31.94 81.17,31.94 83.39,34.16 83.39,35.84 90.68,43.13 90.68,46.13 98.3,53.75 98.3,54.9 v1(98.53,55.13)
  BOTTOM w0.089: 97.68,59.69 97.68,60.21 100.02,62.54 CPU1.BB56
  BOTTOM w0.152: v1(98.53,55.13) 98.95,55.55 98.95,56.57 98.54,56.98 98.4,56.98 97.68,57.7 97.68,59.69
  BOTTOM w0.216: v1(72.01,13.57) 71.84,13.75 71.82,13.75 71.1,14.46 69.98,14.46 69.85,14.34 69.85,13.7 69.98,13.57 70.67,13.57 71.97,12.27 DM1.110
M_A_CLK0: length 72.4
  TOP w0.127: v1(79.65,17.21) 80.06,17.21 v2(80.26,17)
  L4 w0.102: v1(79.65,17.21) 79.68,17.18 80.26,17.18 80.49,17.42 80.49,18.6 79.86,19.24 79.86,21.5 79.59,21.77 79.59,21.91 79.81,22.13 79.95,22.13 80.46,21.62 80.81,21.62 81.1,21.92 81.1,22.26 80.6,22.77 80.6,23.14 81.5,24.05 83.67,24.05 88.22,28.6 88.22,28.6 101.85,42.24 101.85,47.14 102.45,47.74 102.45,47.75 102.75,48.04 102.75,60.92 102.39,61.28 102.39,62.24 102.05,62.58 100.89,62.58 100.72,62.75 100.72,62.99 100.89,63.15 102.24,63.15 102.49,63.41 102.49,63.77 102.24,64.02 101.91,64.02 101.57,64.36 101.57,65.67 101.93,66.03 101.93,67.14 101.55,67.52 v1(101.39,67.52)
  BOTTOM w0.127: CPU1.AT53 101.72,67.85 v1(101.39,67.52) ; v1(79.65,17.21) 79.54,17.32 79.15,17.32 78.85,17.62 78.85,18.57 78.73,18.69 DM1.137
M_A_CLK1: length 72.4
  TOP w0.127: v2(80.52,15.48) 80.83,15.17 v1(81.11,15.17)
  L4 w0.102: v1(100.52,67.51) 100.73,67.73 100.73,67.76 101.19,68.21 101.59,68.21 102.54,67.26 102.54,66.43 103.15,65.82 103.15,47.42 102.54,46.8 102.54,42.29 102.54,41.95 88.5,27.91 88.5,27.91 80.96,20.37 80.49,19.9 80.49,19.32 81.18,18.64 81.18,16.87 80.37,16.06 80.37,15.03 80.49,14.9 80.9,14.9 81.11,15.12 v1(81.11,15.17)
  BOTTOM w0.127: DM1.138 78.97,12.18 79.1,12.3 79.1,13.76 80.31,14.97 80.92,14.97 v1(81.11,15.17) ; v1(100.52,67.51) 100.86,67.85 CPU1.AT55
M_A_CLK#0: length 72.4
  TOP w0.127: v1(79.63,17.87) v2(79.63,18.53)
  L4 w0.102: v1(79.63,17.87) 79.63,17.81 80.05,17.38 80.17,17.38 80.29,17.5 80.29,18.52 79.65,19.15 79.65,21.41 79.39,21.68 79.39,21.99 79.72,22.33 80.03,22.33 80.54,21.82 80.72,21.82 80.9,22 80.9,22.18 80.39,22.69 80.39,23.23 81.42,24.25 83.58,24.25 88.13,28.8 101.65,42.32 101.65,47.23 102.25,47.82 102.25,47.83 102.54,48.13 102.54,60.83 102.18,61.19 102.18,62.16 101.97,62.37 100.81,62.37 100.52,62.66 100.52,63.07 100.81,63.36 102.16,63.36 102.29,63.49 102.29,63.68 102.16,63.82 101.83,63.82 101.37,64.27 101.37,65.75 101.73,66.11 101.73,66.73 101.6,66.85 v1(101.41,66.85)
  BOTTOM w0.127: v1(79.63,17.87) 79.63,17.77 79.42,17.56 79.25,17.56 79.1,17.72 79.1,18.5 79.22,18.63 DM1.139 ; v1(101.41,66.85) 101.41,66.81 101.54,66.69 102.16,66.69 102.29,66.81 102.29,67.08 102.16,67.2 CPU1.AU53
M_A_CLK#1: length 72.4
  TOP w0.127: v2(80.52,14.21) 80.77,14.46 v1(81.11,14.46)
  L4 w0.102: v1(81.11,14.46) 80.87,14.7 80.41,14.7 80.16,14.94 80.16,16.14 80.98,16.95 80.98,18.55 80.29,19.24 80.29,19.99 80.81,20.51 88.42,28.12 88.42,28.12 102.34,42.04 102.34,42.2 102.34,46.89 102.95,47.5 102.95,65.73 102.34,66.35 102.34,67.18 101.51,68.01 101.27,68.01 100.96,67.7 100.96,67.33 v1(100.51,66.88)
  BOTTOM w0.127: v1(81.11,14.46) 80.84,14.73 80.41,14.73 79.34,13.66 79.34,12.44 79.47,12.3 DM1.140 ; v1(100.51,66.88) 100.84,67.2 CPU1.AU55
