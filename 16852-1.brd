# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DQA1_23: length 38.3
  L6 w0.14: v1(189.97,90.92) 189.97,91.3 189.69,91.58 189.1,91.58 188.81,91.29 188.81,90.51 188.69,90.38 188.47,90.38 188.34,90.26 188.34,89.83 188.21,89.7 187.9,89.7 187.77,89.58 187.77,89.15 187.64,89.02 186.32,89.02 186.2,89.15 186.2,89.31 186.36,89.48 187.01,89.48 187.14,89.6 187.14,90.18 187.01,90.3 186.46,90.3 186.33,90.43 186.33,91.07 186.2,91.2 185.91,91.2 185.76,91.35 184.99,91.35 184.98,91.36 184.59,91.36 184.46,91.49 184.46,92.75 184.26,92.95 184.14,93.08 183.87,93.08 183.75,93.21 183.75,93.69 183.85,93.8 184.79,93.8 184.92,93.92 184.92,95.41 184.36,95.98 182.98,95.98 182.85,96.1 182.85,97.09 182.98,97.22 184.03,97.22 184.33,97.52 184.33,98.43 183.96,98.79 183.96,99.95 183.54,100.37 182.46,100.37 182.27,100.56 182.27,101.05 182.46,101.25 183.05,101.25 183.17,101.37 183.17,102.12 183.05,102.24 182.46,102.24 182.34,102.37 182.34,103.78 182.63,104.07 v1(182.8,104.07)
  BOTTOM w0.178: GPU1.E1 188.06,90.34 188.59,90.34 189.17,90.92 v1(189.97,90.92) ; VRAM3.F2 184.59,104.87 183.59,104.87 v1(182.8,104.07) v2(181.71,104.07)
DQA1_24: length 45
  TOP w0.178: VRAM4.C8 184.65,102.53 183.82,102.53 183.81,102.54 183.44,102.54 183.17,102.27 183.17,100.87 183.29,100.74 183.68,100.74 183.81,100.62 183.81,99.97 183.68,99.84 182.57,99.84 182.44,99.71 182.44,99.01 182.45,99 182.45,98.83 182.7,98.57 183.15,98.57 183.33,98.75 183.33,98.96 183.45,99.08 183.91,99.08 184.04,98.96 184.04,98.75 184.21,98.57 185.91,98.57 186.04,98.45 186.04,97.96 185.91,97.83 182.81,97.83 182.66,97.68 182.65,97.68 182.48,97.5 182.48,97.08 182.63,96.93 183.18,96.93 183.35,96.75 183.35,96.22 183.18,96.04 182.44,96.04 182.11,95.71 181.72,95.71 181.5,95.49 181.5,94.7 182.04,94.16 182.5,94.16 182.63,94.29 182.63,95.2 182.76,95.33 183.22,95.33 183.34,95.2 183.34,94.27 183.47,94.14 183.94,94.14 184.07,94.27 184.07,94.6 184.24,94.78 184.69,94.78 184.82,94.9 184.82,95.36 184.69,95.49 184.24,95.49 184.07,95.67 184.07,96.11 184.17,96.21 185.66,96.21 185.77,96.11 185.77,94.85 185.37,94.45 185.37,93.53 185.24,93.41 182.8,93.41 182.68,93.28 182.68,92.81 182.8,92.68 184.39,92.68 184.52,92.55 184.52,91.82 184.39,91.69 183.55,91.69 183.42,91.56 v2(183.42,90.59) 183.42,89.49 183.66,89.25 184.62,89.25 184.93,88.94 v1(184.93,88.76)
  BOTTOM w0.178: GPU1.G7 184.56,88.4 184.92,88.76 v1(184.93,88.76)
DQA1_25: length 44.7
  TOP w0.178: VRAM4.B8 185.02,101.93 185.39,101.56 185.39,100.5 184.53,99.65 184.53,99.15 184.67,99.02 185.17,99.02 185.29,99.14 185.29,99.4 185.46,99.57 185.74,99.57 186.5,98.8 186.5,97.51 186.37,97.39 183.98,97.39 183.8,97.21 183.8,96.84 183.98,96.66 186.16,96.66 186.34,96.83 189.68,96.83 189.8,96.71 189.8,96.33 189.68,96.2 189.5,96.2 189.37,96.08 189.37,94.83 189.18,94.63 188.79,94.63 188.66,94.76 188.66,95.93 188.48,96.11 188.13,96.11 187.95,95.93 187.95,94.68 187.82,94.56 187.37,94.56 187.24,94.68 187.24,95.93 187.06,96.11 186.35,96.11 186.22,95.98 186.22,95.51 186.5,95.23 186.5,94.51 186.37,94.38 185.93,94.38 185.8,94.26 185.8,93.77 185.93,93.64 186.16,93.64 186.29,93.52 186.29,93.27 185.93,92.91 185.05,92.91 184.87,92.73 184.87,91.75 185,91.63 185.66,91.63 185.78,91.5 185.78,91.04 185.66,90.91 184.67,90.91 184.54,90.79 184.54,90.3 184.67,90.17 186.25,90.17 186.47,89.95 v2(186.47,89.09) 186.47,88.56 187.2,87.83 187.2,87.23 186.94,86.97 186.55,86.97 186.32,87.2 186.32,87.57 186.13,87.76 185.89,87.76 185.7,87.95 v1(185.7,88.78)
  BOTTOM w0.178: GPU1.G6 185.7,88.78 v1(185.7,88.78)
DQA1_26: length 43.7
  TOP w0.178: VRAM4.A3 188.76,101.3 188.44,100.98 188.44,100.45 189.32,99.58 192.53,99.58 192.73,99.38 194.85,99.38 195.65,100.18 v2(196.77,100.18) 197.94,100.18 198.99,101.23 199.45,101.68 199.81,101.68 199.93,101.56 200.12,101.36 200.12,101.18 199.94,101 199.94,100.83 200.36,100.41 200.53,100.41 200.75,100.62 200.93,100.62 201.21,100.34 201.21,100.03 199.62,98.44 198.88,97.69 198.88,94.25 199.46,93.66 199.46,92.02 197.85,90.4 195.13,90.4 195.07,90.34 195.07,90.34 194.81,90.08 192.24,90.08 191.98,90.34 191.98,90.34 191.6,90.72 191.6,90.77 191.6,90.77 191.6,90.93 191.47,91.06 190.99,91.06 190.71,90.77 190.71,90.47 191.27,89.9 191.64,89.54 191.64,89.17 190.64,88.18 190.2,88.18 189.59,88.79 v1(189.59,89.15)
  BOTTOM w0.102: GPU1.G1 187.84,88.52 188.96,88.52 v1(189.59,89.15)
DQA1_27: length 44
  TOP w0.178: VRAM4.C3 188.91,103.01 188.42,103.01 188.12,102.71 188.12,102.3 188.41,102.01 188.41,101.51 188.12,101.22 188.12,100.29 189.13,99.29 192.06,99.29 192.07,99.29 192.37,99.29 192.73,98.93 195.03,98.93 195.29,99.19 195.29,99.19 195.84,99.73 198.13,99.73 v2(198.91,100.52) 199.18,100.78 199.36,100.78 200.26,99.88 200.26,99.7 199.18,98.62 199.18,98.62 198.43,97.88 198.43,94.06 199.01,93.48 199.01,92.2 197.66,90.85 194.95,90.85 194.62,90.52 192.43,90.52 192.04,90.91 192.04,90.95 192.04,90.96 192.04,91.5 191.92,91.62 190.93,91.62 190.43,91.12 190.43,90.12 190.82,89.72 190.82,88.99 190.67,88.83 190.22,88.83 190.09,88.96 190.09,89.46 189.96,89.59 189.22,89.59 188.95,89.32 v1(188.95,89.15)
  BOTTOM w0.102: v1(188.95,89.15) 188.55,88.74 188.15,88.74 188.13,88.76 187.42,88.76 187.06,88.4 GPU1.G3
DQA1_28: length 45.4
  TOP w0.178: v1(185.88,87.32) 185.88,86.94 186.46,86.36 187.13,86.36 187.48,86.7 187.48,88 186.93,88.55 186.93,90.07 v2(186.39,90.61) 186.06,90.93 186.06,91.63 185.8,91.89 185.8,92.14 186.66,93 186.66,93.97 186.91,94.22 189.39,94.22 189.82,94.64 189.82,95.45 190.25,95.88 190.25,96.52 190.37,96.65 190.78,96.65 191.09,96.34 191.09,95.96 191.21,95.83 192.11,95.83 192.29,95.65 192.29,94.61 192.42,94.48 192.87,94.48 193,94.61 193,95.65 193.18,95.83 193.53,95.83 193.71,95.65 193.71,94.26 193.84,94.14 195.76,94.14 195.88,94.26 195.88,94.72 195.76,94.85 194.58,94.85 194.46,94.98 194.46,95.43 194.58,95.56 195.79,95.56 195.92,95.69 195.92,96.42 195.79,96.55 192.07,96.55 192.06,96.56 191.93,96.56 191.21,97.28 187.43,97.28 186.97,97.75 186.97,98.86 185.78,100.04 185.78,101.26 VRAM4.A7
  BOTTOM w0.178: v1(185.88,87.32) 185.84,87.32 GPU1.J6
DQA1_29: length 44.3
  TOP w0.178: VRAM4.C2 189.95,102.9 190.19,102.66 190.19,101.15 189.85,100.81 189.85,100.39 189.98,100.26 194.48,100.26 194.76,100.55 195.28,101.07 197.57,101.07 200.03,103.52 200.64,103.52 202.97,101.19 202.97,100.53 199.77,97.32 199.77,94.61 200.35,94.03 200.35,91.65 198.21,89.51 195.77,89.51 195.37,89.11 192.84,89.11 v2(191.53,87.8) 191.05,87.33 191.05,87.31 190.92,87.19 190.39,87.19 189.91,86.7 189.45,86.7 v1(189.33,86.58)
  BOTTOM w0.102: GPU1.J1 187.91,86.61 188.18,86.61 188.18,86.6 188.48,86.6 188.5,86.58 v1(189.33,86.58)
DQA1_30: length 44.6
  TOP w0.178: VRAM4.A2 189.68,101.3 189.62,101.24 189.48,101.24 189.15,100.91 189.15,100.3 189.5,99.95 192.6,99.95 192.73,99.82 194.67,99.82 195.21,100.36 195.47,100.62 197.76,100.62 198.81,101.67 199.26,102.13 199.69,102.13 199.82,102.25 199.82,102.68 200.04,102.91 200.59,102.91 200.72,102.78 v2(200.72,102.42) 200.72,102.11 200.43,101.83 200.43,101.68 200.57,101.55 200.82,101.29 201,101.29 201.51,101.81 201.69,101.81 202.31,101.2 202.31,100.49 201.66,99.85 201.66,99.85 200.07,98.25 199.32,97.51 199.32,94.43 199.9,93.85 199.9,91.83 198.03,89.96 195.63,89.96 195.62,89.95 195.58,89.95 195.26,89.63 192.73,89.63 190.73,87.63 190.34,87.63 189.79,87.08 188.74,87.08 v1(188.67,87.01)
  BOTTOM w0.178: v1(188.67,87.01) 188.05,87.01 187.89,87.17 187.29,87.17 GPU1.J3
DQA1_31: length 44.8
  TOP w0.178: VRAM4.D7 185.7,103.7 185.45,103.45 185.45,101.95 185.71,101.69 186.44,101.69 186.67,101.46 186.67,99.71 187.41,98.98 187.41,98.09 187.78,97.72 191.39,97.72 192.11,97 196.14,97 196.42,96.72 196.42,93.03 196.29,92.91 195.79,92.91 195.67,93.03 195.67,93.43 195.49,93.61 195.13,93.61 194.96,93.43 194.96,93.02 194.83,92.9 194.28,92.9 194.15,93.02 194.15,93.45 193.97,93.63 193.53,93.63 193.19,93.96 192.31,93.96 191.84,94.43 191.84,95.26 191.72,95.38 190.38,95.38 190.26,95.27 190.26,94.46 189.71,93.9 189.7,93.9 189.67,93.87 187.3,93.87 187.07,93.64 187.07,92.87 186.43,92.24 186.43,91.17 187.24,90.36 187.24,88.74 187.79,88.19 187.79,87.35 187.91,87.22 187.91,86.62 187.13,85.83 v2(186.77,85.83) 186.3,85.83 v1(185.91,86.22)
  BOTTOM w0.178: v1(185.91,86.22) 185.91,86.59 GPU1.J5
DQMA0: length 43.3
  TOP w0.178: v1(165.51,89.6) 165.38,89.6 163.82,91.15 163.82,92.29 163.04,93.08 161.42,93.08 159.97,91.63 v2(159.97,91.09) 159.97,89.18 159.72,88.92 159.35,88.92 159.22,89.05 159.22,90.46 159.1,90.59 158.6,90.59 158.48,90.46 158.48,90.03 158.35,89.9 157.81,89.9 156.93,90.79 156.93,91.21 157.05,91.34 159.08,91.34 159.2,91.46 159.2,91.85 158.5,92.55 158.25,92.55 157.74,92.05 156.43,92.05 156.29,92.19 156.29,92.72 156.66,93.08 157.2,93.08 157.32,93.21 157.32,93.9 156.89,94.34 156.89,94.61 157.32,95.05 157.32,95.4 156.89,95.84 156.89,96.62 157.57,97.31 159.21,97.31 159.84,97.94 160.26,97.94 160.26,97.95 161.55,97.95 161.55,97.94 162.68,97.94 163.23,98.49 163.23,98.69 165.11,100.57 165.11,102.59 166.22,103.7 VRAM1.D3
  BOTTOM w0.178: v1(165.51,89.6) 165.91,90 GPU1.E32
DQMA1: length 37.9
  TOP w0.178: VRAM1.E7 163.7,104.12 163.7,103.82 v1(164.39,103.13)
  L6 w0.14: v1(162.1,89.14) 162,89.04 159.87,89.04 159.38,88.55 159.38,87.66 160.13,86.91 161.07,86.91 161.3,87.13 161.3,87.33 160.7,87.93 160.7,88.11 160.91,88.33 161.09,88.33 161.69,87.73 161.89,87.73 162.97,88.8 162.97,89.83 163.54,90.4 163.54,92.36 162.13,93.78 162.13,93.8 160.85,95.07 160.85,99.45 161.28,99.88 161.28,100.32 161.88,100.92 162.43,100.92 162.56,101.05 162.56,102.59 163.36,103.39 164.14,103.39 v1(164.39,103.13)
  BOTTOM w0.152: GPU1.E30 166.92,90.26 166.8,90.38 165.76,90.38 165.4,90.03 165.33,90.03 165.25,89.95 164.83,89.95 164.71,90.07 164.71,90.56 164.58,90.68 164.17,90.68 164.04,90.56 164.04,89.82 163.91,89.7 163.14,89.7 163.04,89.6 163.04,89.2 162.92,89.07 v2(162.69,89.07) 162.17,89.07 v1(162.1,89.14)
DQMA2: length 44.8
  BOTTOM w0.102: GPU1.A21 173.46,92.05 173.46,92.78 172.03,94.2 172.03,94.3
  BOTTOM w0.178: 172.03,94.3 172.03,98.01 172.71,98.69 173.29,98.69 173.42,98.56 173.42,97.03 173.66,96.78 174.02,96.78 174.14,96.91 174.14,97.11 174.27,97.24 174.71,97.24 174.84,97.36 174.84,97.84 174.71,97.97 174.26,97.97 174.13,98.09 174.13,98.55 174.26,98.68 175.52,98.68 175.63,98.79 175.63,99.48 176.87,100.71 176.87,100.72 177.11,100.96 177.11,107.37 176.86,107.62 176.74,107.74 176.17,108.31 v2(173.41,108.31) 172.32,108.31 172.26,108.25 171.72,107.71 171.16,107.15 171.16,104.5 170.69,104.03 169.61,104.03 169.27,103.7 168.9,103.7 168.48,104.13 166.29,104.13 166.01,103.85 165.71,103.85 165.53,103.66 165.53,102.99 164.84,102.3 164.29,102.3 163.94,102.65 163.94,103.57 163.81,103.7 VRAM2.D3
DQMA3: length 39.5
  L4 w0.152: v1(165.07,103.77) 165.88,103.77 166.01,103.64 166.01,102.69 165.88,102.57 165.31,102.57 165.18,102.44 165.18,101.37 165.31,101.24 167.45,101.24 167.57,101.11 167.57,100.65 167.45,100.53 165.33,100.53 165.2,100.4 165.2,98.54 165.33,98.41 166.18,98.41 166.35,98.58 166.35,99.74 166.48,99.87 166.88,99.87 167.01,99.74 167.01,98.58 167.18,98.41 167.65,98.41 167.81,98.58 167.81,99.89 167.98,100.06 168.31,100.06 168.47,99.89 168.47,98.58 168.64,98.41 168.97,98.41 169.13,98.58 169.13,100.93 169.26,101.06 169.66,101.06 169.79,100.93 169.79,98.58 169.96,98.41 172.62,98.41 v1(172.9,98.13)
  BOTTOM w0.102: v1(172.9,98.13) 172.73,98.13 172.44,97.84 v2(172.44,97.57) 172.44,94.08 173.66,92.86 173.66,91.54 GPU1.C21
  BOTTOM w0.178: v1(165.07,103.77) 165.43,104.13 165.89,104.13 166.27,104.5 VRAM2.E7
DQMA4: length 40.3
  TOP w0.178: v1(186.89,103.13) 186.2,103.82 186.2,104.12 VRAM4.E7
  L4 w0.152: v1(182.46,98.15) 182.46,97.19 182.86,96.8 182.86,95.89 182.98,95.77 183.38,95.77 183.6,96 184.05,96 184.31,95.74 184.66,95.74 184.94,96.02 184.94,96.2 184.8,96.33 184.44,96.7 184.43,96.7 184.43,96.7 184.43,97.2 184.24,97.38 184.24,97.99 184.43,98.18 184.43,98.64 184.56,98.77 184.96,98.77 185.09,98.64 185.09,97.01 185.33,96.76 185.72,96.76 186.94,97.98 186.94,98.58 187.07,98.7 187.66,98.7 187.78,98.58 187.78,98.43 187.95,98.27 188.28,98.27 188.44,98.43 188.44,98.58 188.57,98.71 189.08,98.71 189.21,98.58 189.21,98.4 189.33,98.27 189.86,98.27 189.98,98.4 189.98,98.61 190.11,98.73 190.59,98.73 190.72,98.61 190.72,98.4 190.84,98.27 191.38,98.27 191.5,98.4 191.5,99.02 191.52,99.03 191.52,99.04 191.88,99.4 191.88,100.18 191.75,100.31 191.23,100.31 190.99,100.07 190.94,100.07 190.91,100.04 190.04,100.04 190.02,100.07 188.27,100.07 188.14,100.2 188.14,102.57 188.01,102.7 187.34,102.7 186.9,103.13 v1(186.89,103.13)
  BOTTOM w0.102: GPU1.E13 180.03,90.64 180.21,91.32 180.25,91.4 180.25,91.82 180.08,91.99 180.08,92.23 180.11,92.39 180.11,92.53 182.38,94.8 182.38,94.99
  BOTTOM w0.152: 182.38,94.99 182.38,96.8
  BOTTOM w0.178: v1(182.46,98.15) 182.45,98.14 182.45,97.94 182.46,97.93 v2(182.46,97.34) 182.46,96.87 182.38,96.8
DQMA5: length 45.4
  BOTTOM w0.102: 184.16,95.78 184.16,95.06 v2(184.06,94.96) 181.51,92.41 181.51,92 181.65,91.67 181.65,91.55 181.63,91.47 181.59,91.39 181.59,91.07 181.65,90.91 181.65,90.68 181.57,90.58 181.32,90.33 181.18,90.33 180.99,90.14 180.99,89.98 180.87,89.85 180.49,89.85 180.39,89.95 180.39,90.3 180.49,90.4 GPU1.D12
  BOTTOM w0.178: 184.16,95.78 184.44,96.06 184.87,96.06 184.98,96.17 184.99,96.17 186.23,97.4 192.55,97.4 193.18,96.78 194.32,96.78 194.48,96.63 195.35,96.63 195.48,96.5 195.48,96.18 195.61,96.05 196.18,96.05 196.3,96.18 196.3,97.56 196.18,97.69 195.9,97.69 195.77,97.82 195.77,98.33 195.9,98.46 196.32,98.46 197.63,99.76 197.63,100.12 197.5,100.25 194.33,100.25 193.94,99.86 193.94,99.19 193.82,99.06 193.35,99.06 193.22,99.19 193.22,99.43 193.12,99.54 192.7,99.54 192.11,98.95 189.43,98.95 188.44,99.93 187.91,99.93 187.78,100.06 187.78,102.28 187.65,102.41 186.57,102.41 186.51,102.47 185.52,102.47 185.42,102.57 185.42,103.46 185.66,103.7 VRAM3.D3
DQMA6: length 37.3
  L6 w0.14: v1(189.18,90.13) 189.24,90.13 189.52,89.85 189.78,89.59 189.97,89.59 190.28,89.28 193.12,89.28 193.24,89.41 193.24,90.09 193.12,90.21 192.05,90.21 191.92,90.34 191.92,90.91 192.05,91.04 193.13,91.04 193.26,91.17 193.26,91.84 193.13,91.97 191.32,91.97 191.2,91.84 191.2,90.33 191.07,90.21 190.68,90.21 190.55,90.34 190.55,93.51 190.85,93.81 190.92,93.81 191.77,94.66 192.31,94.66 192.72,95.07 192.72,99.64 192.48,99.88 189.42,99.88 189.15,100.14 189.15,100.84 188.76,101.23 188.06,101.23 187.67,101.62 187.67,102.47 187.96,102.77 187.96,103.38 v1(187.57,103.77)
  BOTTOM w0.102: GPU1.E3 187.19,89.73 187.45,89.73 187.65,89.63 187.89,89.63 188.17,89.9 188.86,89.9 189.08,90.13 v1(189.18,90.13)
  BOTTOM w0.178: VRAM3.E7 188.29,103.77 v1(187.57,103.77)
DQMA7: length 44
  TOP w0.178: v1(189.97,90.04) 189.9,90.04 188.59,91.35 188.31,91.35 188.3,91.34 188.21,91.44 188.21,92.2 188.33,92.33 189.4,92.33 189.52,92.2 189.52,91.62 189.78,91.37 190.28,91.37 190.41,91.49 190.41,91.8 190.41,91.8 190.41,91.97 190.53,92.09 192.31,92.09 192.49,91.91 192.49,91.14 192.66,90.97 v2(193.83,90.97) 194.44,90.97 194.76,91.29 197.48,91.29 198.57,92.39 198.57,93.3 197.99,93.88 197.99,97.69 197.99,97.69 197.99,98.06 197.99,98.06 198.73,98.8 198.73,99.16 198.61,99.29 196.02,99.29 195.74,99.01 195.22,98.49 192.73,98.49 192.27,98.95 192.25,98.95 192.24,98.94 188.95,98.94 187.77,100.12 187.77,102.75 188.21,103.2 188.21,103.39 188.53,103.7 VRAM4.D3
  BOTTOM w0.102: GPU1.F4 186.85,89.53 187.4,89.53 187.61,89.43 187.98,89.43 188.25,89.7 189.59,89.7 189.92,90.04 v1(189.97,90.04)
DRAM_RST: length 56.8
  TOP w0.102: VRAM4.T2 189.82,114.91 188.62,116.11 v1(188.62,116.22) ; v1(166.12,116.22) 166.12,116.11 167.32,114.91 VRAM1.T2 ; v2(195.28,108.95) v1(194.69,108.95)
  L3 w0.102: v1(194.69,108.95) 194.69,112.89 191.39,116.19 188.64,116.19 v1(188.62,116.22)
  L4 w0.102: v1(188.62,116.22) 187.98,116.22 187.49,116.7 186.99,116.7 186.64,117.05 186.52,117.05 186.45,117.12 182.1,117.12 182,117.22 176.42,117.22 175.94,116.73 173.75,116.73 173.08,117.41 172.72,117.41 172.44,117.13 171.96,117.13 171.93,117.17 170.68,117.17 170.65,117.13 167.03,117.13 v1(166.12,116.22)
  BOTTOM w0.102: R7804.1 R7802.2 194.69,108.38 v1(194.69,108.95) ; v1(188.62,116.22) 188.46,116.22 188.14,116.53 187.62,116.53 187.45,116.7 186.99,116.7 185.02,114.74 VRAM3.T2 ; VRAM2.T2 162.52,114.74 164.49,116.7 164.95,116.7 165.12,116.53 165.64,116.53 165.96,116.22 v1(166.12,116.22)
DRAM_RST_R: length 2.7
  BOTTOM w0.102: R7804.2 R7803.1 197.61,107.11 C7802.1 v2(197.68,106.23)
DRAM_RST_VGA1: length 37.6
  L4 w0.102: v1(181.9,84.44) 182.19,84.44 182.68,84.93 186.28,84.93 187.93,86.58 188.76,86.58 188.93,86.42 188.93,86.42 189.16,86.18 189.5,86.18 197.81,94.49 197.81,108.62 v1(197.68,108.76)
  BOTTOM w0.102: R7803.2 196.91,108.06 R7819.1 v1(197.68,108.76) 197.75,108.76 v2(198.15,109.15) ; GPU1.L10 181.9,84.78 v1(181.9,84.44)
DS3_PWRCTL: length 4.5
  TOP w0.127: v2(156.21,51.67) C4103.1 R4104.2 R4102.2 155.43,49.9 U4101.4
DSW1: length 2.8
  TOP w0.127: SIM1.DSW1 77.52,111.38 R6302.1 77.66,111.24 v2(78.61,111.24)
E51_RX1: length 2.4
  TOP w0.102: TP6102.1 35.43,56.91 v1(35.13,57.21)
  BOTTOM w0.102: v1(35.13,57.21) 35.13,57.25 35.38,57.5 WLAN1.46
E51_RX2: length 2.5
  TOP w0.102: TP6103.1 37.94,54.47 v1(37.97,54.5)
  BOTTOM w0.102: WLAN1.58 v1(37.97,54.5)
E51_TX1: length 3.7
  TOP w0.102: v2(36.7,57.01) 36,57.71 R6115.2 v1(35.13,58.02)
  BOTTOM w0.102: WLAN1.44 35.2,58 35.18,58.02 v1(35.13,58.02)
E51_TXD_R: length 5
  TOP w0.102: DB3.5 283.74,42.17 v2(281.48,42.17) 279.76,42.17 v1(279.53,42.4)
  BOTTOM w0.102: R2466.1 v1(279.53,42.4)
E71_TP: length 1.7
  TOP w0.102: v1(90.61,84.46) 90.09,84.98 TP2314.1
  BOTTOM w0.102: v1(90.61,84.46) 90.78,84.3 CPU1.E71
EC_AGND: length 39.1
  TOP w0.203: KBC24.112 v1(208.72,22.46)
  TOP w0.508: C2422.2 210.16,18.29 209.76,17.89 v1(209.6,17.89) ; C2435.2 207.23,18.17 205.99,18.17 v1(205.89,18.27) 205.84,18.27 205.79,18.22 205.55,18.22 205.04,17.71 C2427.2 C2407.1 R2441.2 ; C2421.2 C2416.2 204.11,14.03 204.37,13.78 C2415.2 204.37,12.38 v1(204.01,12.02) 203.99,12.05 202.56,12.05 202.27,12.33 202.27,13.14 R2444.2 C2408.1
  L3 w0.508: v1(204.01,12.02) 203.91,12.02 203.76,12.18 v1(201.55,12.18)
  L4 w0.508: v1(205.89,18.27) 205.92,18.25 206.78,18.25 207.14,17.89 v1(209.6,17.89) 210.64,18.93 210.64,20.54 v1(208.72,22.46)
  BOTTOM w0.508: v1(201.55,12.18) 201.55,11.42 v2(201.35,11.21) 201.1,10.97 R2445.2 199.96,10.97 199.56,10.57 199.56,9.71 200.16,9.12 C2441.2 ; v1(205.89,18.27) 205.1,18.27 203.71,16.89 203.71,14.43 204.37,13.77 204.37,12.38 v1(204.01,12.02)
EC_MUTE#: length 217.9
  TOP w0.102: v1(171.81,27.3) 171.37,26.87 166.18,26.87 164.44,28.61 156.12,28.61 147.95,36.78 126.93,36.78 120.89,30.74 120.27,30.74 57.81,30.74 51.89,24.82 v1(50.37,24.82) ; v1(212.04,22.44) 211.51,21.91 KBC24.119
  L3 w0.102: v1(212.04,22.44) 209.96,22.44 209.81,22.29 209.45,22.29 209.19,22.54 209.19,22.6 208.89,22.9 208.54,22.9 206.3,20.66 206.3,19.74 205.08,18.53 204.17,18.53 204.04,18.4 194.59,18.4 194.01,18.98 192.89,18.98 190.28,21.58 190.28,23 189.53,23.75 189.53,25.72 187.38,27.87 181.33,27.87 180.76,27.3 v1(171.81,27.3) ; v1(50.37,24.82) 50.32,24.82 50.32,24.83 49.11,24.83 48.79,24.51 48.79,23.72 42.06,16.99 42.06,13.22 v1(40.03,11.18)
  BOTTOM w0.102: v1(40.03,11.18) 40.03,13.22 v2(38.48,14.76) 38.26,14.76 37.08,15.94 30.45,15.94 29.46,14.95 28.45,14.95 27.86,15.53 R2724.2 27.67,15.21 27.97,14.92 27.97,14.17 R2708.1
EC_SLP_S0IX#: length 171.8
  TOP w0.127: KBC24.30 217.47,34.34 217.88,34.75 217.88,35.64 217.41,36.11 217.41,38 217.87,38.45 217.87,41.19 216.46,42.6 v1(216.46,43.61) ; v1(125.19,67.57) 125.19,67.54 125.76,66.96 126.08,66.96 128.34,64.7 129.49,64.7 v2(129.51,64.73) 130.51,64.73 130.82,64.41 132.88,64.41 133.43,64.96 134.87,64.96 135.25,65.34 v1(135.34,65.34)
  L3 w0.127: v1(240.79,23.91) 240.13,24.57 240.13,26.64 236.72,30.05 236.72,33.9 233.75,36.87 233.75,38.77 231.81,40.71 229.63,40.71 226.73,43.61 v1(216.46,43.61)
  L4 w0.127: v1(135.34,65.34) 134.69,64.68 134.69,58.6 134.79,58.5 134.79,53.88 137.18,51.48 138.51,51.48 144.88,45.12 167.82,45.12 168.62,44.32 181.4,44.32 181.94,44.87 183.51,44.87 184.06,44.32 192.24,44.32 192.88,44.96 196.07,44.96 197.53,46.41 200.77,46.41 203,44.18 206.34,44.18 207.49,43.04 207.75,43.04 208.26,42.53 215.38,42.53 v1(216.46,43.61)
  BOTTOM w0.127: v1(216.46,43.61) 216.52,43.67 217.81,43.67 218.06,43.42 218.06,42.53 217.61,42.09 R4019.1 ; v1(240.79,23.91) 241.38,24.5 245.52,24.5 246.41,25.39 R9142.2 ; CPU1.AT11 125.5,67.85 125.22,67.57 v1(125.19,67.57)
EC_SPI_CLK: length 4.2
  TOP w0.14: v1(215.65,36.05) 215.96,35.74 216.07,35.74 KBC24.32
  BOTTOM w0.14: RN2401.8 216.27,36.68 v1(215.65,36.05) 215.65,36.31 v2(215.26,36.69) 214.88,37.07 R2459.2
EC_SPI_CS0#: length 5.1
  TOP w0.14: v1(214.41,32.63) 214.98,33.19 215.32,33.19 215.38,33.14 KBC24.27
  BOTTOM w0.14: R2426.1 R2490.1 215.07,33.47 v2(214.71,33.11) 214.41,32.81 v1(214.41,32.63)
EC_SPI_CS0#_R: length 163.8
  TOP w0.14: v1(97.1,9.89) 97.1,9.79 96.62,9.31 SPI241.1 94.03,9.31 93.17,8.44 v2(92.96,8.44) R2518.1
  L3 w0.127: v1(185.88,33.01) 186.84,33.97 191.01,33.97 192.06,32.92 192.06,30.59 192.32,30.33 193.13,30.33 194.03,29.42 199.37,29.42 199.71,29.77 200.08,29.77 201.78,28.06 211.14,28.06 211.63,27.57 v1(213.41,27.57) ; v1(97.1,9.89) 97.23,9.89 98.46,11.12 110.07,11.12 110.77,11.82 113.98,11.82 116.21,9.6 116.83,9.6 118.03,8.4 118.03,7.2 118.29,6.93 118.35,6.93 118.94,6.35 125.85,6.35 126.82,5.38 130.87,5.38 131.25,5.77 131.25,8.65 132.24,9.64 143.15,9.64 145.17,11.66 147.93,11.66 148.14,11.86 181.08,11.86 183.83,14.61 183.83,15.52 184.34,16.04 184.34,22.01 184.54,22.21 185.8,22.21 186.64,23.05 187.1,23.05 v1(187.12,23.07)
  L6 w0.114: v1(185.88,33.01) 185.88,30.3 185.72,30.14 185.72,29.78 186.01,29.48 186.01,25.54 186.2,25.35 187.12,24.43 v1(187.12,23.07)
  BOTTOM w0.14: R2426.2 216.85,32.05 214.42,29.62 214.42,28.98 213.41,27.97 v1(213.41,27.57)
EC_SPI_MISO: length 9.6
  TOP w0.14: KBC24.29 215.73,33.94 215.52,34.15 v1(215.52,34.78)
  BOTTOM w0.14: R2457.1 213.11,37.42 v2(213.93,36.6) 214.7,35.83 214.7,35.21 215.13,34.78 v1(215.52,34.78) 216.92,34.78 217.62,35.49 217.62,36.01 217.42,36.21 RN2401.6
EC_SPI_MOSI: length 8.8
  TOP w0.14: KBC24.28 215.36,33.54 214.76,34.15 214.76,34.91 v1(215.26,35.42)
  BOTTOM w0.14: RN2401.7 216.92,36.31 v2(216.31,35.7) 216.03,35.42 v1(215.26,35.42) 215.2,35.49 215.2,35.91 215.12,35.99 215.12,36 214,37.13 R2460.2
EC_VTT: length 183.2
  TOP w0.203: KBC24.95 200.35,23.14 199.9,22.69 v1(199.59,22.69)
  TOP w0.305: v1(183.13,61.33) 182.49,60.68 182.02,60.68 180.99,61.71 180.55,61.71 180.17,61.33 178.26,61.33 177.91,61.67 v2(176.91,61.67) 168.75,61.67 166.32,64.1 166.32,67.35 167.15,68.18 v1(167.77,68.18)
  TOP w0.508: v1(161.8,80.88) 161.29,80.38 159.26,80.38 158.7,79.82 v1(158.7,78.78)
  L3 w0.508: v1(215.59,38.06) 214.68,38.06 214.21,38.53 214.21,41.64 214.6,42.02 219.14,42.02 v1(219.54,41.62) ; v1(194.23,63.05) 194.23,62.39 198.25,58.38 198.25,57.81 198.98,57.07 198.98,56.07 202.36,52.69 208.41,52.69 209.83,51.27 209.83,49.33 210.25,48.92 211.28,48.92 211.32,48.88 211.71,48.88 213.03,47.56 213.03,46.79 215.1,44.71 v1(217.37,44.71) ; v1(134.49,93.41) 135.37,93.41 136.6,94.63 137.12,94.98 143.46,94.98 147.4,91.04 149.73,91.04 152.1,88.68 152.89,88.68 153.01,88.56 154.05,88.56 154.51,88.1 154.51,86.95 155.47,85.98 156.7,85.98 160.4,82.28 160.4,81.93 161.44,80.88 v1(161.8,80.88) 161.8,77.58 160.71,76.49 160.71,74.8 163.01,72.5 163.99,72.5 164.87,71.62 164.87,71.21 165.23,70.85 166.1,70.85 167.16,69.79 167.16,68.79 v1(167.77,68.18)
  L4 w0.305: v1(194.23,63.05) 194.23,63.06 193.25,64.04 185.32,64.04 183.16,61.88 183.16,61.33 v1(183.13,61.33)
  L4 w0.508: v1(213.38,30.93) 212.29,30.93 211.71,30.35 211.71,28.71 212.66,27.76 212.66,26.46 211.79,25.59 208.06,25.59 207.27,26.38 202.62,26.38 199.85,23.6 199.85,23.47 199.59,23.22 v1(199.59,22.69) ; v1(219.54,41.62) 219.54,42.54 217.37,44.7 v1(217.37,44.71)
  L6 w0.508: v1(213.38,30.93) 213.38,30.94 213.1,31.22 213.1,33.04 214.02,33.96 215.59,33.96 216.28,34.65 216.28,36.92 215.6,37.6 215.6,38.05 v1(215.59,38.06)
  BOTTOM w0.508: v1(158.7,78.78) 158.7,78.1 R2402.2 ; v1(199.59,22.69) 200.19,22.69 C2406.1 ; v1(134.49,93.41) 134.49,93.51 133.63,94.37 133.63,95.49 131.6,97.52 R2492.2 131.13,97.3 130.46,96.63 R2440.2
EC_WAKE#: length 85.5
  TOP w0.102: v1(150.47,59.91) 150.21,59.65 v2(149,59.65) 148.42,59.65 147.57,60.5 R1736.1 ; KBC24.35 214.32,38.51 214.86,39.06 v1(214.86,39.28)
  L4 w0.102: v1(205.05,49.28) 205.05,49.69 203.45,51.3 194.32,51.3 192.13,53.49 191.48,53.49 191.32,53.65 187.37,53.65 184.95,51.23 181.8,51.23 179.2,48.63 175.51,48.63 172.43,51.71 158.67,51.71 v1(150.47,59.91)
  L6 w0.102: v1(214.86,39.28) 213.92,40.22 213.92,43.09 212.52,44.49 211.97,44.49 206.89,49.56 205.33,49.56 v1(205.05,49.28)
ECVBAT: length 30.4
  TOP w0.203: KBC24.122 212.71,20.32 v1(212.45,20.05)
  TOP w0.508: C2428.1 219.57,15.16 219.1,15.63 v1(217.65,15.63) ; v1(214.58,17.98) 214.71,17.98 215.11,18.37 R2452.2 R2451.2
  L6 w0.508: v1(214.58,17.98) 215.7,17.98 217.65,16.02 v1(217.65,15.63) 217.91,15.63 221.32,12.23 225.14,12.23 227.2,10.16 227.2,10.02 v1(227.79,9.43)
  BOTTOM w0.508: v1(214.58,17.98) 214.32,17.98 212.45,19.85 v1(212.45,20.05) ; R2472.1 R2473.1 225.55,6.68 225.55,7.22 225.96,7.63 v2(226.75,7.63) 227.79,8.67 v1(227.79,9.43)
EDP_AUX_CON_N: length 8.4
  BOTTOM w0.127: LCD1.12 54.15,76.35 54.28,76.48 54.28,79.41 54.38,79.51 54.38,81.81 C5503.1 R5529.1 54.17,83.68 C5533.2
EDP_AUX_CON_P: length 8.5
  BOTTOM w0.127: LCD1.11 54.65,76.35 54.52,76.48 54.52,79.31 54.62,79.41 54.62,81.6 C5502.1 R5528.1 55.05,83.68 C5531.2
EDP_AUX_CPU_N: length 59.5
  L6 w0.102: v1(56.13,85.2) 56.13,84.99 57.12,84.01 60.01,84.01 61.75,85.75 63.4,85.75 64.82,84.34 70.24,84.34 71.15,83.42 78.16,83.42 79.43,84.69 82.68,84.69 83.34,84.03 84.61,84.03 87.63,87.05 91.63,87.05 92.13,86.55 96.64,86.55 97.15,86.04 103.24,86.04 103.52,86.32 105.09,86.32 105.74,85.67 105.74,85.35 v1(106.87,84.22)
  BOTTOM w0.127: v1(56.13,85.2) 56.06,85.13 54.6,85.13 C5533.1 ; CPU1.E45 106.64,83.99 v1(106.87,84.22)
EDP_AUX_CPU_P: length 59.4
  L6 w0.102: v1(106.87,83.57) 106.76,83.45 106.51,83.45 106.39,83.58 106.39,84.42 105.54,85.27 105.54,85.58 105,86.12 103.61,86.12 103.33,85.84 97.06,85.84 96.56,86.35 92.05,86.35 91.55,86.85 87.72,86.85 84.7,83.83 83.25,83.83 82.59,84.49 79.52,84.49 78.25,83.22 71.07,83.22 70.16,84.13 64.73,84.13 63.32,85.54 61.83,85.54 60.09,83.8 57.04,83.8 56.4,84.44 56.12,84.44 v1(56.01,84.33)
  BOTTOM w0.127: C5531.1 55.12,84.72 55.28,84.88 55.82,84.88 56.11,84.6 56.11,84.43 v1(56.01,84.33) ; v1(106.87,83.57) 106.65,83.34 CPU1.F45
EDP_BKLT_CTRL: length 6.3
  TOP w0.114: D5503.1 49.21,68.25 v1(48.9,67.93) 48.49,68.34 v2(48.49,68.36) 48.49,68.67 48.77,68.95 R5524.2
  BOTTOM w0.114: v1(48.9,67.93) 48.7,68.12 R5530.2
EDP_COMP: length 2.5
  TOP w0.203: R801.2 103.95,83.01 v2(103.87,83.09) 103.85,83.09 v1(103.27,83.67)
  BOTTOM w0.203: v1(103.27,83.67) 103.07,83.67 CPU1.E52
EDP_DISP_UTIL: length 1.4
  TOP w0.102: TP801.1 103,86.45 v1(103.02,86.47)
  BOTTOM w0.102: CPU1.B52 102.91,86.47 v1(103.02,86.47)
EDP_HPD: length 107.3
  TOP w0.102: v1(50.33,71.11) 50.33,71.15 50.53,71.35 RN5503.5 50.18,72.25 49.39,72.25 RN5502.7
  L3 w0.102: v1(52.2,79.61) 51.66,79.08 51.66,74.79 51.87,74.59 51.87,74.23 51.66,74.02 51.66,72.43 v1(50.33,71.11)
  L4 w0.102: v1(52.2,79.61) 53.72,79.61 57.3,83.2 68.04,83.2 69.11,82.13 83.96,82.13 88.54,86.71 89.03,86.71 89.05,86.73 89.37,86.73 89.39,86.71 94.53,86.71 97.09,89.27 97.09,89.48 102.19,94.57 106.46,94.57 107.23,93.81 107.23,91.21 106.68,90.66 106.68,89.56 107.14,89.1 107.79,89.1 109.33,90.64 112.9,90.64 114.16,89.38 115.71,89.38 116.71,88.38 118.75,88.38 120.4,86.73 123.95,86.73 126.65,84.03 126.65,81.57 126.93,81.28 v1(126.93,80.28)
  BOTTOM w0.102: v2(50.71,71.58) 50.71,71.49 v1(50.33,71.11) ; CPU1.L10 v1(126.93,80.28)
EDP_HPD_CONN: length 8.2
  TOP w0.102: v1(50.16,73.57) 50.53,73.2 RN5503.4
  BOTTOM w0.102: v1(50.16,73.57) 50.16,73.32 50.56,72.93 v2(50.56,72.93) 50.59,72.9 52.62,72.9 53.9,74.18 54.86,74.18 55.65,74.96 LCD1.9
EDP_TX_CON_N0: length 8.2
  BOTTOM w0.127: C5508.2 C5504.1 51.5,81.35 53.02,79.83 53.02,76.48 53.15,76.35 LCD1.14
EDP_TX_CON_N1: length 10.5
  BOTTOM w0.127: C5534.2 47.94,82.66 C5507.1 47.83,81.78 47.83,81.47 48.09,81.2 50.59,81.2 51.11,80.68 51.52,80.27 51.52,79.16 51.78,78.9 51.78,77.36 51.52,77.1 51.52,76.48 51.65,76.35 LCD1.17
EDP_TX_CON_P0: length 8.5
  BOTTOM w0.127: C5532.2 C5506.1 52.78,79.73 52.78,76.48 52.65,76.35 LCD1.15
EDP_TX_CON_P1: length 10.7
  BOTTOM w0.127: C5537.2 47.05,82.66 C5509.1 47.99,80.96 50.49,80.96 50.94,80.51 51.28,80.17 51.28,79.06 51.53,78.8 51.53,77.46 51.28,77.2 51.28,76.48 51.15,76.35 LCD1.18
EDP_TX_CPU_N0: length 82.5
  L6 w0.102: v1(102.74,92.31) 102.55,92.5 100.99,92.5 99.4,94.09 96.5,94.09 95.86,94.74 93.32,94.74 91.48,96.58 80.6,96.58 79.56,95.54 55.24,95.54 53.77,94.07 53.77,93.01 53.57,92.8 53.57,92.8 51.41,90.64 51.41,87.11 51.94,86.58 51.94,85.9 52.24,85.61 52.24,83.15 50.84,81.75 49,81.75 48.31,82.44 48.31,83.09 48.54,83.31 49.04,83.31 v1(49.15,83.42)
  BOTTOM w0.089: CPU1.C47 105.36,86.01 105.36,86.89 104.74,87.51 104.7,87.51 104.69,87.52
  BOTTOM w0.127: 104.69,87.52 102.97,89.24 ; 102.97,89.24 v2(102.84,89.11) ; 102.97,89.24 102.58,89.63 102.58,92.15 v1(102.74,92.31) ; C5508.1 51.87,84.07 51.13,84.07 51.1,84.04 51.09,84.03 51.08,84.03 51.06,84.01 51.05,84.01 50.99,83.97 50.97,83.95 50.5,83.49 49.21,83.49 v1(49.15,83.42)
EDP_TX_CPU_N1: length 85.1
  L6 w0.102: v1(47.88,84.44) 47.88,84.72 47.4,85.2 46.58,85.2 46.23,84.85 46.23,83.55 48.72,81.06 51.13,81.06 53.98,83.91 53.98,85.08 53.98,86.37 55.22,87.62 55.22,89.49 54.25,90.46 54.25,92.52 54.46,92.72 54.46,93.31 55.24,94.09 56.29,94.09 56.67,93.71 62.3,93.71 62.48,93.53 68.51,93.53 68.74,93.76 70.53,93.76 70.8,93.49 72.33,93.49 73.59,94.75 84.35,94.75 84.53,94.93 86.06,94.93 87,93.99 95.48,93.99 96.46,93.01 99.13,93.01 101.11,91.02 103.56,91.02 v1(103.8,90.79)
  BOTTOM w0.089: 105.63,87.58 105.65,87.57 105.69,87.57 106.37,86.88 106.37,86.61 106.33,86.52 106.33,86.25 106.37,86.16 106.37,85.96 106.32,85.83 106.22,85.73 106.02,85.73 105.87,85.58 CPU1.D46
  BOTTOM w0.127: 105.63,87.58 103.8,89.42 v1(103.8,90.79) 103.8,91.18 v2(104.05,91.43) ; C5534.1 v1(47.88,84.44)
EDP_TX_CPU_P0: length 82.2
  L6 w0.102: v1(49.15,82.66) 49.15,82.79 48.83,83.11 48.62,83.11 48.52,83 48.52,82.52 49.09,81.95 50.76,81.95 52.04,83.23 52.04,85.52 51.74,85.82 51.74,86.49 51.21,87.02 51.21,90.72 53.37,92.88 53.37,92.89 53.57,93.09 53.57,94.15 55.16,95.74 79.48,95.74 80.52,96.78 91.57,96.78 93.41,94.94 95.94,94.94 96.59,94.3 99.48,94.3 101.07,92.71 102.7,92.71 102.82,92.83 103.38,92.83 103.5,92.7 v1(103.5,92.44)
  BOTTOM w0.089: CPU1.C46 105.55,86.97 104.87,87.64 104.87,87.68 104.86,87.69
  BOTTOM w0.127: v2(103.02,90.33) 102.83,90.33 ; 102.83,90.33 102.83,91.76 v1(103.5,92.44) ; 102.83,90.33 102.83,89.73 104.86,87.69 ; C5532.1 51.35,83.7 51.06,83.7 50.6,83.25 49.61,83.25 49.15,82.79 v1(49.15,82.66)
EDP_TX_CPU_P1: length 84.4
  L6 w0.102: v1(47.16,84.49) 47.22,84.49 47.45,84.72 47.45,84.86 47.32,84.99 46.66,84.99 46.43,84.76 46.43,83.64 48.8,81.27 51.04,81.27 53.77,84 53.77,84.99 53.77,84.99 53.77,86.46 55.02,87.7 55.02,89.41 54.05,90.37 54.05,92.6 54.25,92.81 54.25,93.39 55.16,94.3 55.33,94.3 55.33,94.3 56.37,94.3 56.75,93.91 62.38,93.91 62.57,93.73 68.42,93.73 68.66,93.97 70.61,93.97 70.89,93.69 72.24,93.69 73.51,94.96 84.27,94.96 84.45,95.13 86.14,95.13 87.08,94.19 95.56,94.19 96.55,93.21 99.21,93.21 101.2,91.23 104.21,91.23 v1(104.52,90.92)
  BOTTOM w0.089: CPU1.C45 106.23,85.54 106.34,85.54 106.5,85.7 106.5,85.79 106.55,85.93 106.55,86.2 106.51,86.29 106.51,86.49 106.55,86.58 106.55,86.98 105.82,87.7 105.82,87.74 105.8,87.75
  BOTTOM w0.127: C5537.1 47.37,84 47.37,84.28 v1(47.16,84.49) ; v2(104.22,89.95) 104.04,89.95 ; 104.04,89.95 104.04,90.38 104.52,90.86 v1(104.52,90.92) ; 104.04,89.95 104.04,89.52 105.8,87.75
EDP_VDD_EN: length 132.4
  TOP w0.127: D5502.1 36.32,72.28 v2(36.32,73.82) 36.32,74.53 v1(35.31,75.55)
  L4 w0.127: v1(35.31,75.55) 35.94,76.19 36.7,76.19 42.1,81.58 46.67,81.58 46.91,81.34 50.71,81.34 55.56,86.19 57.83,86.19 58.48,86.84 60.72,86.84 61.66,85.9 63.31,85.9 64.21,85 69.03,85 70.36,83.67 79.7,83.67 80.44,84.4 81.32,84.4 86.13,89.22 89.76,89.22 90.89,90.35 95.72,90.35 101.59,96.22 107,96.22 110.54,92.67 117.33,92.67 117.34,92.68 117.4,92.68 118.49,93.77 118.79,93.77 118.79,93.77 124.72,93.77 125.33,93.17 126.6,93.17 128.32,91.44 129.48,91.44 131.24,89.68 131.24,83.07 128.87,80.7 128.87,80.02 128.48,79.63 128.02,79.63 127.12,78.73 125.52,78.73 125.12,78.33 125.12,77.63 v1(125.62,77.13)
  BOTTOM w0.127: v1(125.62,77.13) 125.38,77.36 125.18,77.36 124.87,77.67 CPU1.U13
EDRAM_OPIO_RCOMP: length 8.3
  TOP w0.305: RN402.4 88.49,83.49 88.77,83.21
  TOP w0.508: v1(89.38,82.48) 89.38,82.71 88.89,83.21 88.77,83.21 ; v2(93.17,82.76) v1(93.73,82.76)
  L3 w0.508: v1(93.73,82.76) 92.85,81.88 89.86,81.88 89.38,82.36 v1(89.38,82.48)
  BOTTOM w0.305: v1(93.73,82.76) 93.88,82.61 93.88,82.59 94.27,82.2 CPU1.H66
EMMC_RCOMP: length 1.9
  BOTTOM w0.203: CPU1.AT1 131.99,67.96 132.04,68.01 132.23,68.01 132.26,68.04 132.32,68.04 v1(133.13,68.85)
  vias: v2(132.84,68.26)
EN/DEM_VGA: length 86
  TOP w0.254: PR8503.2 205.43,52.56 205.43,53.6 205.78,53.96 205.78,53.99 206.14,54.34 PD8501.A ; PR8514.1 208.15,57.33 v1(208.15,56.5) 208.15,55.94 v2(207.95,55.74) 207.95,55.73 207.04,54.82 PD8501.A ; PQ8501.2 208.34,52.94 207.04,54.24 PD8501.A
  L4 w0.254: v1(207.52,113.84) 208.91,112.44 208.91,99.55 206.36,97 206.36,93.12 202.82,89.58 200,89.58 194.44,84.02 194.44,81.6 196.14,79.89 196.14,66.84 197.49,65.49 197.49,62.77 198.04,62.22 202.74,62.22 203.86,61.1 204.5,61.1 208.15,57.44 v1(208.15,56.5)
  BOTTOM w0.254: PC8502.1 208.81,55.8 208.15,56.46 v1(208.15,56.5) ; v1(207.52,113.84) 207.52,113.75 D8602.2
EOPIO_RCOMP: length 10.5
  TOP w0.305: 87.93,82.99 87.84,83.09 RN402.3
  TOP w0.508: v1(94.83,82.52) 94.83,82.34 v2(94.49,82) ; v1(88.69,82.46) 88.47,82.46 87.93,82.99
  L3 w0.508: v1(88.69,82.46) 88.69,82.21 89.62,81.29 93.59,81.29 v1(94.83,82.52)
  BOTTOM w0.305: CPU1.H65 94.87,82.52 v1(94.83,82.52)
EXT_PWR_GATE#: length 3.1
  TOP w0.127: R1731.2 126.35,72.36 v2(127.03,71.69) 127.03,70.24 v1(126.97,70.19)
  BOTTOM w0.127: v1(126.97,70.19) 126.71,70.45 CPU1.AM10
FALL_INT2: length 6.8
  TOP w0.102: Q6701.2 110.97,5.73 110.87,5.62 110.87,5.29 111.09,5.08 Q6701.3 111.66,5.03 v1(111.1,4.41)
  BOTTOM w0.102: R6703.2 113.79,4.68 113.11,5.37 v2(112.47,5.37) 111.81,5.37 111.1,4.66 v1(111.1,4.41)
FAN1_DAC: length 4.1
  TOP w0.203: R2453.1 208.9,39.67 v2(208.94,39.63) 209.04,39.53 209.04,38.49 209.51,38.02 KBC24.47
FAN1_DAC_1: length 16.2
  TOP w0.254: v1(206.5,42.15) 206.6,42.25 207.42,42.25 207.77,41.9 C2401.1 207.77,40.82 R2453.2
  BOTTOM w0.254: v1(206.5,42.15) 206.94,42.59 206.94,44.28 206.58,44.64 v2(206.58,46.11) 206.58,46.57 208.88,48.88 211.96,48.88 212.72,49.64 FAN261.4
FAN1_TACH: length 5.3
  TOP w0.203: KBC24.40 212.31,37.67
  TOP w0.254: 212.31,37.67 v2(212.96,38.32) D2403.A 214.43,39.79 215.4,39.79 R2430.1
FAN_TACH1: length 4.2
  TOP w0.254: R2606.1 EC2602.1 214.06,41.83 D2403.K 214.48,41.77 215.24,42.53 v2(215.42,42.53)
FAN_TACH1_C: length 15.4
  TOP w0.254: v1(212.98,53.96) 213.23,53.71 213.31,53.71 214.48,52.54 214.48,52.21 AFTP2802.1 214.92,51.76 214.92,48.26 215.9,47.28 215.9,46.08 214.95,45.13 R2606.2
  BOTTOM w0.254: FAN1.2 211.77,56.31 212.17,55.92 212.17,54.77 v1(212.98,53.96)
FAN_VCC1: length 9.4
  BOTTOM w0.508: FAN1.4 214.27,56.66 213.74,56.13 213.74,53.82 211.59,51.67 211.46,51.67 211.46,49.64 v1(211.58,49.51)
FBA_VREF_0: length 25.4
  TOP w0.305: VRAM1.H1 168.78,107.56 168.78,109.08 ; VRAM1.M8 v1(162.12,110.5)
  TOP w0.508: 168.78,109.08 v1(168.78,109.46) ; v1(158.82,109.82) v2(158.82,110.42)
  L6 w0.305: v1(162.12,110.5) 163.47,109.15 164.27,109.15 164.52,109.41 165.31,109.41 166.4,110.5 v1(167.72,110.5) 168.2,110.02 168.2,109.89 168.5,109.59 168.65,109.59 v1(168.78,109.46)
  L6 w0.508: v1(161.16,109.46) 160.91,109.46 159.77,110.6 159.77,110.98 ; 159.77,110.98 161.67,110.98 162.12,110.53 v1(162.12,110.5) ; 159.77,110.98 159.39,110.98 158.82,110.42 v1(158.82,109.82)
  BOTTOM w0.305: VRAM2.M8 v1(167.72,110.5) ; VRAM2.H1 161.16,107.46 v1(161.16,109.46)
  BOTTOM w0.508: R7807.2 157.42,111.49 R7801.1 C8147.1 157.48,109.84 157.5,109.82 v1(158.82,109.82)
FBA_VREF_1: length 23.8
  TOP w0.305: v1(191.26,109.59) 191.26,107.62 190.62,106.98 VRAM4.H1 ; VRAM4.M8 v1(184.62,110.5)
  L6 w0.305: v1(183.39,109.59) 183.79,109.59 184.62,110.42 v1(184.62,110.5)
  L6 w0.381: v1(184.62,110.5) 185.01,110.5 186.1,109.42 186.79,109.42 186.91,109.54 188.93,109.54 189.89,110.5 v1(190.22,110.5) 191.13,109.59 v1(191.26,109.59)
  L6 w0.508: v1(193.93,110.48) 193.42,109.97 191.77,109.97 191.39,109.59 v1(191.26,109.59)
  BOTTOM w0.305: VRAM3.M8 v1(190.22,110.5) ; VRAM3.H1 183.94,106.9 183.64,107.19 183.64,107.81 183.39,108.06 v1(183.39,109.59)
  BOTTOM w0.508: R8204.2 195.72,111.86 195.21,111.35 C8230.1 R8206.1 194.08,110.32 v1(193.93,110.48) v2(193.93,111.08)
FBA_ZQ0: length 5.8
  TOP w0.203: v1(162.14,109.68) VRAM1.L8
  TOP w0.254: v1(159.51,109.33) 159.38,109.21 v2(158.32,109.21) R7808.2
  L6 w0.254: v1(162.14,109.68) 161.41,108.95 160.4,108.95 160.02,109.33 v1(159.51,109.33)
FBA_ZQ1: length 6.3
  TOP w0.254: v2(171.89,110.5) R7811.2 170.31,109.59 v1(170.18,109.71)
  L6 w0.254: v1(167.72,109.7) 167.75,109.7 168.48,108.98 169.44,108.98 v1(170.18,109.71)
  BOTTOM w0.254: VRAM2.L8 v1(167.72,109.7)
FBA_ZQ2: length 6.7
  TOP w0.254: v2(194.03,108.87) 194.06,108.9 v1(194.06,109.46)
  L6 w0.254: v1(194.06,109.46) 193.93,109.33 192.41,109.33 192.02,108.95 190.88,108.95 190.22,109.61 v1(190.22,109.7)
  BOTTOM w0.254: R8205.2 194.08,109.48 v1(194.06,109.46) ; VRAM3.L8 v1(190.22,109.7)
FBA_ZQ3: length 6.2
  TOP w0.254: VRAM4.L8 v1(184.62,109.7) ; v1(181.09,109.6) 181.07,109.59 R8203.2
  L6 w0.254: v1(184.62,109.7) 184.52,109.7 183.51,108.7 181.99,108.7 v1(181.09,109.6)
  BOTTOM w0.254: v2(181.15,110.17) 181.09,110.1 v1(181.09,109.6)
FFS_INT2: length 216.7
  TOP w0.102: U6701.11 108.02,7.02 107.54,7.5 107.54,7.61 107.52,7.63 R6704.2 R6707.1 R6706.1 110.65,7.95 111.02,7.58 111.79,7.58 112.52,6.85 112.52,6.23 113.03,5.73 Q6701.5 114.15,5.73 114.55,5.33 v1(114.55,5.06)
  L3 w0.102: v1(114.55,5.06) 114.59,5.01 114.98,5.01 115.38,4.61 117.97,4.61 119.47,3.11 133.1,3.11 134.32,4.33 134.32,6.39 134.77,6.84 137.92,6.84 138.81,7.73 142.88,7.73 142.92,7.77 144.47,7.77 145.71,9.01 175.22,9.01 175.52,8.71 184.15,8.71 184.45,9.01 189.02,9.01 189.15,9.14 189.15,10.71 189.42,10.98 192.87,10.98 193.68,11.79 193.68,12.74 190.17,16.24 190.04,16.24 189.93,16.31 189.77,16.38 189.59,16.41 189.41,16.41 189.23,16.38 189.07,16.31 188.96,16.24 188.28,16.24 188.26,16.27 187.85,16.27 187.19,16.93 187.19,20.99 v1(187.93,21.73) ; v1(187.25,39.86) 187.05,39.66 186.99,39.66 185.74,38.4 182.35,38.4 182.31,38.36 181.57,38.36 181.53,38.4 181.09,38.4 165.27,38.4 164.44,39.23 151.19,39.23 142.24,48.18 142.24,53.75 142.99,54.5 142.99,56.89 141.97,57.91 141.97,70.18 141.27,70.88 141.27,73.7 140.95,74.03 v1(140.34,74.03)
  L6 w0.102: v1(187.93,21.73) 187.93,22.11 188.16,22.34 188.16,23.75 187.99,23.92 187.99,35.3 187.6,35.69 187.6,39.51 v1(187.25,39.86)
  BOTTOM w0.089: 132.38,74.38 132.36,74.36 131.8,74.36 131.71,74.32 131.51,74.32 131.42,74.36 131.18,74.36 CPU1.AC2
  BOTTOM w0.102: 132.38,74.38 132.64,74.64 133.6,74.64 133.61,74.65 134.34,74.65 134.83,74.16 135.44,74.16 135.93,73.67 v2(138.46,73.67) 139.98,73.67 v1(140.34,74.03)
FFS_INT2_Q: length 172.3
  TOP w0.102: v1(115.98,3.74) 116.03,3.8 116.03,4.71 v2(115.32,5.42) 114.36,6.38 Q6701.6 112.06,7.86 111.19,7.86 R6705.2 110.21,8.84 R6706.2
  L3 w0.102: v1(115.98,3.74) 117.39,3.74 118.5,2.63 133.92,2.63 134.24,2.95 142.11,2.95 146.43,7.27 174.5,7.27 174.8,6.97 184.87,6.97 185.17,7.27 190.7,7.27 191.27,7.84 197.93,7.84 199.31,6.46 205.31,6.46 208.28,3.49 224.84,3.49 225.07,3.72 235,3.72 235.76,4.48 235.76,4.51 236.02,4.76 236.04,4.76 236.31,5.03 238.04,5.03 241.76,8.75 245.68,8.75 248.27,11.33 248.27,13.35 253.82,18.91 264.29,18.91 v1(264.92,18.27)
  BOTTOM w0.102: HDD1.11 265.15,18.75 264.92,18.53 v1(264.92,18.27)
FIVR_EN_R: length 5.7
  TOP w0.127: XDP1.45 59.5,98.72 59.78,99 60.04,99 60.61,99.57 R9906.2 60.68,99.55 61.06,99.17 v2(61.59,99.17) 62.13,99.71 R9611.2
FON#: length 2.5
  BOTTOM w0.114: FAN261.1 208.41,50.79 208.15,50.53 v2(207.65,50.53) 207.26,50.91 R2605.2
FP_PWR: length 10
  TOP w0.254: FPR1.6 275.56,20.95 276.12,21.51 v1(276.12,22.13) 275.72,22.54 275.72,23.7 277.02,25 AFTP8902.1
  BOTTOM w0.254: C9202.1 C9201.1 R9202.1 R9201.2 276.23,22.03 v1(276.12,22.13)
GPD2/LAN_WAKE#: length 31.8
  TOP w0.102: v1(124.24,70.2) 124.24,69.47 124.65,69.06 124.65,67.52 125.2,66.97 125.2,66.61 125.64,66.16 126.16,66.16 126.19,66.2 126.52,66.2 126.75,65.97 126.75,65.61 127.21,65.15 v2(127.25,65.15) 127.28,65.13 127.28,65.09 128.16,64.21 130.49,64.21 131.58,63.12 132.36,63.12 133.65,64.41 135.57,64.41 136.27,65.12 139.97,65.12 143.44,61.64 145.74,61.64 145.9,61.48 147.36,61.48 R1736.2 R1707.2
  BOTTOM w0.102: CPU1.AM15 123.92,70.45 124.16,70.22 124.23,70.22 v1(124.24,70.2)
GPD11/LANPHYPC: length 10.8
  BOTTOM w0.089: CPU1.AW17 122.45,65.78 122.45,63.71
  BOTTOM w0.127: 122.45,63.71 122.35,63.61 122.35,63.12 122.45,63.02 122.45,62.68 122.22,62.45 122.22,61.88 122.45,61.66 122.45,60.53 122.43,60.52 122.43,60.19 122.74,59.88 v2(122.74,59.14) 122.74,59.08 122.63,58.96 122.63,57.5 R1709.2 123.31,56.83 RN1701.1
GPIO16_VGA: length 8.4
  BOTTOM w0.102: TP7903.1 192.58,86.01 192.2,86.01 191.43,85.24 190.81,85.24 189.54,83.97 187.63,83.97 187.54,83.88 187.1,83.88 186.92,84.06 186.91,84.06 186.57,84.4 GPU1.M4
GPIO_5_AC_BATT: length 8.1
  TOP w0.127: v1(184.26,80.78) 184.63,80.41 185.09,80.41 185.33,80.66 185.33,80.67 185.39,80.73 185.39,81.24 v2(185.42,81.27) 185.47,81.32 185.5,81.32 186,81.82 187.34,81.82 Q7902.D 187.45,81.32 186.92,80.78 186.92,79.86 R7921.2
  BOTTOM w0.127: GPU1.T9 183.54,80.78 v1(184.26,80.78)
GPIO_8_ROMSO: length 1.5
  TOP w0.102: TP7905.1 181.89,82.69 v1(181.58,82.69)
  BOTTOM w0.102: GPU1.P10 181.67,82.6 v1(181.58,82.69)
GPIO_9_ROMSI: length 4.1
  TOP w0.102: v1(189.61,82.31) 189.89,82.03 TP7906.1
  BOTTOM w0.089: 188.03,82.53 187.51,82.53 187.45,82.48 187.19,82.48 187.14,82.53 186.79,82.53 GPU1.P4
  BOTTOM w0.102: v1(189.61,82.31) 188.25,82.31 188.03,82.53
GPIO_10_ROMSCK: length 4.1
  TOP w0.102: TP7901.1 190.55,83.17 v1(190.25,83.17)
  BOTTOM w0.102: v1(190.25,83.17) 190.24,83.17 189.79,82.71 188.2,82.71 188.17,82.74 187.38,82.74 GPU1.P2
GPIO_17_THERMAL_INT: length 5.6
  TOP w0.102: TP7923.1 189.23,80.53 189.23,81.55 v1(189.22,81.56)
  BOTTOM w0.102: GPU1.R6 185.65,81.67 188.23,81.67 188.33,81.57 189.21,81.57 v1(189.22,81.56)
GPIO_19_CTF: length 8.1
  BOTTOM w0.102: GPU1.M2 189.35,84.4 190.69,85.74 191.19,85.74 191.44,85.99 191.44,87.23 v2(191.44,87.41) 191.95,87.92 R7922.1
GPIO_22_ROMCS#: length 7.6
  TOP w0.102: TP7910.1 189.87,83.38 v1(189.61,83.12)
  BOTTOM w0.102: v1(189.61,83.12) 189.44,83.12 189.39,83.08 187.51,83.08 187.46,83.13 187.18,83.13 187.13,83.08 186.7,83.08 186.51,83.27 185.98,83.27 185.67,83.58 185.67,83.71 185.38,84 184.78,84 184.66,84.13 184.34,84.13 184.01,83.8 GPU1.N8
GPP_B2/VRALERT#: length 1.9
  TOP w0.102: v1(126.09,70.19) 126.09,70.7 TP1708.1
  BOTTOM w0.102: CPU1.AM11 125.77,70.45 126.03,70.19 v1(126.09,70.19)
GPP_B4/CPU_GP3: length 1.3
  TOP w0.102: TP404.1 129.86,66.03 v1(129.79,65.96)
  BOTTOM w0.102: v1(129.79,65.96) 129.53,65.96 CPU1.AY5
GPP_B18/GSPI0_MOSI: length 22.7
  TOP w0.102: v1(147.19,68.55) 147.18,68.57 v2(146.33,68.57) 145.54,68.57 145.35,68.38 145.35,67.87 145.36,67.87 145.36,67.67 144.95,67.27 143.67,67.27 143.32,67.63 134.37,67.63 133.97,67.22 130.98,67.22 130.15,68.04 129.59,68.04 v1(128.82,68.82)
  BOTTOM w0.102: v1(128.82,68.82) 128.78,68.82 128.46,68.5 CPU1.AR7 ; R2007.2 147.46,68.82 v1(147.19,68.55) 146.86,68.88 R2019.1
GPP_B23/SML1ALERT#: length 4.8
  TOP w0.102: v1(128.22,71.87) 128.22,71.84 128.65,71.41 129.46,71.41 129.51,71.36 129.97,71.36 v2(130.02,71.31) 130.19,71.31 R1820.2
  BOTTOM w0.102: CPU1.AM7 128.36,70.76 128.22,70.9 v1(128.22,71.87)
GPP_C2/SMBALERT#: length 23.3
  TOP w0.102: R1821.1 144.25,77.38 v2(143.99,77.12) 143.23,76.36 140.16,76.36 140.05,76.26 138.76,76.26 v1(138.05,75.55)
  L3 w0.102: v1(126.27,79.19) 126.58,78.88 126.58,77.25 126.58,77.25 126.58,76.92 127.11,76.39 131.16,76.39 131.77,77 134.95,77 134.96,77.01 135.03,77.01 135.04,77.02 136.03,77.02 136.06,77 136.45,77 137.9,75.55 v1(138.05,75.55)
  BOTTOM w0.102: v1(126.27,79.19) 126.6,78.86 CPU1.R10
GPP_C5/SML0ALERT#: length 15.4
  TOP w0.102: R1822.2 146.3,75.61 R1823.1 145.1,75.61 144.98,75.5 140.77,75.5 v1(140.34,75.93)
  BOTTOM w0.102: CPU1.W1 132.2,76.57 132.34,76.43 133.86,76.43 134.47,75.82 134.47,75.79 134.59,75.66 134.69,75.66 v2(134.9,75.45) 137.34,75.45 137.87,75.98 140.28,75.98 v1(140.34,75.93)
GPP_D4/FLASHTRIG: length 2.5
  TOP w0.102: R1503.1 128.99,86.92 v1(128.98,86.93) 128.7,86.65 v2(128.7,86.37)
  BOTTOM w0.102: v1(128.98,86.93) 128.75,86.7 128.75,86.41 CPU1.B7
GPP_E0/SATAXPCIE0/SATAGP0: length 9
  BOTTOM w0.089: 133.99,82.76 131.8,82.76 131.71,82.8 131.51,82.8 131.42,82.76 131.18,82.76 CPU1.H2
  BOTTOM w0.102: 133.99,82.76 134.34,83.12 134.34,84.06 133.85,84.55 133.85,86.46 133.86,86.47 134.88,87.49 TP1601.1
GPP_E2/SATAXPCIE2/SATAGP2: length 2.5
  TOP w0.102: TP1603.1 129.54,84.93 v1(130.07,84.4)
  BOTTOM w0.102: v1(130.07,84.4) 130.07,84.38 129.69,84 129.69,83.49 CPU1.G4
GPP_E3/CPU_GP0: length 4.2
  BOTTOM w0.102: CPU1.A6 129.38,86.68 129.38,86.84 129.55,87.01 129.59,87.01 130.3,87.72 TP403.1
GPU_ALERT#: length 4.3
  BOTTOM w0.102: THM263.6 203.47,109.73 203.23,109.48 201.63,109.48 v2(201.45,109.66) 201.04,109.26 R2616.2
GPU_DMINUS: length 45.8
  BOTTOM w0.254: 205.73,90.18 205.73,89.61 203.3,87.18 197.79,87.18 197.49,87.49 195.14,87.49 193.19,85.54 193.19,85.12 193.19,79.85 192.65,79.31 190.58,79.31 188.69,81.2 GPU1.T2 ; 205.73,90.18 205.73,93.54 205.73,93.96 206.3,94.53 206.3,99.24 203.58,101.96 203.58,103.4 C2623.2 203.47,103.82 THM263.3 ; 205.73,90.18 v2(205.56,90.18)
GPU_DPLUS: length 47.5
  BOTTOM w0.203: 188.48,80.69 188.37,80.81 186.91,80.81 GPU1.T4
  BOTTOM w0.254: 206.24,91.3 206.24,89.4 203.51,86.68 197.58,86.68 197.27,86.98 195.35,86.98 193.7,85.33 193.7,79.64 192.86,78.8 190.37,78.8 188.48,80.69 ; 206.24,91.3 v2(206.4,91.3) ; 206.24,91.3 206.24,93.75 206.81,94.32 206.81,99.45 204.09,102.17 204.09,103.55 C2623.1 204.12,103.75 THM263.2
GPU_DPRSLP: length 1.1
  BOTTOM w0.102: TP7918.1 191.83,77.19 R7911.1
GPU_DPRSLP_R: length 6.6
  L3 w0.102: v1(185.71,80.02) 187.37,80.02 v1(188.66,78.73)
  BOTTOM w0.102: v1(185.71,80.02) 185.7,80.02 GPU1.U6 ; R7911.2 190.09,78.14 v2(190.04,78.19) 189.99,78.19 189.46,78.72 188.66,78.72 v1(188.66,78.73)
GPU_PWR_LEVEL: length 77.2
  TOP w0.102: v1(188.47,70.22) 188.47,70.55 187.76,71.26 187.76,76.56 187.91,76.71 R7937.1 ; KBC24.21 v1(214.88,30.74)
  L3 w0.102: v1(212.72,43.67) 212.29,44.1 212.29,47.26 211.43,48.12 211.36,48.12 211.34,48.14 210.81,48.14 210.79,48.12 209.66,48.12 208.76,49.02 208.68,49.02 208.33,49.37 208.33,49.66 208.08,49.92 208.01,49.92 206.76,51.17 206.02,51.17 206.01,51.18 200.55,51.18 197.61,54.11 197.61,55.44 196.78,56.27 194.11,56.27 193.73,55.9 190.44,55.9 190.09,56.25 190.09,58.51 192.94,61.35 192.94,63.23 191.72,64.45 191.72,67.18 188.69,70.22 v1(188.47,70.22)
  L6 w0.102: v1(214.88,30.74) 214.35,30.21 212.93,30.21 211.82,31.32 211.82,33.6 212.34,34.12 213.23,34.12 213.77,34.66 213.77,39.95 213.61,40.1 213.61,42.8 213.01,43.41 212.99,43.41 v1(212.72,43.67)
  BOTTOM w0.102: v1(212.72,43.67) 213.1,43.67 v2(213.34,43.9)
GPU_PWR_LEVEL_R: length 4.5
  TOP w0.102: R7937.2 187.88,80.27 v2(187.68,80.48) 187.76,80.55 187.76,80.58 188.34,81.16 188.34,82.66 188.36,82.68 188.36,82.92 188.44,82.99 Q7902.G
GPU_T_CRIT#: length 7.5
  BOTTOM w0.102: THM263.4 202.82,108.31 203.19,108.68 R2617.2 206.32,109.1 v2(206.81,109.59) 207.17,109.22 R2618.1
GPU_T_CRIT_R#: length 6.6
  BOTTOM w0.102: Q2606.S 207.61,104.09 207.99,104.47 208,104.47 208.97,105.44 208.97,107.5 208.7,107.77 v2(208.25,107.77) R2618.2
H_CATERR#: length 8.1
  BOTTOM w0.089: 96.51,88.33 96.51,87.2 96.64,87.07 96.64,86.56 96.63,86.55 96.61,86.5 96.61,86.28 96.64,86.22 96.64,85.94 96.61,85.88 96.58,85.75 96.54,85.61 96.54,85.24 96.42,85.09 96.26,84.86 CPU1.D63
  BOTTOM w0.102: TP401.1 96.9,92.31 96.9,88.72 96.51,88.33
H_CPU_SVIDALRT#: length 5
  BOTTOM w0.114: 95.91,88.68 95.91,88.68 95.91,86.55 96.2,86.26 CPU1.B63
  BOTTOM w0.14: 95.91,88.68 95.91,89.98 v2(95.89,90) 94.96,90 R728.2
H_CPU_SVIDCLK: length 5.7
  BOTTOM w0.114: v2(96.24,91.2) 96.29,91.15 96.29,88.78 96.12,88.61 96.12,86.8 CPU1.A63
  BOTTOM w0.14: R732.1 95.66,91.77 v2(96.24,91.2)
H_CPU_SVIDDAT: length 8.4
  BOTTOM w0.114: CPU1.D64 95.63,85.29 95.85,85.51 95.93,85.66 95.93,85.89 95.71,86.11 95.71,88.45 v2(95.15,89.01)
  BOTTOM w0.14: v2(95.15,89.01) 94.27,89.89 R726.2 94.44,90.4 94.44,90.98 93.8,91.62 R709.1
H_CPUPWRGD: length 9.5
  BOTTOM w0.127: EC1710.2 R405.1 EC1701.1 86.3,87.93 86.49,87.74 TP1709.1 88.22,87.74 88.71,87.26 92.52,87.26 CPU1.A68
H_PECI: length 177.7
  L3 w0.127: v1(185.75,57.77) 185.78,57.74 185.78,55.84 188.09,53.53 195.68,53.53 199.79,49.41 201.02,49.41 v1(203.07,47.36)
  L6 w0.114: v1(120.85,100.11) 137.18,100.11 143.12,94.17 143.12,91.72 141.17,89.76 141.17,87.76 148.97,79.96 148.97,79.1 151.77,76.29 162.79,76.29 166.46,72.63 166.52,72.63 168.66,70.49 168.66,69.37 171.87,66.15 175.42,66.15 176.91,64.66 177.82,64.66 178.08,64.4 178.5,64.4 178.53,64.37 178.77,64.37 181.21,61.93 181.21,61.27 183.39,59.09 184.43,59.09 v1(185.75,57.77) ; v1(199.9,26.34) 199.49,26.34 198.87,26.96 198.71,26.96 197.91,27.76 197.91,30.16 198.36,30.61 198.36,33.89 197.51,34.74 197.51,39.58 196.01,41.08 196.01,45.87 196.45,46.31 196.45,47.48 196.37,47.56 196.37,48.02 196.72,48.37 196.93,48.37 197.54,48.98 201.47,48.98 202.34,48.11 202.34,48.09 v1(203.07,47.36)
  BOTTOM w0.14: 104.9,97.75 v2(104.9,97.65) ; 104.9,97.75 104.49,97.34 104.49,96.06 102.01,93.58 102.01,88.43 101.15,87.56 101.15,87.03 101.15,87.03 CPU1.A54 ; 104.9,97.75 108.36,101.2 116.49,101.2 116.54,101.25 119.76,101.25 120.85,100.16 v1(120.85,100.11) ; v1(199.9,26.34) 199.9,26.3 200.7,25.49 200.7,25.44 201.04,25.11 R2437.2
