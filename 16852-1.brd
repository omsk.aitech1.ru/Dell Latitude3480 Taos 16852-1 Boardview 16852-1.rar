# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DMIC_DATA: length 81.9
  TOP w0.14: R2714.1 26.8,18.25 27.2,18.65 27.2,19.57 v1(27.43,19.8) ; v1(47.2,67.35) 47.49,67.64 47.49,68.63 47.07,69.05 ; 47.07,69.05 46.6,69.51 46.6,71.48 46.41,71.67 RN5504.3 ; 47.07,69.05 v2(46.94,68.92)
  L6 w0.114: v1(47.2,67.35) 47.51,67.05 47.51,64.18 46.12,62.79 36.61,62.79 35.69,61.87 35.69,57.15 34.85,56.32 34.85,56.32 33.78,55.25 31.1,52.57 27.56,52.57 27.18,52.18 22.73,52.18 22.35,51.8 22.35,49.77 17.48,44.9 17.48,41.65 20.96,38.17 20.96,37.5 22.05,36.41 22.3,36.16 22.3,36.09 22.31,36.08 22.31,30.89 24.64,28.56 24.64,26.6 26.49,24.75 26.49,23.27 26.8,22.97 26.8,20.43 v1(27.43,19.8)
DMIC_DATA_EDP: length 6.6
  TOP w0.14: 46.38,76.77 46.38,76.41 46.72,76.07 46.72,75.09 EC5502.1 46.66,74.55 46.66,74.13 46.41,73.88 RN5504.2 ; 46.38,76.77 v2(46.21,76.77) ; 46.38,76.77 46.38,77.17 v1(46.15,77.39)
  BOTTOM w0.14: LCD1.28 46.15,77.39 v1(46.15,77.39)
DMIC_DATA_R: length 2.9
  TOP w0.14: R2714.2 26.8,16.69 EC2701.1 26.61,16.24 25.73,15.36 HDA27.2
DPLL_PVDD: length 7.1
  TOP w0.254: v2(180.71,71.54) 180.97,71.8 C7711.1 ; C7711.1 C7710.1 179.7,72.44 v1(179.32,72.82) ; C7711.1 182.03,72.44 C7713.1 183.54,73.95 R7704.2
  BOTTOM w0.254: v1(179.32,72.82) 179.31,72.83 179.22,72.83 178.85,73.2 GPU1.AF14
DPLL_VDDC: length 5.5
  TOP w0.254: v1(178.16,73.57) 178.21,73.52 v2(178.21,73.01) 178.21,72.16 C7715.1 178.27,71.28 C7714.1 178.03,71.26 R7705.2
  BOTTOM w0.254: GPU1.AD14 178.72,74.57 178.31,74.17 178.31,73.73 v1(178.16,73.57)
DQA0_0: length 46.6
  TOP w0.178: VRAM1.C8 162.36,102.9 161.99,102.53 161.32,102.53 161.31,102.54 160.94,102.54 160.67,102.27 160.67,100.9 160.04,100.27 155.71,100.27 154.07,98.63 154.07,94.58 152.97,93.48 152.97,90.76 156.36,87.37 156.36,83.82 157.31,82.87 157.32,82.87 157.33,82.86 161.29,82.86 162.2,83.78 v1(162.2,87.39)
  BOTTOM w0.178: v1(162.2,87.39) 162.15,87.34 v2(162.15,86.78) 162.15,85.7 162.78,85.08 165.79,85.08 166.34,85.63 168.15,85.63 GPU1.K27
DQA0_1: length 45.3
  TOP w0.178: v1(162.94,87.41) 162.94,87.69 162.57,88.07 162.22,88.07 161.73,87.58 v2(161.73,85.94) 161.73,83.94 161.1,83.31 157.51,83.31 156.89,83.93 156.89,87.47 153.41,90.95 153.41,93.3 154.51,94.4 154.51,98.43 155.28,99.21 155.77,99.69 159.85,99.69 159.85,99.69 161.5,99.69 161.51,99.69 161.9,99.69 162.16,99.95 162.16,100.35 162.89,101.07 162.89,101.71 162.52,102.08 VRAM1.B8
  BOTTOM w0.178: GPU1.J29 167.32,86.5 167.19,86.37 165.97,86.37 165.75,86.15 165.26,86.15 164.65,85.55 162.88,85.55 162.75,85.67 162.75,87.28 162.88,87.41 v1(162.94,87.41)
DQA0_2: length 44.7
  TOP w0.178: VRAM1.D7 163.94,103.08 163.94,102.95 164.2,102.69 164.24,102.69 164.77,102.15 164.77,100.74 162.42,98.39 161.74,98.39 161.73,98.39 160.08,98.39 160.07,98.39 159.52,98.39 158.88,97.76 157.18,97.76 156.44,97.01 156.44,93.49 155.73,92.78 155.73,91.36 157.67,89.42 158.41,89.42 158.53,89.29 158.53,88.55 158.67,88.41 159.84,88.41 160.44,89.02 v2(160.44,89.27) 160.44,91.45 161.62,92.63 162.85,92.63 163.51,91.97 163.51,90.99 164.65,89.85 164.65,87.68 v1(164.41,87.44)
  BOTTOM w0.178: v1(164.41,87.44) 163.97,86.99 163.34,86.99 163.21,86.87 163.21,85.98 163.34,85.86 164.57,85.86 165.24,86.53 165.24,87.13 165.35,87.23 165.87,87.23 165.93,87.17 166.37,87.17 166.37,87.17 166.67,87.17 166.92,87.42 GPU1.H30
DQA0_3: length 44
  TOP w0.178: v1(163.75,87.44) 163.75,87.51 162.68,88.59 162.11,88.59 161.29,87.77 v2(161.29,87.34) 161.29,84.13 161.09,83.93 160.57,83.93 160.44,84.06 160.44,84.77 160.31,84.89 159.85,84.89 159.73,84.77 159.73,83.88 159.6,83.75 159.14,83.75 159.02,83.88 159.02,84.8 158.9,84.92 158.42,84.92 158.31,84.8 158.31,84.12 158.18,83.99 157.46,83.99 157.33,84.12 157.33,87.65 153.9,91.08 153.9,93.16 154.96,94.21 154.96,98.25 155.47,98.76 155.95,99.24 158.45,99.24 158.56,99.35 161.99,99.35 163.32,100.68 VRAM1.A7
  BOTTOM w0.178: GPU1.H32 165.27,87.6 164.66,88.21 163.88,88.21 163.75,88.08 v1(163.75,87.44)
DQA0_4: length 44.2
  TOP w0.178: v1(168,88.66) 168.16,88.66 168.62,89.12 168.62,91.64 168.75,91.77 169.13,91.77 169.14,91.76 169.24,91.76 169.37,91.63 v2(169.37,90.05) 169.37,88.99 169.37,88.98 169.37,88.56 169.49,88.44 169.96,88.44 170.08,88.56 170.08,88.99 170.09,89 170.09,98.31 170.03,98.37 170.03,99.98 169.9,100.11 169.43,100.11 169.3,99.98 169.3,93.85 169.18,93.73 168.68,93.73 168.55,93.85 168.55,96.09 168.43,96.21 167.02,96.21 166.89,96.34 166.89,96.83 167.02,96.96 168.43,96.96 168.55,97.09 168.55,98.56 168.43,98.69 166.98,98.69 166.85,98.82 166.85,99.32 166.98,99.44 168.43,99.44 168.55,99.57 168.55,100.08 168.43,100.2 167.8,100.2 167.68,100.33 167.68,100.93 167.69,100.95 167.69,102.6 167.39,102.9 VRAM1.C2
  BOTTOM w0.178: GPU1.G29 167.71,88.4 167.97,88.66 v1(168,88.66)
DQA0_5: length 44.2
  TOP w0.178: v1(168.12,89.57) 168.12,89.82 167.88,90.06 166.96,90.06 166.84,90.19 166.84,90.65 166.96,90.78 v2(167.77,90.78) 168.07,90.78 168.2,90.91 168.2,91.31 168.01,91.5 167.28,91.5 167.15,91.62 167.15,92.59 167.28,92.72 167.81,92.72 167.99,92.54 167.99,92.37 168.12,92.24 168.58,92.24 168.7,92.37 168.7,92.54 168.88,92.72 169.64,92.72 169.76,92.84 169.76,93.31 169.64,93.43 168.27,93.43 168.1,93.61 168.1,94.2 167.97,94.32 167.42,94.32 167.29,94.2 167.29,93.55 167.17,93.42 166.59,93.42 166.46,93.3 166.46,92.51 166.27,92.31 165.57,92.31 165.45,92.44 165.45,94.02 165.57,94.15 166.43,94.15 166.56,94.28 166.56,94.91 166.68,95.04 168,95.04 168.11,95.15 168.11,95.66 168,95.77 166.37,95.77 166.19,95.95 166.19,96.59 166.06,96.72 165.61,96.72 165.48,96.59 165.48,95.95 165.3,95.77 164.1,95.77 163.91,95.96 163.91,97.08 164.04,97.21 164.99,97.21 165.12,97.34 165.12,97.94 164.99,98.07 164.79,98.07 164.58,98.27 164.58,98.45 165.55,99.43 165.73,99.43 165.84,99.32 165.84,97.57 165.96,97.44 167.98,97.44 168.1,97.57 168.1,98.08 167.98,98.21 166.67,98.21 166.54,98.33 166.54,99.73 166.67,99.86 167.19,99.86 167.32,99.99 VRAM1.A2
  BOTTOM w0.178: GPU1.F28 167.75,89.2 v1(168.12,89.57)
DQA0_6: length 43.6
  TOP w0.178: VRAM1.A3 166.61,101.3 167,100.91 167,100.28 166.86,100.14 165.67,100.14 164.12,98.59 164.12,97.92 163.22,97.02 162.16,97.02 162.03,96.9 162.03,95.85 161.9,95.72 161.43,95.72 161.31,95.85 161.31,96.93 161.18,97.06 160.63,97.06 160.5,96.93 160.5,96.49 160.38,96.36 158.35,96.36 158.22,96.23 158.22,95.75 158.35,95.62 159.15,95.62 159.28,95.49 159.28,95.04 159.15,94.91 158.35,94.91 158.22,94.78 158.22,94.24 158.35,94.11 159.09,94.11 159.22,93.99 159.22,93.1 159.42,92.9 159.88,92.9 160,93.02 160,95.44 160.13,95.57 160.62,95.57 160.75,95.44 160.75,94.09 160.87,93.97 161.05,93.97 161.05,93.97 161.51,93.97 161.63,94.09 161.63,94.86 161.76,94.99 162.61,94.99 162.74,95.11 162.74,96.29 162.87,96.42 163.32,96.42 163.44,96.29 163.44,95.8 163.92,95.32 165.98,95.32 166.11,95.2 166.11,94.56 165.98,94.43 164.68,94.43 164.36,94.11 164.36,92.74 165.26,91.84 166.37,91.84 166.52,91.68 v2(166.52,91.2) 166.52,89.85 v1(166.52,89.6)
  BOTTOM w0.178: GPU1.F32 166.13,89.2 v1(166.52,89.6)
DQA0_7: length 44
  TOP w0.178: v1(165.13,89.09) 165.09,89.05 165.09,87.39 165.21,87.27 165.92,87.27 166.05,87.39 166.05,88.22 166.17,88.35 166.66,88.35 166.79,88.22 166.79,87.39 166.91,87.27 167.39,87.27 167.39,87.27 168.28,87.27 168.44,87.43 168.44,88 168.31,88.13 167.64,88.13 167.52,88.26 167.52,88.94 167.39,89.07 166.13,89.07 166,89.2 166,91 165.65,91.36 164.83,91.36 v2(164.6,91.59) 164.37,91.82 164.37,92.27 163.9,92.73 163.9,94.38 163.78,94.51 162.78,94.51 162.65,94.38 162.65,93.65 162.53,93.52 161.6,93.52 160.78,93.52 160.47,93.2 160.47,92.75 160.09,92.37 159.31,92.37 157.77,93.92 157.77,96.45 158.18,96.87 159.65,96.87 160.28,97.5 160.44,97.5 160.45,97.5 161.36,97.5 161.37,97.5 163.07,97.5 163.67,98.1 163.67,98.68 165.53,100.53 166.04,100.53 166.16,100.66 166.16,100.98 165.65,101.5 165.65,102.45 166.1,102.9 VRAM1.C3
  BOTTOM w0.178: v1(165.13,89.09) 165.71,89.09 165.97,88.83 166.55,88.83 GPU1.F30
DQA0_8: length 39.4
  TOP w0.178: v1(162.13,89.85) 162.69,89.29 v2(162.69,89.11) ; v1(160.32,105.7) 161.07,104.96 161.54,104.96 161.57,104.93 162.15,104.93 VRAM1.F8
  L6 w0.14: v1(162.13,89.85) 162.15,89.85 162.64,90.34 162.64,90.47 162.64,90.86 162.37,91.14 161.98,91.14 160.79,89.96 159.41,89.96 158,91.37 158,92.21 158.14,92.35 158.41,92.35 158.55,92.49 158.55,92.77 158.41,92.91 158.14,92.91 158,93.05 158,93.33 158.14,93.47 158.41,93.47 158.55,93.61 158.55,93.89 158.41,94.03 158.14,94.03 158,94.17 158,98.58 158.88,99.47 158.88,101.23 159.05,101.39 159.65,101.39 159.78,101.52 159.78,101.93 159.65,102.05 159.05,102.05 158.88,102.22 158.88,102.55 159.05,102.71 159.67,102.71 159.84,102.88 159.84,103.21 159.67,103.37 159.05,103.37 158.88,103.54 158.88,103.87 159.05,104.03 159.67,104.03 159.84,104.2 159.84,104.53 159.67,104.69 159.46,104.69 159.33,104.82 159.33,105.29 159.46,105.41 160.09,105.41 160.32,105.65 v1(160.32,105.7)
  BOTTOM w0.14: v1(162.13,89.85) 162.43,89.85 162.6,90.02 162.6,90.74 162.83,90.97 163.09,90.97 163.23,90.83 163.23,90.11 163.36,89.98 163.67,89.98 163.79,90.11 163.79,90.83 163.93,90.97 165.3,90.97 165.44,91.11 165.8,91.11 165.86,91.17 166.53,91.17 166.76,90.94 166.78,90.94 GPU1.C30
DQA0_9: length 39
  TOP w0.178: VRAM1.H3 166.15,106.9 v1(165.02,105.78)
  L6 w0.14: v1(165.02,105.78) 165.02,106.26 165.72,106.96 166.23,106.96 166.61,107.34 167.15,107.34 167.28,107.21 167.28,107.12 167.64,106.76 168.54,106.76 168.63,106.66 168.63,106.29 168.24,105.89 168.24,104.79 168.64,104.39 168.64,102.58 168.32,102.26 168.32,101.59 167.4,100.67 167.4,90.96 166.99,90.55 166.21,90.55 165.71,90.05 164.56,90.05 164.43,90.17 164.43,91.95 165.14,92.66 165.15,92.66 165.41,92.92 165.41,93.69 165.28,93.82 164.9,93.82 v1(164.9,93.82)
  BOTTOM w0.102: GPU1.F27 168.72,89.2 168.85,89.33 168.85,90.14 168.78,90.3 168.78,90.57 168.85,90.71 168.85,90.94 168.78,91.1 168.78,91.37 168.85,91.51 168.85,91.74 167.24,93.34 165.95,93.34 165.92,93.32 165.4,93.32 v1(164.9,93.82)
DQA0_10: length 38
  TOP w0.178: v1(164.41,104.48) 163.73,105.17 163.73,106.49 VRAM1.H7
  L6 w0.14: v1(162.13,92.16) 161.62,92.16 161.33,91.87 161.33,91.22 161.31,91.21 161.31,91.17 160.57,90.43 159.57,90.43 159,90.99 159,94.19 158.47,94.73 158.47,98.39 159.26,99.18 159.26,100.45 159.51,100.71 160.04,100.71 160.17,100.84 160.17,102.49 160.8,103.12 161.4,103.12 161.52,103.25 161.52,104.31 161.3,104.54 160.97,104.54 160.84,104.66 160.84,105.16 160.97,105.29 161.43,105.29 161.56,105.41 161.56,106.12 162.56,107.12 163.32,107.12 163.72,106.72 163.72,105.17 v1(164.41,104.48)
  BOTTOM w0.102: 165.01,92.09 165.52,92.09 166.14,92.71 166.18,92.71 166.2,92.73 166.96,92.73 167.59,92.1 167.59,91.73 GPU1.A28
  BOTTOM w0.178: v1(162.13,92.16) 162.13,92.3 162.47,92.65 v2(163.09,92.65) 163.91,92.65 164.47,92.09 165.01,92.09
DQA0_11: length 39.9
  TOP w0.178: v1(159.59,105.85) 160.02,106.28 160.21,106.28 160.44,106.51 162.13,106.51 VRAM1.H8
  L6 w0.14: v1(162.15,90.55) 162.02,90.55 160.98,89.51 159.22,89.51 158.96,89.77 157.55,91.18 157.55,91.23 157.54,91.24 157.54,98.77 158.63,99.86 158.63,104.99 159.49,105.85 v1(159.59,105.85)
  BOTTOM w0.102: 164.76,91.51 165.16,91.51 165.26,91.61 165.62,91.61 165.85,91.84 165.86,91.84 165.97,91.96 166.27,91.96 166.49,91.73 166.49,91.52 166.85,91.17 167.23,91.17 167.59,90.8 GPU1.C28
  BOTTOM w0.178: v1(162.15,90.55) 161.88,90.55 161.55,90.22 161.55,88.84 161.42,88.72 v2(161.11,88.72) 160.51,88.72 160.39,88.84 160.39,89.38 160.26,89.51 159.57,89.51 159.45,89.64 159.45,90.09 159.57,90.22 160.4,90.22 161.85,91.67 162.34,91.67 162.5,91.51 164.76,91.51
DQA0_12: length 39.1
  TOP w0.178: v1(164.36,103.82) 164.36,103.87 163.69,104.55 163.69,104.74 163.32,105.11 VRAM1.F7
  L6 w0.14: v1(162.76,92.05) 162.76,92.42 162.55,92.63 161.87,92.63 161.71,92.8 161.71,93.55 161.51,93.75 161.01,93.75 160.88,93.62 160.88,91.6 160.76,91.48 160.15,91.48 160.03,91.6 160.03,94.09 160.38,94.44 160.38,94.92 160.21,95.09 159.4,95.09 159.27,95.22 159.27,95.62 159.4,95.75 160.21,95.75 160.38,95.92 160.38,96.25 160.21,96.41 159.43,96.41 159.3,96.54 159.3,96.94 159.43,97.07 160.21,97.07 160.38,97.24 160.38,97.57 160.21,97.73 159.5,97.73 159.33,97.9 159.33,98.23 159.5,98.39 160.21,98.39 160.38,98.56 160.38,98.97 160.24,99.11 159.77,99.11 159.64,99.24 159.64,100.07 159.77,100.2 160.66,100.2 160.79,100.32 160.79,100.9 160.56,101.13 160.56,102.31 160.92,102.67 162.11,102.67 163.33,103.89 163.33,104.2 163.45,104.32 163.86,104.32 v1(164.36,103.82)
  BOTTOM w0.102: 165.01,91.81 165.53,91.81 166.23,92.51 166.26,92.51 166.29,92.53 166.87,92.53 167.35,92.06 167.35,91.47 167.59,91.22 167.8,91.22 168.11,90.91 168.11,90.19 168.31,90 GPU1.E27
  BOTTOM w0.178: 165.01,91.81 162.99,91.81 v1(162.76,92.05)
DQA0_13: length 42
  TOP w0.178: VRAM1.G2 167.69,106.47 168.62,106.47 169.37,105.72 v1(169.37,105.42) 170.41,105.42 v2(170.61,105.22)
  L6 w0.14: v1(164.96,93.11) 163.99,92.13 163.99,88.93 164.97,87.94 165.71,87.94 166.07,88.31 166.07,89.78 166.39,90.1 167.24,90.1 167.87,90.74 167.87,99.53 169.63,101.29 169.63,105.16 v1(169.37,105.42)
  BOTTOM w0.102: GPU1.G26 169.66,88.4 169.79,88.53 169.79,89.06 169.79,89.06 169.79,89.25 169.51,89.53 169.18,89.53 169.06,89.65 169.06,90.17 168.99,90.33 168.99,90.51 169.06,90.68 169.06,90.97 168.99,91.13 168.99,91.29 169.06,91.46 169.06,91.77 169.01,91.89 167.34,93.56 165.82,93.56 ; 164.43,93.96 164.43,93.66 164.54,93.55 164.54,93.54 164.96,93.12 v1(164.96,93.11)
  BOTTOM w0.178: 164.43,93.96 164.43,94.12 164.72,94.41 164.97,94.41 165.82,93.56 165.82,93.56
DQA0_14: length 41
  TOP w0.178: v1(165.02,103.13) 165.15,103.13 VRAM1.E3
  L6 w0.14: v1(165.02,103.13) 165.02,102.9 164.79,102.67 163.15,102.67 162.87,102.4 162.87,101.17 163.04,101 163.78,101 163.94,100.84 163.94,100.34 163.78,100.18 162.37,100.18 162.1,99.91 162.1,99.42 162.23,99.29 162.73,99.29 162.86,99.16 162.86,98.55 162.73,98.43 161.46,98.43 161.33,98.3 161.33,97.79 161.46,97.67 162.51,97.67 162.68,97.5 162.68,96.96 162.55,96.83 161.45,96.83 161.32,96.7 161.32,96.19 161.45,96.06 162.01,96.06 162.14,95.93 v1(162.14,94.49)
  BOTTOM w0.102: GPU1.D26 169.57,90.95 169.65,91.11 169.65,91.34 169.59,91.48 169.59,91.8 169.73,92.04 169.73,92.37 169.49,92.61 168.58,92.61 167.38,93.81 166.06,93.81 164.98,94.9 164.57,94.9 164.45,94.77
  BOTTOM w0.178: 164.45,94.77 164.17,94.5 163.08,94.5 162.84,94.26 162.84,93.65 161.66,92.46 161.66,92.45 159.88,90.67 159.31,90.67 159.02,90.95 159.02,91.13 v2(161.42,93.54) 162.14,94.26 v1(162.14,94.49)
DQA0_15: length 39.3
  TOP w0.178: VRAM1.F2 v1(166.92,104.9)
  L6 w0.14: v1(163.57,95) 164.31,94.27 164.73,94.27 164.81,94.35 166.06,94.35 166.19,94.22 166.19,93.05 164.87,91.73 164.87,91.17 165.06,90.98 166.01,90.98 166.02,90.99 166.81,90.99 166.95,91.14 166.95,91.54 166.83,91.67 166.38,91.67 166.26,91.79 166.26,92.31 166.52,92.57 166.54,92.57 166.87,92.9 166.87,96.77 166.52,97.11 166.52,97.46 166.87,97.8 166.87,100.87 167.36,101.37 167.36,101.86 167.52,102.03 167.94,102.03 168.07,102.16 168.07,102.56 167.94,102.69 167.49,102.69 167.36,102.82 167.36,103.22 167.49,103.35 168.22,103.35 168.34,103.48 168.34,103.88 168.22,104.01 166.87,104.01 166.75,104.14 166.75,104.77 166.87,104.9 v1(166.92,104.9)
  BOTTOM w0.102: 165.76,94.46 166.2,94.01 167.46,94.01 168.66,92.81 169.65,92.81 169.94,92.52 169.94,91.93 169.79,91.72 169.79,91.53 169.85,91.39 169.85,91.04 169.79,90.93 169.79,90.54 169.6,90.16 169.62,89.93 169.79,89.79 170.12,89.45 GPU1.F25
  BOTTOM w0.178: v1(163.57,95) 163.7,95 164.06,95.36 v2(164.44,95.36) 164.85,95.36 165.76,94.46
DQA0_16: length 44.7
  BOTTOM w0.102: GPU1.A25 170.14,91.62 170.14,92.83 169.96,93.02 168.75,93.02 167.52,94.25 166.97,94.25 166.6,94.61
  BOTTOM w0.178: 166.6,94.61 166.59,94.62 166.24,94.62 165.69,95.17 165.69,95.52 165.41,95.81 163.87,95.81 163.56,95.49 162.43,95.49 159.13,92.19 156.67,92.19 156.3,92.19 154.58,93.9 154.58,96.82 152.33,99.07 152.33,99.07 151.73,99.67 150.97,100.43 150.97,100.76 150.97,101.13 152.78,102.94 154.1,102.94 v2(154.75,102.29) 155.65,101.39 155.65,101.02 155.65,100.65 156.04,100.25 158.57,100.25 158.91,100.6 159.9,100.6 160.67,101.36 160.67,102.27 160.94,102.54 161.55,102.54 161.57,102.53 162.15,102.53 VRAM2.C2
DQA0_17: length 44.4
  BOTTOM w0.102: GPU1.C25 170.29,90.97 170.37,91.14 170.37,91.31 170.45,91.46 170.45,91.85 170.36,91.94 170.36,92.93 170.08,93.22 168.83,93.22 167.41,94.64
  BOTTOM w0.178: 167.41,94.64 167.2,94.64 166.78,95.06 166.42,95.06 166.13,95.36 166.13,95.71 166.13,95.85 166.13,95.92 165.8,96.25 163.69,96.25 163.37,95.93 162.24,95.93 158.94,92.63 v2(157.8,92.63) 156.48,92.63 155.03,94.09 155.03,97 152.51,99.52 152.51,99.52 152.18,99.85 151.42,100.61 151.42,100.94 152.97,102.49 153.91,102.49 154.07,102.34 154.07,102.09 153.95,101.97 153.95,101.71 154.2,101.46 154.45,101.46 154.57,101.58 154.82,101.58 155.2,101.21 155.2,100.46 155.85,99.81 158.66,99.81 159.13,100.28 160.07,100.28 160.65,100.86 161.3,100.86 161.36,100.92 162.23,100.92 162.52,101.21 VRAM2.A2
DQA0_18: length 44.6
  BOTTOM w0.102: GPU1.E25 170.35,90 170.58,90.22 170.58,91.26 170.65,91.41 170.65,92.07 170.58,92.14 170.58,92.48 170.71,92.61 170.71,92.88 170.12,93.46 169,93.46 167.68,94.79
  BOTTOM w0.178: VRAM2.A3 163.32,101.07 162.83,100.58 161.91,100.58 161.9,100.58 161.54,100.58 161.41,100.45 160.7,100.45 160.17,99.93 159.33,99.93 158.77,99.37 155.67,99.37 155.21,99.82 154.75,100.28 154.75,100.81 154.55,101.02 154.01,101.02 153.22,101.82 153.04,101.82 v2(152.51,101.28) 152.03,100.81 152.03,100.63 155.47,97.18 155.47,94.27 156.67,93.08 157.27,93.08 157.57,93.38 157.98,93.38 158.28,93.08 158.73,93.08 162.03,96.37 163.19,96.37 163.51,96.69 166.31,96.69 166.58,96.43 166.58,95.89 167.68,94.79
DQA0_19: length 44.8
  BOTTOM w0.102: GPU1.D24 171.12,90.6 171.17,90.7 171.17,90.95 171.25,91.11 171.25,91.34 171.19,91.48 171.19,91.8 171.39,92.13 171.39,92.14 171.39,92.48 170.16,93.71 169.16,93.71 168.96,93.91
  BOTTOM w0.178: VRAM2.C3 163.32,102.73 163.6,102.45 163.6,102.44 164.17,101.87 164.17,101.41 163,100.24 162.45,100.24 161.9,99.69 161.54,99.69 161.34,99.89 160.62,99.89 160.29,99.56 159.48,99.56 158.84,98.92 158.45,98.92 155.48,98.92 154.44,99.96 153.37,101.03 153.19,101.03 152.81,100.66 152.81,100.48 155.92,97.37 155.92,94.46 156.55,93.82 158.84,93.82 161.84,96.82 163,96.82 163.32,97.14 v2(165.96,97.14) 166.78,97.14 167.04,96.88 167.04,96.06 167.93,95.16 167.93,94.94 168.96,93.91
DQA0_20: length 45.1
  BOTTOM w0.102: 170.2,94.92 170.23,94.94 170.64,94.94 170.84,94.74 170.84,94.25 172.24,92.85 172.24,92.2 172.24,92.19 172.24,91.39 172.18,91.26 172.18,90.3 172.12,90.2 171.93,90 GPU1.E23
  BOTTOM w0.178: 170.2,94.92 169.89,95.23 169.89,96.25 169.76,96.38 169.45,96.38 169.17,96.65 169.17,97.04 169.44,97.31 169.76,97.31 169.89,97.44 169.89,97.75 173.07,100.94 173.87,101.74 v2(173.87,101.98) 174.29,102.4 174.29,102.87 174.05,103.12 174.05,103.54 174.29,103.78 174.29,104.3 174.05,104.54 174.05,104.87 174.29,105.11 174.29,105.52 174.2,105.61 173.37,105.61 173.25,105.74 173.25,106.78 173.12,106.9 172.8,106.9 172.49,106.59 172.49,105.48 172.85,105.12 173.11,104.86 173.11,103.63 172.99,103.5 172.05,103.5 171.37,102.82 170.71,102.82 169.58,101.7 169.58,100.7 168.01,99.12 167.45,99.12 167.32,99.25 167.32,100.4 167.2,100.52 166.72,100.52 166.6,100.4 166.6,99.13 166.47,99 166,99 165.88,99.13 165.88,99.45 165.75,99.58 165.24,99.58 165.11,99.45 165.11,99.17 164.98,99.05 164.19,99.05 164.07,99.17 164.07,99.42 165.03,100.39 165.27,100.39 166.13,101.24 166.46,101.24 VRAM2.A7
DQA0_21: length 45.4
  BOTTOM w0.102: 169.39,94.02 170.14,94.02 171.6,92.56 171.6,92.01 171.39,91.72 171.39,91.53 171.45,91.39 171.45,91.03 171.39,90.88 171.39,90.21 171.17,89.99 171.17,89.41 171.39,89.2 GPU1.F23
  BOTTOM w0.178: 169.39,94.02 168.38,95.03 168.38,95.35 167.49,96.24 167.49,96.75 167.49,97.3 167.15,97.64 v2(163.86,97.64) 163.19,97.64 162.82,97.26 161.65,97.26 161.39,97 161.39,97 158.66,94.27 156.74,94.27 156.42,94.59 156.42,95 156.54,95.12 157.84,95.12 157.96,95.25 157.96,95.56 157.69,95.83 156.66,95.83 156.53,95.96 156.53,98.35 156.66,98.48 157.1,98.48 157.28,98.3 157.28,97.01 157.41,96.88 157.71,96.88 158.01,97.18 158.01,98.35 158.14,98.48 158.86,98.48 159.61,99.23 160.42,99.23 160.73,99.53 161.3,99.53 161.42,99.41 162.02,99.41 162.47,99.86 163.12,99.86 164.59,101.33 164.59,101.66 165.86,102.93 165.86,103.3 166.26,103.7 VRAM2.D7
DQA0_22: length 45.3
  BOTTOM w0.102: GPU1.D22 172.7,90.58 172.77,90.74 172.77,90.95 172.85,91.11 172.85,91.34 172.79,91.48 172.79,91.8 173.05,92.24 173.05,92.53 172.52,93.06 172.32,93.06 171.19,94.18 171.19,94.75 171.18,94.77
  BOTTOM w0.178: 171.18,94.77 171.14,94.8 171.14,95.13 170.97,95.31 170.46,95.31 170.33,95.44 170.33,95.9 170.46,96.02 170.97,96.02 171.14,96.2 171.14,96.65 170.97,96.82 170.46,96.82 170.33,96.95 170.33,97.41 170.46,97.53 170.97,97.53 171.14,97.71 171.14,98.38 172.6,99.84 173.15,99.84 173.28,99.71 173.28,99.7 173.4,99.58 173.91,99.58 174.02,99.69 174.02,100.07 173.51,100.58 173.51,100.75 173.83,101.07 174.04,101.07 174.89,100.21 175.11,100.21 175.36,100.46 175.36,100.82 174.54,101.64 174.54,101.78 174.74,101.98 174.74,105.49 175.15,105.9 175.15,107.24 175.02,107.36 174.54,107.36 174.41,107.24 v2(174.41,106.8) 174.41,106.18 174.28,106.06 173.82,106.06 173.69,106.18 173.69,107.24 173.56,107.36 172.63,107.36 172.61,107.34 172.04,106.78 172.04,104.87 172.17,104.74 172.55,104.74 172.67,104.63 172.67,104.06 172.55,103.95 171.87,103.95 171.18,103.27 170.09,103.27 169.97,103.14 169.97,102.72 169.21,101.96 169.21,100.89 168.08,99.76 167.8,99.76 167.68,99.89 167.68,100.93 167.69,100.95 167.69,101.81 167.4,102.1 VRAM2.B8
DQA0_23: length 45.8
  BOTTOM w0.102: GPU1.F21 172.98,89.2 172.85,89.33 172.85,89.34 172.66,89.53 172.64,89.53 172.54,89.63 172.54,89.95 172.99,90.4 172.99,90.89 173.05,91.04 173.05,91.39 172.99,91.53 172.99,91.72 173.25,92.09 173.25,92.62 171.59,94.28 171.59,94.93
  BOTTOM w0.178: VRAM2.C8 167.32,102.83 167.61,102.53 168.27,102.53 168.3,102.56 169.09,102.56 169.53,103 169.53,103.39 169.86,103.71 171,103.71 171.6,104.31 171.6,106.96 172.17,107.53 172.36,107.72 172.45,107.81 175.56,107.81 175.68,107.69 175.68,107.21 175.95,106.93 176.54,106.93 176.67,106.8 176.67,102.51 176.54,102.38 176.07,102.38 175.94,102.51 175.94,105.54 175.81,105.67 175.54,105.67 175.18,105.31 175.18,101.77 175.31,101.64 v2(175.82,101.64) 176.48,101.64 176.61,101.51 176.61,101.09 176.42,100.91 176.42,100.9 175.19,99.66 175.19,99.45 175.19,99.26 175.06,99.13 172.52,99.13 171.59,98.2 171.59,94.93
DQA0_24: length 40.4
  L4 w0.152: v1(159.54,106.74) 158.88,106.74 158.15,106.01 158.15,96.02 159.2,94.97 159.21,94.97 159.21,94.97 160.47,94.97 160.63,94.81 160.63,93.89 160.76,93.77 161.33,93.77 161.46,93.89 161.46,94.81 161.62,94.97 162.74,94.97 163.17,94.54 164.98,94.54 166.55,92.97 171.62,92.97 172.36,93.72 172.36,94.45 172.72,94.8 v1(172.88,94.8)
  BOTTOM w0.102: GPU1.E21 173.78,90.9 173.78,91.25 173.86,91.42 173.86,93.1 172.9,94.06
  BOTTOM w0.178: v2(159.23,107.3) 159.23,107.05 v1(159.54,106.74) 159.54,106.59 159.72,106.41 159.74,106.39 159.76,106.37 159.79,106.34 159.85,106.31 159.91,106.29 159.95,106.29 160.87,106.29 161.06,106.47 162.15,106.47 VRAM2.G2 ; v1(172.88,94.8) 172.9,94.78 172.9,94.06
DQA0_25: length 41.5
  L4 w0.152: v1(160.3,104.07) 159.84,104.54 159.84,105.07 159.64,105.27 158.75,105.27 158.65,105.16 158.65,103.77 158.81,103.61 159.25,103.61 159.38,103.48 159.38,102.91 159.25,102.78 158.81,102.78 158.65,102.62 158.65,102.12 158.81,101.96 159.25,101.96 159.37,101.83 159.37,101.26 159.25,101.13 158.81,101.13 158.65,100.97 158.65,100.47 158.81,100.31 159.15,100.31 159.28,100.18 159.28,99.61 159.15,99.48 158.81,99.48 158.65,99.32 158.65,96.46 159.64,95.47 164.71,95.47 166.85,93.33 171.39,93.33 171.89,93.83 171.89,94.64 172.72,95.46 172.88,95.46 v1(172.9,95.44)
  BOTTOM w0.102: GPU1.D20 174.37,90.65 174.37,90.95 174.45,91.11 174.45,91.34 174.39,91.48 174.39,92.14 174.71,92.47 174.71,92.83 173.33,94.21 173.33,95.41 173.2,95.54 173.02,95.54 172.92,95.44 v1(172.9,95.44)
  BOTTOM w0.178: VRAM2.F2 162.09,104.87 161.09,104.87 v1(160.3,104.07) v2(159.23,104.07)
DQA0_26: length 40.5
  L4 w0.152: v1(172.93,96.07) 172.68,96.07 171.52,94.92 171.51,94.92 171.42,94.83 171.42,94.45 171.42,94.06 171.08,93.72 167.12,93.72 164.91,95.94 160.41,95.94 159.67,96.67 159.67,99.16 161.68,101.18 161.68,105.88 162.74,106.94 163.1,106.94 163.57,106.47 163.57,105.95 v1(164.4,105.13)
  BOTTOM w0.102: v1(172.93,96.07) 173.23,96.07 173.7,95.6 173.7,94.15 174.91,92.93 174.91,92.31 174.59,91.99 174.59,91.53 174.65,91.39 174.65,91.03 174.59,90.88 174.59,89.53 GPU1.F19
  BOTTOM w0.178: VRAM2.H3 163.69,106.53 163.69,105.84 v1(164.4,105.13)
DQA0_27: length 38.9
  L4 w0.152: v1(172.95,96.71) 171.15,96.71 170.69,96.25 170.69,94.22 170.56,94.1 167.51,94.1 166.28,95.33 166.28,96.19 165.7,96.76 162.75,96.76 162.59,96.93 162.59,97.86 162.29,98.16 161.89,98.16 161.76,98.03 161.76,96.73 161.63,96.61 160.57,96.61 160.44,96.73 160.44,99.41 160.57,99.54 161.8,99.54 162.36,100.1 163.74,100.1 163.87,100.23 163.87,100.8 163.74,100.93 162.73,100.93 162.6,101.06 162.6,102.19 162.2,102.59 162.2,103.41 v1(162.89,104.1)
  BOTTOM w0.102: v1(172.95,96.71) 173.16,96.71 173.5,96.38 174.17,96.38 174.32,96.23 174.65,96.23 174.78,96.1 174.78,95.73 174.65,95.6 174.5,95.6 174.07,95.17 174.07,95.17 174.07,94.08 175.12,93.03 175.12,92.1 174.92,91.9 GPU1.A19
  BOTTOM w0.178: VRAM2.E3 163.29,104.5 v1(162.89,104.1)
DQA0_28: length 39.6
  L4 w0.152: v1(165.05,104.4) 165.17,104.28 166.27,104.28 166.4,104.15 166.4,102.51 166.65,102.26 167.08,102.26 167.36,102.54 167.36,103.92 167.49,104.04 167.99,104.04 168.12,103.92 168.12,102.72 168.24,102.59 169.15,102.59 169.28,102.47 169.28,101.61 169.4,101.49 170.16,101.49 170.29,101.36 170.29,99.22 170.45,99.06 170.78,99.06 170.95,99.22 170.95,100.72 171.11,100.89 171.44,100.89 171.61,100.72 171.61,99.22 171.77,99.06 172.1,99.06 172.27,99.22 172.27,100.72 172.44,100.89 172.77,100.89 172.93,100.72 172.93,98.96 173.06,98.83 173.46,98.83 173.59,98.96 173.59,100.72 173.76,100.89 174.23,100.89 174.35,100.76 174.35,97.76 174.59,97.52 174.59,97.49 174.59,96.24 174.73,96.1 v1(175.29,96.1)
  BOTTOM w0.102: GPU1.D18 175.93,90.68 175.95,90.85 176.05,91.11 176.05,91.34 175.99,91.48 175.99,93.35 176.12,93.48 176.12,94.55 175.83,94.83 175.83,95.9 175.63,96.1 v1(175.29,96.1)
  BOTTOM w0.178: v1(165.05,104.4) 165.78,104.4 166.52,105.15 VRAM2.F7
DQA0_29: length 40.3
  L4 w0.152: v1(166.92,105.7) 166.92,105.82 167.33,106.23 168.79,106.23 169.09,106.53 169.81,106.53 170.07,106.27 170.07,106.09 170.66,105.5 170.66,105.1 170.66,104.69 172.99,102.35 173.4,102.35 174.59,102.35 174.72,102.48 174.72,103.26 174.84,103.39 178.16,103.39 178.29,103.26 178.29,102.56 178.58,102.26 178.95,102.26 179.28,102.59 179.28,103.89 179.41,104.01 181.15,104.01 181.56,103.6 181.56,101.12 180.49,100.05 178.53,100.05 175.32,96.84 v1(175.26,96.84)
  BOTTOM w0.102: GPU1.F17 176.19,89.86 176.19,90.9 176.25,91.01 176.25,91.39 176.19,91.53 176.19,93.13 176.32,93.26 176.32,94.71 176.2,94.83 176.2,96.25 175.62,96.84 v1(175.26,96.84)
  BOTTOM w0.178: VRAM2.F8 v1(166.92,105.7)
DQA0_30: length 40.7
  TOP w0.178: v1(169.63,106.09) 170.26,106.09 v2(170.61,106.44)
  L4 w0.152: v1(175.31,97.5) 178.22,100.4 178.22,100.85 178.34,100.98 179.02,100.98 179.15,100.85 179.15,100.68 179.31,100.52 179.81,100.52 179.97,100.68 179.97,100.79 180.1,100.92 180.69,100.92 181.07,101.3 181.07,101.77 180.9,101.94 180.55,101.94 180.42,102.06 180.42,102.47 180.55,102.6 180.9,102.6 181.07,102.76 181.07,103.43 180.95,103.54 179.97,103.54 179.75,103.32 179.75,102.4 179.14,101.79 178.19,101.79 177.82,102.16 177.82,102.79 177.69,102.92 176.77,102.92 176.61,102.75 176.61,102.04 176.48,101.91 176.07,101.91 175.95,102.04 175.95,102.75 175.78,102.92 175.31,102.92 175.19,102.79 175.19,102.29 174.78,101.88 173.59,101.88 172.8,101.88 170.39,104.3 169.67,104.3 169.55,104.42 169.55,104.9 169.97,105.32 169.97,105.75 v1(169.63,106.09)
  BOTTOM w0.102: v1(175.31,97.5) 175.48,97.5 176.57,96.4 176.57,93.03 176.44,92.9 176.44,91.68 GPU1.A17
  BOTTOM w0.178: v1(169.63,106.09) 169.61,106.09 169.21,106.49 167.73,106.49 VRAM2.H8
DQA0_31: length 40.1
  L4 w0.152: v1(175.29,98.21) 175.36,98.21 177.75,100.6 177.75,101.57 177.47,101.85 177.11,101.85 176.99,101.72 176.99,100.77 176.86,100.64 176.45,100.64 176.33,100.77 176.33,101.31 176.2,101.43 175.65,101.43 175.53,101.31 175.53,99.44 175.36,99.27 175.03,99.27 174.86,99.44 174.86,101.25 174.7,101.41 172.6,101.41 172.18,101.84 171.94,101.84 171.46,101.36 170.98,101.36 170.84,101.5 170.84,101.68 171.48,102.31 171.48,102.54 171.24,102.78 171.01,102.78 170.12,101.89 169.95,101.89 169.66,102.18 169.66,102.36 170.54,103.24 170.54,103.75 170.42,103.88 169.44,103.88 169.27,103.7 168.91,103.7 168.28,104.33 166.81,104.33 166.39,104.74 165.47,104.74 v1(165.13,105.08)
  BOTTOM w0.102: v1(175.29,98.21) v2(176.34,97.15) 176.94,96.55 176.94,92.85 176.64,92.56 176.64,91.96 176.85,91.75 176.85,91.46 GPU1.C17
  BOTTOM w0.178: v1(165.13,105.08) 165.13,105.14 165.51,105.52 165.51,106.02 166.39,106.9 VRAM2.H7
DQA1_0: length 41.7
  TOP w0.178: v2(181.74,105.34) 182.47,105.34 v1(182.82,105.7) 183.57,104.96 184.04,104.96 184.07,104.93 184.65,104.93 VRAM4.F8
  L4 w0.152: v1(182.82,105.7) 183.28,105.24 184.86,105.24 184.95,105.15 184.95,104.66 184.83,104.54 184.18,104.54 184.05,104.41 184.05,103.81 183.46,103.22 183.46,102.9 183.34,102.77 182.47,102.77 182.29,102.6 182.29,102.08 182.42,101.95 182.96,101.95 183.09,101.83 183.09,101.42 182.96,101.29 182.42,101.29 182.23,101.1 182.23,100.43 180.87,99.08 178.96,99.08 178.03,98.15 178.03,97.36 177.47,96.79 176.67,96.79 176.45,96.57 176.45,96.1 176.61,95.94 177.05,95.94 177.17,95.81 177.17,95.4 177.05,95.27 176.61,95.27 176.45,95.11 176.45,94.78 176.61,94.61 177.05,94.61 177.17,94.49 177.17,94.08 177.05,93.95 176.44,93.95 176.31,93.83 176.31,93.46 176.44,93.33 177.16,93.33 177.17,93.34 177.84,93.34 177.96,93.46 177.96,95.92 178.89,96.84 v1(179,96.84)
  BOTTOM w0.102: GPU1.E17 176.76,90 176.98,90.22 176.98,91.26 177.05,91.42 177.05,91.84 176.85,92.04 176.85,92.46 177.36,92.97 177.36,94.66
  BOTTOM w0.178: 177.36,94.66 177.36,95.71 177.6,95.95 178.11,95.95 v1(179,96.84)
DQA1_1: length 40.7
  TOP w0.178: VRAM4.H8 184.63,106.51 182.73,106.51 182.09,105.87 v1(182.09,105.85)
  L4 w0.152: v1(182.09,105.85) 182.09,104.6 182.32,104.37 182.32,103.68 181.91,103.28 181.91,100.78 180.68,99.55 178.76,99.55 177.37,98.16 177.37,97.92 177.56,97.73 177.56,97.55 177.27,97.26 177.09,97.26 176.9,97.45 176.67,97.45 175.97,96.75 175.97,94.37 175.72,94.12 174.53,94.12 174.4,94.26 174.35,94.26 174.35,94.27 173.2,94.27 173,94.07 173,93.67 173.55,93.12 174.65,93.12 174.81,92.96 175.31,92.96 175.44,92.83 175.44,92.44 175.56,92.31 176.35,92.31 176.48,92.44 176.48,92.83 176.61,92.96 178.37,92.96 179,93.59 179,94 178.81,94.19 178.81,94.19 178.53,94.46 178.53,95.28 178.53,95.69 v1(179,96.16)
  BOTTOM w0.102: 178.06,94.38 178.06,93.9 177.66,93.5 177.66,91.95 177.59,91.87 177.59,91.48 177.65,91.34 177.65,91.11 177.45,90.73 177.32,90.59 GPU1.D16
  BOTTOM w0.178: v2(181.56,105.6) 181.81,105.85 v1(182.09,105.85) ; v1(179,96.16) 178.06,95.22 178.06,94.38
DQA1_2: length 40.2
  TOP w0.178: VRAM4.F2 v1(189.42,104.9)
  L4 w0.152: v1(179,95.47) 179.79,94.68 179.79,91.99 180.24,91.54 182.31,91.54 182.56,91.78 182.56,92.02 183.62,93.08 185.7,93.08 188.39,95.77 192.56,95.77 192.59,95.79 192.6,95.79 194.06,97.25 194.06,97.8 194.06,101.5 193.87,101.69 193.87,101.86 194.05,102.04 194.05,102.22 193.77,102.51 193.59,102.51 193.4,102.32 193.17,102.32 192.94,102.56 192.94,102.79 193.14,103 193.14,103.18 192.86,103.47 192.68,103.47 192.47,103.26 192.24,103.26 191.79,103.7 191.08,103.7 190.38,104.4 189.92,104.4 v1(189.42,104.9)
  BOTTOM w0.102: GPU1.F15 178,89.2 177.79,89.41 177.79,90.89 177.85,91.03 177.85,91.39 177.79,91.53 177.79,91.77 177.87,91.85 177.87,93.41 178.44,93.99 178.44,94.52 178.43,94.53
  BOTTOM w0.178: 178.43,94.53 178.43,94.9 v1(179,95.47)
DQA1_3: length 40.1
  TOP w0.178: VRAM4.G2 190.19,106.47 191.33,106.47 v1(192.41,105.4)
  L4 w0.152: v1(179,94.66) 179.32,94.34 179.32,91.61 179.8,91.13 182.41,91.13 183.03,91.75 183.03,92.11 183.69,92.77 186.13,92.77 187.87,94.51 188.13,94.51 188.85,95.24 192.69,95.24 194.63,97.18 194.63,102.38 194.31,102.7 194.31,102.94 194.61,103.24 194.61,103.42 194.32,103.71 194.14,103.71 193.84,103.41 193.61,103.41 193.37,103.64 193.37,103.87 193.66,104.16 193.66,104.34 193.37,104.63 193.19,104.63 192.91,104.34 192.67,104.34 192.41,104.61 v1(192.41,105.4)
  BOTTOM w0.102: GPU1.A15 178.07,91.65 178.07,93.33 178.69,93.95 178.69,94.35 v1(179,94.66)
  BOTTOM w0.178: v1(192.41,105.4) v2(193.17,105.4)
DQA1_4: length 40.4
  TOP w0.178: v1(186.86,103.82) 186.86,103.87 186.19,104.55 186.19,104.74 185.82,105.11 VRAM4.F7
  L4 w0.152: v1(186.86,103.82) 186.77,103.82 186.45,103.5 186.45,102.95 187.06,102.35 187.66,102.35 187.79,102.22 187.79,99.88 187.92,99.75 190.88,99.75 191.01,99.63 191.01,99.22 190.88,99.09 187.29,99.09 187.17,99.22 187.17,100.24 187.04,100.36 186.59,100.36 186.46,100.24 186.46,98.17 186.14,97.85 185.78,97.85 185.66,97.97 185.66,100.2 185.53,100.33 185.12,100.33 185,100.2 185,99.27 184.87,99.14 183.9,99.14 183.77,99.01 183.77,97.24 183.64,97.12 183.22,97.12 183.09,97.24 183.09,98.9 182.96,99.03 182.2,99.03 v1(181.98,98.8)
  BOTTOM w0.102: GPU1.D14 179.17,90.65 179.17,90.95 179.25,91.11 179.25,91.34 179.19,91.48 179.19,92.58 179.29,92.68 179.29,93.47
  BOTTOM w0.178: v1(181.98,98.8) 181.98,98.78 181.94,98.75 181.94,98.54 181.94,98.54 181.94,98.19 181.67,97.93 181.33,97.93 181.03,97.63 180.7,97.63 v2(180.59,97.53) 180.44,97.38 180.44,94.63 179.29,93.47
DQA1_5: length 40.9
  TOP w0.178: v1(186.91,104.48) 186.23,105.17 186.23,106.49 VRAM4.H7
  L4 w0.152: v1(181.9,97.48) 181.85,97.48 181.39,97.02 181.39,96.18 181.26,96.05 180.83,96.05 180.68,96.2 180.68,97.88 180.42,98.13 180.42,98.48 180.55,98.61 180.68,98.61 181.07,98.61 181.87,99.41 182.49,99.41 182.62,99.53 182.62,100.77 182.74,100.89 183.15,100.89 183.27,100.77 183.27,99.53 183.4,99.41 183.82,99.41 183.94,99.53 183.94,100.31 184.08,100.45 184.08,103.26 184.36,103.54 184.72,103.54 184.84,103.43 184.84,103 185.69,102.16 185.69,101.92 185.08,101.31 185.08,101.13 185.36,100.85 185.54,100.85 186.15,101.46 186.39,101.46 186.73,101.11 187.3,101.11 187.43,101.24 187.43,101.86 187.3,101.99 186.9,101.99 185.54,103.34 185.54,103.51 185.87,103.84 185.87,104.77 186,104.9 186.51,104.9 186.91,104.49 v1(186.91,104.48)
  BOTTOM w0.102: GPU1.F13 179.59,89.33 179.28,89.33 179.03,89.58 179.03,90.04 179.39,90.4 179.39,90.89 179.45,91.03 179.45,91.39 179.39,91.53 179.39,92.49 179.49,92.59 179.49,93.22 179.77,93.5
  BOTTOM w0.178: v1(181.9,97.48) 181.55,97.48 180.9,96.84 v2(180.9,94.73) 180.9,94.63 179.77,93.5
DQA1_6: length 39.3
  TOP w0.178: v1(187.52,103.13) 187.57,103.13 188.02,103.59 188.02,104.6 188.15,104.73 188.79,104.73 VRAM4.E3
  L4 w0.152: v1(187.52,103.13) 187.77,103.13 188.01,103.38 188.01,103.74 188.14,103.86 188.55,103.86 188.68,103.74 188.68,103.1 188.47,102.89 188.47,102.07 188.65,101.89 188.65,101.28 188.47,101.1 188.47,100.53 188.6,100.4 189.2,100.4 189.33,100.53 189.33,100.73 189.49,100.9 189.82,100.9 189.99,100.73 189.99,100.48 190.15,100.31 190.8,100.31 191.23,100.74 191.4,100.74 191.68,101.02 191.93,101.02 192.18,100.77 192.18,99.23 191.99,99.04 191.99,98.07 191.72,97.8 187.81,97.8 187.42,97.8 184.9,95.27 184.43,95.27 184.27,95.11 184.27,94.74 184.14,94.62 183.73,94.62 183.61,94.74 183.61,95.17 183.48,95.3 182.97,95.3 182.53,94.86 182.53,93.76 182.4,93.64 182.04,93.64 181.91,93.77 181.91,95.24 182.39,95.72 182.39,96.58 182.12,96.85 v1(181.92,96.85)
  BOTTOM w0.102: 180.42,93.61 179.69,92.89 179.69,92.51 179.68,92.49 179.68,91.64 GPU1.A13
  BOTTOM w0.178: 180.42,93.61 181.36,94.56 181.36,96.45 181.36,96.45 v2(181.36,96.56) 181.36,96.6 181.6,96.84 181.92,96.84 v1(181.92,96.85)
DQA1_7: length 39.8
  TOP w0.178: VRAM4.H3 188.67,106.9 187.55,105.78 v1(187.52,105.78)
  L4 w0.152: v1(181.92,96.18) 181.86,96.12 181.86,95.98 181.45,95.57 181.45,94.2 181.05,93.8 181.05,93.45 181.25,93.25 182.5,93.25 183.49,94.25 184.52,94.25 187.61,97.34 191.91,97.34 192.44,97.88 192.44,97.93 192.46,97.94 192.46,100.99 191.83,101.62 190.86,101.62 190.73,101.74 190.73,102.53 190.7,102.56 190.28,102.98 190.01,102.98 189.87,102.84 189.87,101.38 189.74,101.25 189.62,101.25 189.61,101.25 189.25,101.25 189.25,101.25 189.1,101.25 188.97,101.38 188.97,103.93 188.68,104.22 188.13,104.22 188.01,104.34 188.01,105.53 187.76,105.78 v1(187.52,105.78)
  BOTTOM w0.102: 180.94,93.7 179.91,92.67 179.91,92.43 179.88,92.4 179.88,91.91 180.05,91.74 180.05,91.48 179.97,91.38 179.72,91.13 GPU1.C13
  BOTTOM w0.178: v1(181.92,96.18) 181.9,96.17 v2(181.9,95.44) 181.9,94.67 180.94,93.7
DQA1_8: length 45.5
  BOTTOM w0.102: 184.57,94.9 183.27,93.61 183.16,93.61 183.16,93.6 183.02,93.6 181.71,92.3 181.71,92.04 181.77,91.91 181.77,91.91 181.85,91.71 181.85,91.52 181.79,91.24 181.79,91.12 181.85,90.98 181.85,90.7 181.86,90.62 181.82,90.57 181.81,90.56 181.81,90.56 181.8,90.55 181.79,90.53 181.79,90.26 181.98,90.07 182.41,90.07 182.54,89.94 182.54,89.67 182.41,89.54 181.45,89.54 181.32,89.67 GPU1.E11
  BOTTOM w0.178: VRAM3.C3 185.91,102.99 186.41,102.99 186.7,102.69 187.95,102.69 188.08,102.56 188.08,100.39 188.2,100.26 188.64,100.26 189.62,99.28 191.97,99.28 192.88,100.19 193.59,100.19 193.72,100.32 193.72,100.56 193.84,100.69 198.19,100.69 198.31,100.56 198.31,99.82 198.16,99.66 196.77,98.27 196.77,98.15 196.77,98.14 196.77,97.59 196.77,95.79 196.55,95.57 196.38,95.57 196.12,95.57 196,95.44 196,95.19 195.85,95.04 195.38,95.04 195.05,95.37 195.05,96.06 194.92,96.18 194.29,96.18 194.14,96.33 192.99,96.33 192.37,96.96 186.41,96.96 185.44,95.98 185.44,95.68 v2(185.31,95.56) 185.22,95.47 184.69,95.47 184.57,95.34 184.57,94.9
DQA1_9: length 44.5
  BOTTOM w0.102: 183.19,94.43 182.53,93.74 181.31,92.51 181.31,91.61 GPU1.A11
  BOTTOM w0.178: VRAM3.A3 185.58,101.06 185.58,99.48 185.71,99.36 186.59,99.36 186.72,99.48 186.72,100.85 186.6,100.98 186.6,101.94 186.72,102.07 187.32,102.07 187.45,101.94 187.45,99.78 187.58,99.65 188.18,99.65 188.81,99.03 188.81,98.86 189.06,98.6 192.77,98.6 192.78,98.6 193.42,98.6 193.43,98.6 194.26,98.6 194.39,98.73 194.39,99.68 194.52,99.8 196.41,99.8 196.54,99.68 196.54,99.3 196.29,99.05 195.45,99.05 195.33,98.93 195.33,97.2 195.2,97.07 194.66,97.07 194.53,97.2 194.53,97.76 194.41,97.89 193.86,97.89 193.73,97.76 193.73,97.47 193.61,97.34 193.33,97.34 192.82,97.85 188.08,97.85 187.95,97.97 187.95,98.84 187.82,98.97 187.31,98.97 187.18,98.84 187.18,97.97 187.06,97.85 185.41,97.85 185.28,97.72 185.28,97.12 184.69,96.53 184.11,96.53 v2(183.92,96.33) 183.92,96.18 183.65,95.91 183.65,95.14 183.64,95.13 183.64,94.88 183.19,94.43
DQA1_10: length 44.8
  BOTTOM w0.102: GPU1.C11 181.22,90.8 181.05,90.97 181.05,91.39 180.99,91.47 180.99,91.74 181.1,91.85 181.1,92.72 183.21,94.83 183.21,96.1
  BOTTOM w0.178: 183.21,96.1 183.38,96.27 183.38,98.11 183.51,98.23 183.95,98.23 184.13,98.06 184.13,97.1 184.26,96.97 184.51,96.97 184.84,97.3 184.84,98.16 184.97,98.29 186.6,98.29 186.73,98.42 186.73,98.9 186.6,99.03 183.44,99.03 183.01,99.46 183.01,100.21 182.88,100.35 181.36,100.35 181.02,100.01 181.02,98.88 180.83,98.69 180.49,98.69 180.14,99.04 180.14,99.59 180.01,99.72 178.4,99.72 178.01,99.33 178.01,98.85 177.86,98.7 176.8,98.7 176.67,98.83 176.67,99.26 177.76,100.35 177.76,100.35 177.9,100.49 v2(179.78,100.49) 180.48,100.49 180.95,100.96 180.95,101.91 181.14,102.1 181.57,102.1 181.7,101.97 181.7,101.21 181.82,101.08 182.32,101.08 182.45,101.21 182.45,102.14 182.58,102.27 182.93,102.27 183.17,102.03 183.17,101.12 183.78,100.51 183.78,99.95 184.04,99.69 185.15,99.69 185.27,99.82 185.27,101.17 185.15,101.3 VRAM3.A2
DQA1_11: length 45.7
  BOTTOM w0.102: 180.09,90.02 180.19,90.12 180.19,90.46 180.26,90.65 180.62,90.87 180.82,91.01 180.85,91.18 180.85,91.32 180.79,91.4 180.79,91.82 180.9,91.93 180.9,92.87 182.78,94.75 182.78,96.5 182.83,96.55
  BOTTOM w0.178: 182.83,96.55 182.94,96.66 182.94,98.66 182.66,98.94 182.66,99.73 182.48,99.9 181.81,99.9 181.5,99.59 181.5,98.72 180.85,98.08 180.48,98.08 179.27,99.28 178.58,99.28 178.46,99.15 178.46,96.93 177.93,96.4 177.67,96.4 177.67,96.4 177.14,96.92 177.14,97.17 177.72,97.75 177.72,97.93 177.39,98.25 177.21,98.25 176.64,97.68 176.39,97.68 176.07,97.99 v2(176.07,98.7) 176.07,99.29 177.31,100.53 177.31,100.54 177.56,100.78 177.56,102.97 177.68,103.09 178.15,103.09 178.28,102.97 178.28,101.07 178.4,100.94 178.88,100.94 179.01,101.07 179.01,102.38 179.17,102.54 179.61,102.54 179.79,102.37 179.79,101.21 179.92,101.08 180.38,101.08 180.5,101.21 180.5,102.37 180.68,102.54 183.81,102.54 183.82,102.53 184.87,102.53 185.02,102.68 VRAM3.C2 ; 180.09,90.02 180.09,89.72 180.21,89.6 180.64,89.6 181.04,89.2 GPU1.F11
DQA1_12: length 44.1
  BOTTOM w0.102: GPU1.A9 182.95,91.63 182.95,92.52 183.43,93 183.68,93 185.09,94.4 185.26,94.4 185.6,94.07 186.17,94.07 186.49,94.39 186.49,94.68 186.77,94.96 186.77,95.21 187.03,95.47
  BOTTOM w0.178: 187.03,95.47 191.75,95.47 192.38,94.85 193.48,94.85 193.69,94.63 193.69,94.16 195.63,92.23 197.94,92.23 198.25,92.54 198.25,93.95 197.99,94.21 197.99,94.59 198.25,94.85 198.25,97.66 198.77,98.18 200.17,99.57 200.17,99.83 199.82,100.18 199.82,101.2 200.17,101.55 200.17,101.81 199.81,102.18 v2(198.35,102.18) 192.83,102.18 192.69,102.32 192.38,102.32 192.14,102.09 192.14,101.72 191.66,101.24 191.66,100.33 191.54,100.2 191.13,100.2 191.03,100.31 190.25,100.31 190.12,100.43 190.12,100.79 190,100.92 189.33,100.92 189.02,101.23 VRAM3.A7
DQA1_13: length 44.5
  BOTTOM w0.102: 187.2,94.99 186.86,94.66 186.86,94.22 186.5,93.86 185.51,93.86 185.3,94.07 185.05,94.07 183.76,92.79 183.51,92.79 183.16,92.44 183.16,91.93 183.25,91.84 183.25,91.46 183.06,91.27 183.02,91.27 182.89,91.14 182.89,90.83 GPU1.C9
  BOTTOM w0.178: 187.2,94.99 190.95,94.99 191.47,94.99 192.12,94.35 192.88,94.35 195.44,91.78 198.34,91.78 198.7,92.15 198.7,94.67 198.7,97.47 198.96,97.73 200.52,99.29 200.52,99.29 200.82,99.6 200.82,100.15 200.7,100.27 200.35,100.27 200.26,100.37 200.26,101.01 200.35,101.11 200.7,101.11 200.82,101.23 200.82,101.79 199.93,102.68 v2(194.84,102.68) 193.05,102.68 192.8,102.92 192.43,102.92 192.19,102.68 192.18,102.68 191.7,102.2 191.7,101.9 191.44,101.64 191.08,101.64 191,101.72 190.52,101.72 190.47,101.67 190.33,101.53 190.11,101.53 189.88,101.76 189.88,102.04 VRAM3.B8
DQA1_14: length 46.6
  BOTTOM w0.102: 187.87,94.06 187.54,94.06 186.91,93.43 185,93.43 184.19,92.63 184.19,90.4 184.19,90.4 182.99,89.2 GPU1.F9
  BOTTOM w0.178: 187.87,94.06 187.89,94.08 191.08,94.08 191.91,93.25 192.72,93.25 195.08,90.89 198.7,90.89 199.61,91.8 199.61,97.13 200.89,98.4 201.71,99.23 201.71,102.16 v2(200.95,102.92) 200.17,103.7 199.8,103.7 191.33,103.7 190.96,104.07 189.39,104.07 VRAM3.D7
DQA1_15: length 44.6
  BOTTOM w0.102: GPU1.D8 183.51,90.19 183.2,90.19 183.06,90.32 183.06,90.48 183.25,90.66 183.25,91.01 183.44,91.39 183.45,91.4 183.45,91.92 183.36,92.02 183.36,92.35 183.6,92.59 183.87,92.59 184.91,93.63 186.56,93.63 187.32,94.39
  BOTTOM w0.178: VRAM3.C8 190.19,102.53 191.64,102.53 192.36,103.25 v2(196.47,103.25) 199.99,103.25 201.27,101.97 201.27,99.41 200.7,98.85 199.17,97.31 199.17,91.99 198.52,91.34 195.26,91.34 192.91,93.69 192.15,93.69 191.89,93.95 191.29,94.55 187.48,94.55 187.32,94.39
DQA1_16: length 39.1
  L6 w0.14: v1(191.7,92.59) 192.36,93.25 194.58,93.25 195.17,93.84 195.17,103.67 193.93,104.91 192.28,104.91 192.16,104.79 192.16,103.79 192.03,103.67 191.18,103.67 191.05,103.79 191.05,104.91 191.8,105.67 191.8,106.13 191.42,106.51 191.42,107.77 191.3,107.9 190.79,107.9 190.66,107.77 190.66,106.94 v1(189.42,105.7)
  BOTTOM w0.102: 188.68,93.23 187.85,93.23 187.28,92.94 187.16,92.82 185.34,92.82 184.94,92.42 184.94,91.94 185.05,91.82 185.05,91.4 184.99,91.34 184.99,91.22 184.88,90.36 GPU1.E7
  BOTTOM w0.178: 188.68,93.23 190.07,93.23 190.13,93.16 190.16,93.16 190.42,92.9 190.42,92.14 190.54,92.02 v2(190.75,92.02) 191.38,92.02 191.7,92.34 v1(191.7,92.59) ; VRAM3.F8 v1(189.42,105.7)
DQA1_17: length 38.9
  L6 w0.14: v1(191.07,93.27) 191.08,93.28 191.08,93.31 191.97,94.19 193.6,94.19 193.73,94.32 193.73,94.78 193.6,94.9 193.32,94.9 193.19,95.03 193.19,95.64 193.3,95.75 193.7,95.75 193.82,95.88 193.82,96.46 193.7,96.58 193.35,96.58 193.19,96.75 193.19,97.24 193.35,97.41 193.74,97.41 193.87,97.54 193.87,98.11 193.74,98.23 193.35,98.23 193.19,98.4 193.19,98.9 193.35,99.06 193.81,99.06 193.94,99.19 193.94,99.76 193.81,99.89 193.35,99.89 193.19,100.05 193.19,100.52 193.02,100.69 192.5,100.69 192.37,100.81 192.37,101.38 192.5,101.51 193.72,101.51 193.85,101.64 193.85,102.21 193.72,102.33 192.13,102.33 191.66,101.86 191.66,100.4 191.53,100.28 189.82,100.28 189.5,100.59 189.5,100.98 188.94,101.54 188.94,101.72 188.78,101.89 188.41,101.89 188.25,102.05 188.25,102.55 188.41,102.71 188.78,102.71 188.94,102.88 188.94,103.43 187.97,104.4 v1(187.55,104.4)
  BOTTOM w0.102: v1(191.07,93.27) 190.92,93.42 190.92,93.57 190.82,93.67 190.3,93.67 190.26,93.71 187.47,93.71 186.99,93.23 185.08,93.23 184.52,92.67 GPU1.A7
  BOTTOM w0.178: VRAM3.F7 189.02,105.15 188.28,104.4 v1(187.55,104.4)
DQA1_18: length 39
  L6 w0.14: v1(191.06,92.61) 191.23,92.77 191.23,92.79 192.16,93.72 193.9,93.72 194.41,94.23 194.41,98.94 194.7,99.23 194.7,100.24 194.57,100.36 194.04,100.36 193.92,100.49 193.92,101.04 194.07,101.2 194.57,101.2 194.7,101.32 194.7,102.36 194.22,102.84 193.75,102.84 193.59,103 193.59,104.2 193.42,104.36 192.93,104.36 192.76,104.2 192.76,102.84 192.63,102.71 190.86,102.71 190.73,102.58 190.73,102.3 190.61,102.18 190.03,102.18 189.9,102.3 189.9,103.17 190.03,103.3 190.38,103.3 190.5,103.43 190.5,104.28 190.38,104.41 190.03,104.41 190.02,104.41 188.5,104.41 187.81,105.09 v1(187.53,105.09)
  BOTTOM w0.102: v1(191.06,92.61) 190.57,93.09 190.57,93.15 190.25,93.47 190.1,93.47 190.06,93.51 187.56,93.51 187.07,93.03 185.23,93.03 184.73,92.53 184.73,91.85 184.85,91.74 184.85,91.5 184.52,90.98 GPU1.C7
  BOTTOM w0.178: VRAM3.H7 188.89,106.9 188.01,106.02 188.01,105.57 v1(187.53,105.09)
DQA1_19: length 38.8
  TOP w0.178: v1(184.98,89.64) 184.9,89.72 v2(184.4,89.72)
  L6 w0.14: v1(181.48,106.41) 181.47,106.41 181.35,106.28 181.35,105.3 181.47,105.18 182.1,105.18 182.22,105.05 182.22,104.48 182.1,104.35 181.46,104.35 181.34,104.23 181.34,103.67 181.46,103.55 181.83,103.55 181.96,103.42 181.96,102.87 181.83,102.75 181.47,102.75 181.35,102.62 181.35,101.48 181.47,101.35 181.77,101.35 181.9,101.22 181.9,100.13 182.03,100 183.46,100 183.58,99.87 183.58,99.39 183.46,99.26 182.66,99.26 182.53,99.13 182.53,98.74 182.83,98.43 183.66,98.43 183.78,98.31 183.78,97.81 183.66,97.69 182.66,97.69 182.66,97.68 182.5,97.68 182.38,97.56 182.38,95.71 182.59,95.51 183.24,95.51 183.37,95.38 183.37,95.05 183.54,94.89 184.35,94.89 184.48,94.77 184.48,94.36 184.35,94.24 183.67,94.24 183.54,94.11 183.28,93.85 183.28,93.73 183.3,93.71 183.3,92.63 183.31,92.62 183.31,92 183.54,91.78 183.54,91.54 183.45,91.46 183.45,91.29 183.58,91.17 184.05,91.17 184.3,90.92 184.8,90.92 184.8,90.91 185.57,90.91 185.73,90.76 185.73,90.37 185.6,90.25 184,90.25 183.76,90.49 183.39,90.49 183.26,90.36 183.26,89.49 183.39,89.37 184.86,89.37 184.98,89.49 v1(184.98,89.64)
  BOTTOM w0.178: v1(181.48,106.41) 181.53,106.46 183.78,106.46 183.79,106.47 184.65,106.47 VRAM3.G2 ; v1(184.98,89.64) 184.54,89.2 GPU1.F7
DQA1_20: length 37.5
  L6 w0.14: v1(189.97,92.72) 189.92,92.78 189.92,94.62 190.14,94.85 191.29,94.85 191.56,95.11 191.56,95.54 191.43,95.67 190.01,95.67 189.88,95.8 189.88,96.06 189.88,96.25 190.01,96.37 192.12,96.37 192.25,96.5 192.25,96.91 192.12,97.04 191.77,97.04 191.65,97.16 191.65,97.32 191.52,97.44 190.81,97.44 190.68,97.32 190.68,97.16 190.55,97.04 189.61,97.04 189.49,97.16 189.49,97.83 189.49,97.98 189.61,98.11 192.16,98.11 192.25,98.2 192.25,99.39 192.12,99.51 191.22,99.51 191.1,99.39 191.1,98.97 190.97,98.84 190.4,98.84 190.27,98.97 190.27,99.39 190.14,99.52 189.76,99.52 189.64,99.39 189.64,98.89 189.51,98.77 189.09,98.77 188.79,99.07 188.79,100.63 188.66,100.76 187.67,100.76 187.27,101.16 187.27,102.09 186.43,102.94 186.43,103.56 186.44,103.57 186.44,104.78 186.78,105.13 v1(186.9,105.13)
  BOTTOM w0.102: v1(189.97,92.72) 189.87,92.62 189.82,92.62 189.15,91.96 188.46,91.96 188.46,91.96 188.01,91.96 187.77,92.2 187.43,92.2 187.39,92.16 186.86,92.16 186.31,91.6 GPU1.A5
  BOTTOM w0.178: v1(186.9,105.13) 186.19,105.84 186.19,106.25 185.86,106.58 185.86,106.86 VRAM3.H3
DQA1_21: length 39.1
  L6 w0.14: v1(192.41,106.09) 192.41,107.08 192.87,107.55 193.81,107.55 194.59,106.78 194.59,105.81 194.59,105.07 195.62,104.03 195.62,91.87 194.59,90.83 194.59,90.09 194.59,89.32 194.47,89.2 193.91,89.2 193.79,89.33 193.79,91.52 193.91,91.64 194.29,91.64 194.42,91.77 194.42,92.5 194.29,92.63 193.66,92.63 193.66,92.63 v1(192.64,92.63)
  BOTTOM w0.102: GPU1.E5 186.55,90.43 187.05,90.43 187.33,90.7 187.33,90.91 187.59,91.17 188.05,91.17 188.26,91.37 188.51,91.37
  BOTTOM w0.178: 188.51,91.37 191.36,91.37 192.23,92.24 v2(192.23,92.24) 192.6,92.61 192.62,92.61 v1(192.64,92.63) ; VRAM3.H8 190.23,106.49 191.71,106.49 192.11,106.09 v1(192.41,106.09)
DQA1_22: length 37.2
  L6 w0.14: v1(185.39,104.1) 184.79,104.7 184.79,105.14 184.66,105.26 184.44,105.26 184.43,105.27 183.6,105.27 183.48,105.14 183.48,104.66 183.6,104.54 183.94,104.54 184.07,104.41 184.07,103.14 185.4,101.81 186.3,101.81 186.42,101.68 186.42,101.24 186.3,101.11 185.04,101.11 184.91,100.98 184.91,100.18 185.04,100.06 186.17,100.06 186.29,99.93 186.29,99.37 186,99.08 184.91,99.08 184.78,98.96 184.78,98.25 184.91,98.12 186.16,98.12 186.44,97.85 186.44,97.44 186.18,97.18 184.62,97.18 184.38,96.94 184.38,96.59 184.61,96.36 185.23,96.36 185.39,96.19 185.39,93.18 185.26,93.06 185.04,93.06 184.91,92.93 184.91,92.06 185.17,91.8 185.55,91.8 185.55,91.8 185.93,91.8 186.1,91.64 186.69,91.64 186.82,91.51 186.82,90.87 186.94,90.75 187.78,90.75 187.91,90.87 187.91,91.09 188.05,91.22 188.05,91.9 188.32,92.17 189.79,92.17 189.92,92.04 189.92,92.03 v1(189.97,91.98)
  BOTTOM w0.102: v1(189.97,91.98) 189.74,91.76 189.24,91.76 189.24,91.75 188.31,91.75 187.94,91.39 187.47,91.39 186.92,90.84 GPU1.C3
  BOTTOM w0.178: VRAM3.E3 185.79,104.5 v1(185.39,104.1)
