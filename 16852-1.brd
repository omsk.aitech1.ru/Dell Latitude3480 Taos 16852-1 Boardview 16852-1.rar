# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SML1_SMBDATA: length 303
  TOP w0.14: Q7901.3 178.67,68.65 178,67.99 177.08,67.99 176.99,67.9 176.79,67.9 v1(176.79,67.9) ; R2482.2 222.12,4.05 222.78,3.39 223.88,3.39 224.41,3.92 v1(224.66,3.92) ; v1(138.62,77.78) 142.71,77.78 144.37,79.43 RN1807.6
  L3 w0.127: v1(162.31,75.39) 162.31,74.81 162.63,74.5 164.01,74.5 165.04,75.53 167.59,75.53 168.55,76.5 170.67,76.5 171.08,76.08 171.08,72.77 172.75,71.11 175.1,71.11 176.79,69.41 v1(176.79,67.9) 176.79,67.65 176.08,66.93 172.91,66.93 172.27,67.57 170.03,67.57 168.79,66.34 168.23,66.34 167.13,65.25 167.13,62.43 166.09,61.39 166.09,60.82 165.18,59.91 165.18,56.84 166.17,55.85 170.54,55.85 171.55,54.84 181.08,54.84 183.22,52.69 195.35,52.69 199.45,48.59 200.55,48.59 201.27,47.86 v1(201.27,47.31)
  L4 w0.127: v1(138.62,77.78) 139.15,78.31 139.15,79.46 140.55,80.86 140.55,87.2 142.39,89.04 142.39,92.68 139.29,95.78 130.42,95.78 129.95,95.31 125.83,95.31 125.59,95.55 125.59,95.55 125.46,95.68 117.88,95.68 117.75,95.55 117.75,95.55 116.65,94.46 111.28,94.46 109.99,95.75 109.99,97.26 108.55,98.7 106.65,98.7 105.54,99.82 97.38,99.82 96.38,98.82 96.38,93.62 95.15,92.39 85.62,92.39 83.23,94.79 79.66,94.79 77.76,92.88 76.94,92.88 76.68,92.62 76.68,91.58 v1(75.54,90.43)
  L6 w0.114: v1(224.66,3.92) 224.73,3.92 224.94,4.13 224.94,5.76 223.33,7.36 222.83,7.36 222.06,8.13 214.33,8.13 212.2,10.25 212.2,11.19 211.44,11.95 211.44,13.99 210.41,15.02 207.47,15.02 204.92,17.57 204.92,17.88 204.72,18.07 204.72,19.66 204.74,19.68 204.74,20.74 203.48,22.01 203.48,22.77 204.22,23.51 204.22,24.5 203.8,24.92 203.8,25.8 205.44,27.45 205.44,29.11 205.6,29.27 205.6,29.93 205.69,30.03 205.69,30.66 204.67,31.68 204.67,32.46 203.7,33.42 201.99,33.42 200.15,35.27 200.15,39.75 198.46,41.44 198.46,44.51 199.97,46.02 199.97,48.02 200.15,48.19 201.14,48.19 201.55,47.79 201.55,47.58 v1(201.27,47.31)
  BOTTOM w0.089: 134.42,77.17 134.36,77.23 132.61,77.23 132.46,77.38 131.95,77.38 131.91,77.42 131.79,77.46 131.71,77.5 131.51,77.5 131.41,77.46 131.15,77.46 131.06,77.5 130.86,77.5 130.78,77.47 130.55,77.24 CPU1.V3
  BOTTOM w0.14: Q2604.1 223.44,5.85 224.37,5.85 224.74,5.47 224.74,4 v1(224.66,3.92) ; Q2601.6 74.86,90.91 75.34,90.43 v1(75.54,90.43) ; 134.42,77.17 134.49,77.09 135.42,77.09 135.47,77.05 137.4,77.05 137.73,77.38 138.23,77.38 v1(138.62,77.78) 138.93,77.78 138.93,77.77 144.73,77.77 146.12,76.38 148.88,76.38 150.24,75.02 150.77,75.02 151,74.79 152.05,73.74 155.86,73.74 156.02,73.58 157.16,73.58 157.75,74.17 160.53,74.17 ; 160.53,74.17 v2(160.53,74.38) ; 160.53,74.17 161.18,74.17 162.31,75.3 v1(162.31,75.39)
SPI0_MOSI_XDP: length 230.5
  TOP w0.114: v1(63.83,41.51) 63.83,41.17 64.12,40.88 108.97,40.88 115.95,47.86 116.92,47.86 119.86,44.92 151.61,44.92 158.21,38.32 161.17,38.32 161.21,38.36 v1(161.24,38.36) ; R9910.1 v1(58.9,101.18) 58.37,101.71 57.05,101.71 56.57,102.19 55.37,102.19 54.58,101.41 54.58,100.45 R9909.2 53.53,100.15 v2(53.21,99.83)
  L3 w0.114: v1(58.9,101.18) 59.91,100.17 59.91,99.11 59.43,98.62 59.43,98.2 59.76,97.87 59.76,94.1 59.03,93.37 59.03,92.78 59.04,92.77 59.04,89.85 59.29,89.6 59.29,88.07 59.81,87.55 59.81,86.13 59.26,85.57 59.26,84.52 57.89,83.15 57.89,82.96 57.32,82.39 57.32,81.97 57.89,81.39 57.89,78.16 57.03,77.29 57.03,68.08 57.8,67.31 57.83,67.31 58.57,66.57 58.57,63.22 56.39,61.05 56.39,58.55 57.73,57.21 57.73,55.16 58.8,54.09 58.8,50.97 57.55,49.72 v1(57.15,49.72) ; v1(135.99,65.97) 137.08,64.88 139.47,64.88 141.26,63.1 141.26,59.45 140.2,58.4 140.2,57.65 140.44,57.41 141.33,57.41 142.47,56.27 142.47,54.71 141.73,53.96 141.73,47.97 151.14,38.56 161.02,38.56 161.21,38.36 v1(161.24,38.36)
  BOTTOM w0.114: v1(57.15,49.72) 57.15,48.27 61.15,44.27 61.87,44.27 62.12,44.01 62.12,43.8 63.73,42.2 63.73,41.62 v1(63.83,41.51) ; v1(135.99,65.97) 136.08,66.06 R1826.1
SPI0_MOSI_XDP_R: length 3.8
  TOP w0.114: C9903.1 R9910.2 59,99.47 XDP1.47
SPI1_CLK_ROM_R: length 3.7
  BOTTOM w0.14: R2511.1 EC2505.1 159.07,48.37 159.19,48.25 159.66,48.25 159.79,48.37 159.79,48.88 159.92,49.01 SPI252.6
SPI1_HOLD_ROM_R: length 9.8
  BOTTOM w0.14: R2509.1 SPI252.7 163.45,50.28 164.57,51.4 164.57,53.93 ; RN2502.2 164.57,53.93 ; 164.57,53.93 164.1,53.45 163.69,53.45 v2(163.57,53.34)
SPI1_SI_ROM_R: length 9.8
  BOTTOM w0.14: EC2506.1 R2512.1 169.81,46.77 167.13,46.77 162.61,47.74 SPI252.5
SPI1_SO_ROM_R: length 3.8
  BOTTOM w0.14: SPI252.2 v2(169.95,50.28) 170.62,50.28 EC2504.1 R2513.2
SPI1_WP_ROM_R: length 9.5
  BOTTOM w0.14: RN2502.1 165.22,51.12 167.34,49.01 SPI252.3 v2(169.9,49.01) 170.68,49.01 R2514.2
SPI3_CLK_ROM: length 165.2
  L6 w0.114: v1(179.63,6.21) 187.76,6.21 190.4,8.85 197.89,8.85 198.03,8.71 198.2,8.54 199.73,8.54 203.31,4.96 203.79,4.96 203.9,5.07 210.48,5.07 v1(210.7,5.29)
  BOTTOM w0.14: v1(179.63,6.21) 178.22,6.21 176.1,8.33 137.94,8.33 136.77,7.16 133.67,7.16 129.06,2.56 104.08,2.56 100.05,6.59 R2519.2 ; v1(210.7,5.29) 211.18,5.77 211.18,7.66 211.35,7.83 211.35,15.16 207.24,19.26 207.24,22.7 207.29,22.74 207.29,31.71 205.19,33.81 205.19,35.92 207.03,37.76 207.58,37.76 208.49,38.67 208.49,39.36 209.73,40.6 v2(210.31,40.6) 210.31,40.5 210.57,40.24 213.49,40.24 214.41,39.32 214.41,39 R2459.1
SPI3_CLK_ROM_R: length 8.1
  TOP w0.14: v1(97.33,5.47) 98.63,6.77 SPI241.6 100.38,6.77 101.12,6.03 101.12,5.74 EC2508.1
  BOTTOM w0.14: v1(97.33,5.47) 97.33,5.88 v2(98.04,6.59) R2519.1
SPI3_HOLD_ROM_R: length 4.3
  TOP w0.14: R2455.1 101.66,6.09 101.04,6.72 101.04,7.45 101.4,7.81 v2(101.4,8.16) 101.27,8.29 100.03,8.29 SPI241.7
SPI3_SI_ROM: length 165.5
  L6 w0.114: v1(211.58,5.14) 210.48,4.04 210.04,4.04 209.99,3.99 209.62,3.99 209.57,4.04 206.51,4.04 206.11,3.65 205.75,3.65 205.36,4.04 203.33,4.04 199.71,7.66 198.8,7.66 198.73,7.6 198.37,7.6 197.49,8.48 190.55,8.48 187.91,5.84 187.9,5.84 187.54,5.48 v1(179.71,5.48)
  BOTTOM w0.14: R2460.1 214,39.13 213.4,39.72 v2(212.27,39.72) 211.22,39.72 209.82,38.31 208.72,38.31 207.75,37.34 207.21,37.34 205.61,35.75 205.61,33.99 207.71,31.89 207.71,22.57 207.66,22.52 207.66,19.46 208.78,18.34 209.79,18.34 210.05,18.08 210.05,17.1 212.03,15.11 212.03,9.45 212.08,9.4 212.08,7.29 211.75,6.95 211.75,5.74 211.58,5.58 v1(211.58,5.14) ; R2521.2 100.35,5.7 103.91,2.14 129.24,2.14 133.84,6.74 136.95,6.74 138.11,7.91 175.93,7.91 178.35,5.48 v1(179.71,5.48)
SPI3_SI_ROM_R: length 5.4
  TOP w0.14: v1(98.04,5.47) 98.07,5.5 SPI241.5 100.79,4.48 v2(100.79,4.25) EC2509.1
  BOTTOM w0.14: v1(98.04,5.47) 98.27,5.7 R2521.1
SPI3_SO_ROM: length 164.6
  L6 w0.114: v1(180.72,4.99) 187.63,4.99 190.75,8.11 197.18,8.11 198.12,7.17 198.87,7.17 199.26,6.79 199.26,6.47 202.44,3.28 210.61,3.28 v1(212.45,5.12)
  BOTTOM w0.14: v1(180.72,4.99) 178.26,4.99 175.76,7.49 138.29,7.49 137.06,6.26 133.95,6.26 129.41,1.72 103.74,1.72 100.64,4.81 R2522.1 ; v1(212.45,5.12) 212.45,7.06 212.5,7.12 212.5,9.57 212.45,9.62 212.45,15.29 210.47,17.27 210.47,18.25 209.96,18.76 208.96,18.76 208.08,19.64 208.08,22.35 208.13,22.4 208.13,32.11 206.03,34.21 206.03,35.57 207.38,36.92 207.93,36.92 208.9,37.89 209.99,37.89 v2(210.35,38.25) 211.4,39.3 212.88,39.3 213.11,39.08 R2457.2
SPI3_SO_ROM_R: length 9.2
  TOP w0.14: EC2507.1 93.94,8.04 SPI241.2 95.58,8.04 96.04,7.58 96.04,7.43 v1(96.16,7.3)
  BOTTOM w0.14: R2522.2 98.87,4.94 97.23,4.94 96.77,5.39 v2(96.77,6.39) 96.77,6.69 v1(96.16,7.3)
SPI3_WP_ROM_R: length 3.3
  TOP w0.14: SPI241.3 93.83,6.77 93.22,6.16 93.22,5.78 v2(93.19,5.75) 93.19,5.51 R2456.2
SPI_CLK_CPU: length 10
  BOTTOM w0.089: CPU1.AV2 131.49,66.6 131.78,66.31 132.39,66.31 132.45,66.25 132.55,66.25 132.56,66.23
  BOTTOM w0.127: 133.1,66.23 133.09,66.23 132.56,66.23
  BOTTOM w0.14: 133.1,66.23 134.87,66.23 135.31,65.79 135.53,65.79 135.8,65.52 137.21,65.52 v2(138.28,66.6) 138.98,67.29 RN1805.7
SPI_CLK_ROM: length 162.5
  TOP w0.14: v1(242.95,29.5) 242.63,29.82 R9132.1
  L3 w0.127: v1(144.27,50.91) 144.27,57.39 144.21,57.45 144.21,57.47 143.64,58.04 143.64,66.41 v1(143.51,66.53)
  L6 w0.114: v1(144.27,50.91) 144.51,50.91 145.05,51.45 148.41,51.45 148.53,51.57 148.53,52.25 148.64,52.36 148.87,52.36 148.98,52.25 148.98,51.57 149.1,51.45 149.33,51.45 149.44,51.57 149.44,52.25 149.56,52.36 149.79,52.36 149.9,52.25 149.9,51.57 150.01,51.45 150.24,51.45 150.36,51.57 150.36,52.25 150.47,52.36 150.7,52.36 150.81,52.25 150.81,51.57 150.93,51.45 151.16,51.45 151.27,51.57 151.27,52.25 151.39,52.36 151.61,52.36 151.73,52.25 151.73,51.57 151.84,51.45 152.07,51.45 152.19,51.57 152.19,52.25 152.3,52.36 152.53,52.36 152.64,52.25 152.64,51.57 152.76,51.45 154.71,51.45 155.71,50.45 v1(155.9,50.45) 156.18,50.18 158.26,50.18 159.21,51.13 166.12,51.13 167.36,49.89 168.22,49.03 170.66,49.03 174.09,45.6 190.5,45.6 195.57,50.67 210.05,50.67 211,49.72 211,49.23 212.64,47.59 212.64,46.57 217.86,41.36 217.86,40.62 217.37,40.13 v1(217.37,39.86) 217.68,39.86 217.86,40.05 225.23,40.05 225.24,40.03 225.61,40.03 225.62,40.05 226.38,40.05 228.16,38.26 228.16,36.84 231.69,33.31 238.83,33.31 239.21,32.92 241.14,32.92 241.25,32.82 241.61,32.82 241.71,32.92 242.14,32.92 242.95,32.11 v1(242.95,29.5)
  BOTTOM w0.14: v1(144.27,50.91) 144.15,50.79 144.15,50.66 143.82,50.34 143.82,49.96 145.92,47.87 147.07,47.87 147.2,47.99 RN2503.3 ; v1(143.51,66.53) 143.23,66.53 143.19,66.49 142.82,66.49 142.17,67.13 v2(141.88,67.13) 141.43,67.13 141.27,67.29 RN1805.2 ; R9151.1 243.34,29.89 v1(242.95,29.5) ; v1(217.37,39.86) 217.17,39.86 216.27,38.96 RN2401.1 ; R2511.2 158.18,49.35 157.83,49.01 157.48,49.01 157.35,49.13 157.35,50.01 157.19,50.18 156.9,50.18 156.78,50.05 156.78,48.38 156.64,48.25 156.36,48.25 156.22,48.38 156.22,50.04 155.9,50.35 v1(155.9,50.45)
SPI_CLK_ROM_R: length 14.1
  BOTTOM w0.14: RN2503.6 147.2,49.86 149.73,52.4 149.73,54.09 148.84,54.98 SKT25.6 SPI25.6 147.13,54.98 146.65,54.49 145.03,54.49 144.2,53.66 v2(144.2,53.63) EC2503.1 FC2501.1
SPI_CLK_ROM_TPM1: length 14.7
  TOP w0.14: U9101.6 250.26,34.78 249.87,35.16 v2(247.27,35.16) 246.89,35.16 v1(244.98,37.07)
  L3 w0.127: v1(244.98,37.07) 244.98,34.94 243.51,33.47 243.51,31.56 243.39,31.44 v1(243.39,31.38)
  BOTTOM w0.14: v1(243.39,31.38) 243.84,30.93 R9151.2
SPI_CLK_ROM_TPM2: length 4.5
  TOP w0.14: R9132.2 243.52,30.15 244.81,28.86 v2(244.96,28.86) 245.44,28.86 245.73,29.15 245.73,29.16 246.01,29.44 U9104.19
SPI_CS2#_R: length 170
  TOP w0.14: R9129.2 258.32,30.92 258.09,30.69 258.09,29.42 257.25,28.59 257.25,26.55 256.5,25.8 Q9104.G v1(254.78,25.8) ; 243.46,34.78 243.48,34.76 244.46,34.76 R9133.2 ; 243.46,34.78 243.44,34.76 242.49,34.76 v1(241.66,33.92) ; 243.46,34.78 v2(243.46,34.78)
  L3 w0.127: v1(243.59,28.28) 243.54,28.28 242.51,29.32 242.51,32.89 241.66,33.74 v1(241.66,33.92)
  L4 w0.127: v1(243.59,28.28) 243.59,28.28 243.74,28.43 246.58,28.43 247.71,27.3 251.33,27.3 252.83,25.8 v1(254.78,25.8) ; v1(136.73,68.49) 137.1,68.12 137.1,65.68 135.28,63.87 135.28,60.4 135.37,60.32 135.4,60.15 135.57,59.72 135.57,59.14 135.32,58.88 135.32,55.19 135.67,54.83 135.67,53.53 137.34,51.86 138.67,51.86 145.04,45.5 167.98,45.5 168.72,44.76 181.29,44.76 181.78,45.25 183.67,45.25 184.22,44.7 192.08,44.7 192.72,45.34 195.91,45.34 197.37,46.79 200.92,46.79 203.15,44.56 206.5,44.56 207.56,43.51 210.89,43.51 211.5,44.12 212.91,44.12 212.97,44.05 216.64,44.05 217.14,43.55 217.14,43.12 217.14,42.82 219.49,40.47 223.65,40.47 224.2,41.03 227.88,41.03 229.31,39.6 229.31,38.11 233.13,34.29 239.33,34.29 239.7,33.92 v1(241.66,33.92)
  BOTTOM w0.14: R9130.1 241.49,28.73 241.93,28.28 v1(243.59,28.28) 244.2,28.28 244.86,28.94 R9137.1 ; v1(136.73,68.49) 136.65,68.57 R1816.1
SPI_CS2#_R_TPM1: length 15.5
  TOP w0.14: U9101.1 254.57,32.82 v2(254.48,32.73) 254.46,32.7 v1(253.72,32.7)
  L3 w0.127: v1(253.72,32.7) 253.72,31.49 252.66,30.43 244.98,30.43 244.02,31.39 v1(244.02,31.49)
  BOTTOM w0.14: R9137.2 244.4,30.55 244.4,31.05 244.02,31.43 v1(244.02,31.49)
SPI_CS2#_R_TPM2: length 7.2
  TOP w0.14: v1(243.97,28.94) 244.53,28.38 245.77,28.38 246.32,28.94 U9104.20
  BOTTOM w0.14: v2(241.35,29.91) 242.3,29.91 R9140.2 242.32,29 R9130.2 v1(243.97,28.94)
SPI_CS_CPU_N0: length 7.1
  BOTTOM w0.14: CPU1.AU3 130.63,68.17 130.3,68.5 130.3,68.74 130.49,68.92 131.77,68.92 132.21,69.36 133.72,69.36 134.14,69.78 v2(134.16,69.78) 134.43,69.78 R1812.2
SPI_CS_CPU_N1: length 5.9
  BOTTOM w0.14: CPU1.AU2 131.44,67.29 131.83,67.68 132.08,67.68 132.15,67.75 132.34,67.75 132.34,67.75 132.69,67.75 133.63,68.69 134.52,68.69 135.31,69.48 v2(135.36,69.48) 136.16,69.48 R1828.2
SPI_CS_ROM_N0: length 122.2
  L3 w0.127: v1(155.19,60.69) 154.53,60.69 149.77,65.45 147.13,65.45 145.33,67.26 144.51,67.26 143.76,68.01 v1(143.76,68.29)
  L6 w0.114: v1(212.37,38.85) 212.37,39.32 211.4,40.29 211.4,41.32 210.74,41.98 210.74,44.01 208.61,46.14 208.01,46.14 207.76,46.39 207.76,47.22 207.32,47.65 207.32,48.05 207.06,48.3 206.63,48.3 206.51,48.42 203.82,48.42 203.67,48.27 202.99,48.27 201.7,49.55 196.02,49.55 190.96,44.49 172.63,44.49 171.82,45.3 170.39,45.3 165.72,49.97 159.61,49.97 158.71,49.07 153.99,49.07 v1(152.78,50.28)
  BOTTOM w0.14: R2490.2 214.19,34.87 212.37,36.69 v1(212.37,38.85) ; R2501.1 155.19,61.26 v1(155.19,60.69) 154.73,60.23 154.24,60.23 154.11,60.1 154.11,58.79 154.24,58.66 156.56,58.66 157.62,57.6 157.62,56.46 157.49,56.33 156.72,56.33 156.59,56.46 156.59,57.05 156.12,57.52 SPI25.1 SKT25.1 154.05,57.52 152.95,56.41 152.95,54.49 152.87,54.41 152.87,54.35 152.78,54.26 v1(152.78,50.28) ; R1812.1 136.44,70.09 137.41,70.09 137.54,70.22 138.05,70.22 138.49,69.78 138.49,69.54 138.75,69.28 139.12,69.28 139.13,69.28 v2(139.8,69.28) 141.65,69.28 141.95,68.98 143.13,68.98 143.76,68.34 143.76,68.29 v1(143.76,68.29)
SPI_CS_ROM_N1: length 45.7
  L4 w0.127: v1(169.42,50.84) 159.03,50.84 150.7,59.17 150.4,59.17 148.37,61.2 147.07,61.2 146.61,61.66 146.61,65.96 v1(144.39,68.18)
  BOTTOM w0.14: v1(144.39,68.18) 144.37,68.18 144.02,67.84 143.58,67.84 143.02,68.39 v2(142.49,68.39) 141.95,68.39 141.48,68.86 139.21,68.86 139.21,68.86 137.67,68.86 R1828.1 ; SPI252.1 169.99,51.55 R2515.1 170.03,51.45 v1(169.42,50.84)
SPI_HOLD_CPU: length 18.7
  BOTTOM w0.089: 133,67.29 132.4,67.22 132.37,67.21 132.2,67.03 131.21,67.03 131.17,67.04 130.74,67.04 130.71,67.03 130.54,67.03 130.36,67.1 CPU1.AU4
  BOTTOM w0.14: 133,67.29 133.53,67.29 133.89,67.65 134.42,67.65 134.82,68.05 136.53,68.05 136.54,68.04 137.18,68.04 137.59,68.44 139.38,68.44 139.39,68.44 141.3,68.44 141.78,67.97 142.85,67.97 143.4,67.42 144.74,67.42 R1811.2 ; R1811.2 145.28,67.49 RN1802.4 ; R1811.2 144.98,68.26 v2(145.36,68.64)
SPI_HOLD_ROM: length 27.6
  L4 w0.127: v1(156.51,50.61) 156.51,51.17 155.54,52.15 155.54,52.75 152.21,56.08 151.95,56.34 151.95,56.34 147.6,60.69 146.61,60.69 v1(146.5,60.59)
  L6 w0.114: v1(144.5,65.34) 144.5,64.69 146.5,62.69 v1(146.5,60.59)
  BOTTOM w0.14: R2509.2 157.68,50.28 157.35,50.61 156.52,50.61 v1(156.51,50.61) ; v2(147.02,63.54) 147.02,62.35 R2503.2 146.81,62.11 146.34,61.64 146.34,60.91 146.35,60.9 146.35,60.75 v1(146.5,60.59) ; v1(144.5,65.34) 144.55,65.39 144.81,65.39 145.28,65.86 145.28,66.48 R1811.1
SPI_HOLD_ROM_R: length 16.8
  BOTTOM w0.14: SPI25.7 146.81,56.25 146.56,56.5 146.56,58.91 146.43,59.04 146.43,59.45 147.08,60.09 147.08,61 R2503.1 ; v2(152.02,62.98) 152.02,62.2 RN2501.2 151.55,62.11 151.33,61.89 151.33,58.58 151.48,58.43 151.48,57.48 150.24,56.25 SKT25.7
SPI_IRQ#: length 10
  TOP w0.102: R9117.1 R9119.2 247.97,33.5 247.37,34.1 v1(247.37,34.25) ; R9135.1 244.45,30.05 v2(244.45,30.77) 244.45,30.8 244.83,31.18 v1(244.86,31.18)
  L3 w0.102: v1(247.37,34.25) 247.83,33.79 247.83,31.56 247.07,30.8 245.24,30.8 v1(244.86,31.18)
SPI_IRQ#_TPM1: length 3.7
  TOP w0.14: U9101.7 249.88,34.28 C9103.1 R9117.2 249.86,33.37 249.86,32.78 250.16,32.47 v2(250.16,32.45)
SPI_IRQ#_TPM2: length 2.8
  TOP w0.14: R9135.2 245.53,30.55 v2(245.75,30.77) 246.58,29.94 U9104.18
SPI_SI_CPU: length 10
  BOTTOM w0.089: CPU1.AV3 130.83,66.86 131.15,66.86 131.19,66.85 132.27,66.85 132.36,66.94 132.54,67.04 132.84,67.04
  BOTTOM w0.14: RN1805.8 v2(138.23,67.94) 137.81,67.94 137.43,67.56 R1824.2 136.93,67.59 R1826.2 136.08,67.59 R1825.1 134.94,67.3 133.86,67.3 133.6,67.04 132.84,67.04
SPI_SI_ROM: length 153.7
  TOP w0.14: v2(143.84,49.64) 143.84,49.72 v1(144.27,50.15)
  L3 w0.127: v1(143,66.94) 143,62.18 143.26,61.93 143.26,57.88 143.83,57.31 143.83,50.59 v1(144.27,50.15)
  L6 w0.114: v1(244.42,25.11) 243.51,26.02 240.24,26.02 236.88,29.38 234.16,29.38 233.83,29.05 233.07,29.05 231.57,30.55 231.57,32.38 227.43,36.53 227.43,37.15 225.5,39.08 218.41,39.08 217.84,38.52 216.86,38.52 v1(216.85,38.52) 216.85,39.17 216.49,39.53 216.49,40.75 216.59,40.85 216.59,41.44 215.52,42.51 215.36,42.51 215.17,42.33 215.01,42.33 214.85,42.49 214.85,42.65 215.04,42.84 215.04,43 212.93,45.1 212.22,45.1 211.33,46 211.33,46.16 211.54,46.37 211.54,46.53 211.38,46.69 211.22,46.69 211.01,46.48 210.84,46.48 210.68,46.64 210.68,46.8 210.9,47.02 210.9,47.18 210.73,47.34 210.57,47.34 210.36,47.13 210.2,47.13 208.48,48.85 208.48,49.53 208.08,49.92 195.87,49.92 190.81,44.86 172.9,44.86 171.55,46.21 v1(171.45,46.21) 169.37,48.29 167.92,48.29 167.05,49.15 167.05,49.15 165.81,50.39 159.51,50.39 158.56,49.44 154.88,49.44 153.6,50.72 152.53,50.72 150.93,49.11 146.03,49.11 144.99,50.15 v1(144.27,50.15)
  BOTTOM w0.14: v1(216.85,38.52) 216.85,38.45 216.92,38.39 RN2401.2 ; v1(244.42,25.11) 244.6,25.28 244.6,27.93 245.05,28.37 R9139.1 245.36,28.83 R9150.1 ; RN2503.4 146.49,48.39 145.74,49.14 145.74,49.42 145.47,49.69 145.25,49.69 144.79,50.15 v1(144.27,50.15) ; RN1805.1 141.21,67.94 141.6,67.55 142.39,67.55 v1(143,66.94) ; R2512.2 170.94,46.72 v1(171.45,46.21)
SPI_SI_ROM_R: length 13.6
  TOP w0.14: v1(145.86,50.76) 145.87,50.78 v2(145.87,51.5) 145.67,51.7 EC2501.1
  BOTTOM w0.14: RN2503.5 146.55,50.27 146.05,50.76 v1(145.86,50.76) 145.86,52.05 146,52.19 148.64,52.19 148.77,52.31 148.77,52.62 148.64,52.74 146,52.74 145.86,52.88 145.86,53.11 146.46,53.71 SPI25.5
SPI_SI_ROM_TPM1: length 13.2
  TOP w0.14: v1(246.63,37.07) 247.52,36.18 249.87,36.18 250.77,35.28 U9101.5
  L3 w0.127: v1(245.62,31.74) 245.69,31.81 245.69,35.11 246.63,36.05 v1(246.63,37.07)
  BOTTOM w0.14: R9150.2 245.72,30.42 245.62,30.5 v2(245.62,31.1) v1(245.62,31.74)
SPI_SI_ROM_TPM2: length 3.9
  TOP w0.14: v1(245.07,26.78) 245.07,27.35 v2(245.25,27.53) 245.77,28.05 245.84,28.05 245.86,28.07 246.05,28.07 246.42,28.44 U9104.21
  BOTTOM w0.14: R9139.2 245.36,27.46 245.07,27.16 v1(245.07,26.78)
SPI_SO_CPU: length 10.6
  BOTTOM w0.089: 132.34,65.94 132.15,66.13 131.71,66.13 131.54,66.3 131.16,66.3 130.9,66.04 CPU1.AW3
  BOTTOM w0.14: RN1805.6 139.07,66.79 v2(137.64,65.36) 137.38,65.1 136.04,65.1 135.82,64.89 134.83,64.89 133.94,65.77 133.78,65.94 132.34,65.94
SPI_SO_ROM: length 155.5
  L3 w0.127: v1(149.86,50.02) 149.56,50.32 149.56,55.47 147,58.03 147,61.61 146.24,62.37 146.24,64.64 v1(144.83,66.05)
  L6 w0.114: v1(245.21,25.21) 243.92,26.5 240.27,26.5 237.03,29.75 234.01,29.75 233.68,29.42 233.23,29.42 231.94,30.7 231.94,32.54 227.79,36.68 227.79,37.31 225.65,39.45 225.34,39.45 218.15,39.45 217.66,38.96 v1(217.31,38.96) 217.22,39.05 217.22,39.32 216.86,39.68 216.86,40.49 216.96,40.59 216.96,41.66 212.84,45.78 212.68,45.78 212.45,45.55 212.29,45.55 212.07,45.78 212.07,45.93 212.27,46.14 212.27,47.44 211.16,48.55 210.84,48.55 210.15,47.86 209.99,47.86 209.83,48.02 209.83,48.18 210.3,48.65 210.3,48.82 210.14,48.98 209.97,48.98 209.5,48.51 209.34,48.51 209.18,48.67 209.18,48.83 209.91,49.56 209.91,49.87 209.47,50.3 195.73,50.3 190.65,45.23 173.93,45.23 172.9,46.26 172.59,46.26 172.47,46.14 v1(172.47,45.96) 172.32,45.96 169.63,48.66 168.07,48.66 167.21,49.52 165.97,50.76 159.36,50.76 158.41,49.81 155.03,49.81 153.75,51.08 150.92,51.08 v1(149.86,50.02)
  BOTTOM w0.14: v1(172.47,45.96) v2(172.47,47.23) 172.47,49.13 171.93,49.67 R2513.1 ; v1(144.83,66.05) 144.71,66.05 144.38,66.37 144.01,66.37 143.7,66.07 142.64,66.07 142,66.71 141.26,66.71 141.18,66.79 RN1805.3 ; R9134.1 R9152.1 247.78,26.4 247.27,25.89 245.9,25.89 v1(245.21,25.21) ; v1(217.31,38.96) 217.31,38.93 217.42,38.82 RN2401.3 ; v1(149.86,50.02) 148.85,49.01 148.85,48.95 148.73,48.84 148.68,48.84 148.35,48.51 RN2503.1
SPI_SO_ROM_R: length 16.6
  BOTTOM w0.14: RN2503.8 148.35,49.83 149.31,50.79 150.75,50.79 152.38,49.15 153.22,49.15 153.24,49.13 154.08,49.13 154.37,49.43 EC2502.1 154.37,52.14 155.42,53.19 155.99,53.19 156.1,53.31 156.1,55.97 155.83,56.25 SPI25.2
SPI_SO_ROM_TPM1: length 21.6
  TOP w0.14: v1(258.27,34.51) 257.4,33.64 256.08,33.64 255.44,34.28 U9101.2
  L3 w0.127: v1(253.11,28.51) 253.26,28.66 253.26,29.65 254.58,30.97 254.58,33.26 255.83,34.51 v1(258.27,34.51)
  BOTTOM w0.14: R9152.2 247.78,28.81 248.72,29.76 v2(248.94,29.76) 251.86,29.76 v1(253.11,28.51)
SPI_SO_ROM_TPM2: length 4.8
  TOP w0.14: v2(244.73,25.97) 245.31,25.97 v1(245.36,26.02) 246.62,26.02 247.13,26.53 U9104.24
  BOTTOM w0.14: R9134.2 246.82,26.4 245.75,26.4 v1(245.36,26.02)
SPI_WP_CPU: length 18.9
  BOTTOM w0.127: 132.9,65.54 131.6,65.54 131.31,65.83 CPU1.AW2
  BOTTOM w0.14: 132.9,65.54 133.85,65.54 134.92,64.47 136,64.47 136.21,64.69 137.85,64.69 139.31,66.14 RN1805.5 140.41,65.53 v2(140.41,65.09) 140.48,65.02 142.21,65.02 142.34,64.89 143.76,64.89 144.09,64.56 R1827.2 144.9,64.81 144.9,64.89 145.53,65.52 145.93,65.52 146.2,65.79 146.2,66.27 146.34,66.41 RN1802.3
SPI_WP_ROM: length 57.4
  L3 w0.127: v1(144.2,65.92) 144.06,65.78 144.06,58.16 144.59,57.63 144.59,57.61 144.72,57.48 144.72,49.97 144.46,49.71 144.05,49.71 v1(143.37,50.39)
  BOTTOM w0.14: R2514.1 171.77,48.75 171.9,48.62 171.9,46.03 171.64,45.76 171.26,45.76 170.78,46.24 169.51,46.24 169.43,46.33 168.82,46.33 168.25,45.76 167.51,45.76 167.48,45.74 166.17,45.74 165.81,45.38 159.28,45.38 v2(158.02,46.64) 157.24,47.43 151.56,47.43 151.06,47.43 150.91,47.27 148.42,47.27 147.83,47.87 147.82,47.87 147.7,47.99 ; 147.7,47.99 RN2503.2 ; 147.7,47.99 147.7,47.81 147.34,47.45 145.74,47.45 143.4,49.79 143.4,50.36 v1(143.37,50.39) ; RN1805.4 141.32,66.14 141.81,65.65 143.92,65.65 v1(144.2,65.92)
SPI_WP_ROM_R: length 24.9
  BOTTOM w0.14: RN2501.1 151.93,60.15 152.22,59.86 152.22,54.29 149.13,51.2 ; SKT25.3 154.03,54.98 153.58,54.53 153.58,50.44 152.97,49.83 152.34,49.83 150.96,51.2 149.13,51.2 ; 149.13,51.2 147.78,49.85 147.78,49.45 RN2503.7
SPKR: length 264.6
  TOP w0.254: R2006.2 138.86,50.53 v1(138.81,50.48)
  L3 w0.254: v1(186.74,27.44) 186.72,27.42 181.48,27.42 180.86,26.79 154.64,26.79 146.28,18.43 146.28,16.11 143.06,12.9 143.06,12.86 142.78,12.58 117.35,12.58 115.74,14.19 114.99,14.95 113.41,14.95 113,14.53 112.88,14.51 111.37,14.51 109.32,12.46 88.94,12.46 88.66,12.18 58.56,12.18 58,11.62 42.32,11.62 41.37,10.68 v1(40.61,10.68)
  L4 w0.254: v1(184.74,43.01) 184.58,43.17 184.58,43.17 183.33,44.42 182.13,44.42 181.58,43.88 168.43,43.88 167.75,44.56 144.73,44.56 v1(138.81,50.48) 137.21,50.48 135.79,51.9 135.79,51.93 135.49,52.23 135.46,52.23 134.34,53.35 134.34,58.32 134.24,58.42 134.24,61.86 133.54,62.56 133.54,63.93 v1(132.46,65.01)
  L6 w0.254: v1(186.74,27.44) 186.74,38.87 186.66,38.94 186.66,41.08 v1(184.74,43.01)
  BOTTOM w0.089: CPU1.AW5 129.8,66.49 130.18,66.12 130.18,65.44 130.58,65.03 131.5,65.03 131.64,64.9 132.35,64.9 v1(132.46,65.01)
  BOTTOM w0.254: RN2701.2 27.49,16.8 27.69,17 29.59,17 29.84,17.26 33.15,17.26 33.91,16.5 38.88,16.5 v2(39.56,15.81) 40.61,14.76 v1(40.61,10.68)
SPV10: length 29.2
  TOP w0.254: v2(164.03,81.44) 163.86,81.62 v1(163.86,82) ; v1(183.29,87.19) 183.29,86.56 C8055.1
  L4 w0.254: v1(163.86,82) 164.9,83.04 166.88,83.04 168.64,84.8 172.26,84.8 175.6,81.46 176.25,81.46 177.13,82.35 179.96,82.35 180.24,82.63 180.24,83.35 181.27,84.38 181.27,84.49 181.7,84.92 181.97,84.92 183.29,86.24 v1(183.29,87.19)
  BOTTOM w0.254: v1(163.86,82) 163.83,81.98 C8056.1 162.89,81.86 L8003.2 ; GPU1.H8 183.69,87.6 v1(183.29,87.19)
SPV18: length 22
  TOP w0.254: v1(184.11,87.16) 184.85,87.16 185.4,86.61 185.4,86.05 186.3,85.15 188.58,85.15 189.81,86.38 190.4,86.38 190.72,86.7 v2(192.46,86.7) 193.65,86.7 195.83,88.89 196.47,88.89 v1(196.6,89.01)
  BOTTOM w0.254: v1(184.11,87.16) 184.11,87.21 184.5,87.6 GPU1.H7 ; L8002.2 201.52,91.04 C8053.1 200.6,90.12 C8054.1 197.85,90.12 196.75,89.01 v1(196.6,89.01)
SRTC_RST#: length 29.4
  TOP w0.127: RN1801.4 135.01,48.31 C1806.1 EC1806.1 v2(133.35,49.34) 133.35,49.49 v1(132.84,50)
  L4 w0.127: v1(121.5,69.45) 121.5,68.75 121.1,68.35 121.1,67.36 121.16,67.3 121.16,66.62 121.51,66.27 121.78,66.27 122.13,65.92 122.13,65.65 131.99,55.78 131.99,52.1 132.05,52.04 132.05,50.79 v1(132.84,50)
  BOTTOM w0.127: v1(121.5,69.45) 121.54,69.45 121.89,69.8 CPU1.AN18
SUS_CLK: length 121
  TOP w0.14: R2428.2 209.45,15.73 v1(209.5,15.68)
  L6 w0.114: v1(209.5,15.68) 207.6,15.68 205.48,17.8 205.48,18.11 205.43,18.16 205.43,20.76 205.85,21.18 205.85,25.29 206,25.45 206,28.88 206.16,29.04 206.16,29.7 206.25,29.79 206.25,30.94 205.97,31.23 v1(205.82,31.23)
  BOTTOM w0.14: R1813.2 122.56,51.07 122.89,50.74 123.67,50.74 124.02,50.39 124.02,50.07 125.65,48.45 128.44,48.45 150.62,26.27 173.38,26.27 180.63,33.52 183.67,33.52 185.1,34.94 186.43,34.94 186.75,34.62 199.6,34.62 200.84,33.39 203.25,33.39 v2(203.81,32.83) 204.45,32.19 204.85,32.19 v1(205.82,31.23)
SUS_CLK_WLAN_WWAN: length 336.9
  TOP w0.14: R6117.1 38.21,55.69 39.54,55.69 39.75,55.48 41.15,55.48 41.33,55.67 42.16,55.67 42.34,55.49 v1(42.7,55.49) ; v1(93.85,118.6) 93.85,118.75 93.74,118.86 92.52,118.86 91.62,119.75 91.62,121.33 91.72,121.42 92.29,121.42 R6213.2 ; v1(86.36,93.08) 86.11,92.82 86.11,88.19 83.93,86.01 83.93,80.54 83.7,80.31 83.7,78.99 80.47,75.76 v1(80.47,72.58) 80.47,72.38 80.54,72.31 80.54,70.58 80.24,70.28 79.11,70.28 77.95,69.12 77.95,58.3 v1(78.64,57.62)
  L3 w0.127: v1(86.36,93.08) 86.49,93.08 87.62,94.21 87.62,106.42 89.26,108.07 89.26,108.97 89.1,109.13 89.1,110.53 91.54,112.96 91.54,113.52 93.88,115.86 93.88,116.32 93.85,116.34 v1(93.85,118.6) ; v1(68.07,44.46) 63.22,44.46 62.38,45.3 62.38,46.09 59.36,49.11 58.9,49.11 58.88,49.08 56.85,49.08 54.49,51.45 54.02,51.45 51.92,51.45 49.78,53.58 49.72,53.58 49.65,53.64 48.87,53.64 48.68,53.83 44.35,53.83 v1(42.7,55.49)
  L4 w0.127: v1(80.47,72.58) 80.69,72.8 83.24,72.8 83.8,72.24 87.91,72.24 89.54,70.61 117.03,70.61 117.34,70.3 117.34,69.47 117.47,69.34 117.71,69.1 118.07,68.74 118.78,68.74 119.25,68.28 119.25,66.46 122.61,63.1 122.61,60.18 124.99,57.8 127.28,57.8 130.3,54.78 130.3,50.24 153.68,26.86 171.99,26.86 176.15,31.02 176.15,35.41 177.37,36.64 181.62,36.64 182.42,35.83 v1(182.42,35.31)
  BOTTOM w0.14: R1817.2 124.26,50.98 124.61,50.63 124.61,50.31 126.02,48.9 128.82,48.9 149.97,27.75 165.68,27.75 165.93,27.99 166.3,27.99 167.45,26.85 173.13,26.85 180.39,34.1 181.28,34.1 182.42,35.25 v1(182.42,35.31) ; v1(68.07,44.46) 70.07,44.46 71.26,45.65 71.62,45.65 74.99,49.01 74.99,49.38 78.21,52.6 v2(78.21,56.14) 78.21,57.06 78.64,57.5 v1(78.64,57.62)
SUS_STAT#/LPCPD#: length 28
  TOP w0.127: v1(126.62,62.4) 126.76,62.27 128.55,62.27 129.03,62.75 129.85,62.75 130.76,61.83 134.08,61.83 136.72,64.47 139.7,64.47 141.72,62.45 141.72,59.7 143.53,57.89 144.57,57.89 v2(144.58,57.89) 144.71,58.02 R1814.2
  BOTTOM w0.089: CPU1.BA11 125.55,64.48 125.55,63.17 126.28,62.44 126.58,62.44 v1(126.62,62.4)
SUSACK#: length 79.4
  TOP w0.127: KBC24.34 214.72,38.07 v2(214.93,38.29) 215.49,38.85 v1(215.54,38.85) ; R1703.1 155.79,65.39 v1(156.28,64.9)
  L4 w0.127: v1(207.9,49.48) 204.23,53.15 194.74,53.15 192.89,55 192.1,55 191.94,55.17 189.13,55.17 188.65,55.65 187.53,55.65 187.31,55.43 186.49,55.43 184.77,53.72 179.46,53.72 179.14,54.04 171.23,54.04 170.57,54.71 166.87,54.71 164.52,57.06 160.66,57.06 157.61,60.11 157.61,62.85 156.28,64.18 v1(156.28,64.9)
  L6 w0.127: v1(207.9,49.48) 208.1,49.28 208.1,48.69 212.07,44.73 212.62,44.73 214.16,43.19 214.16,40.36 214.79,39.72 215.05,39.72 215.31,39.46 215.31,39.08 v1(215.54,38.85)
SUSACK#_R: length 34.9
  TOP w0.127: v1(126.09,69.53) 126.41,69.53 126.79,69.15 127.52,69.15 127.68,68.98 128.09,68.98 128.55,69.44 129.15,69.44 130.09,68.5 130.29,68.5 131.15,67.64 133.75,67.64 135.05,68.93 137.18,68.93 137.76,68.35 143.2,68.35 143.58,68.73 143.95,68.73 144.5,68.73 145.05,69.28 150.86,69.28 151.28,68.86 151.4,68.86 152.18,68.07 152.86,68.07 R1708.2 154.39,68.7 v2(154.79,68.31) 155.27,67.83 155.27,66.59 R1703.2
  BOTTOM w0.127: CPU1.AP11 125.99,69.53 v1(126.09,69.53)
SUSCLK_NGFF_C: length 5.2
  TOP w0.14: AFTP6255.1 93.28,122.86 R6213.1 93.78,121.52 v1(94.23,121.07)
  BOTTOM w0.14: v1(94.23,121.07) 94.31,121 WWAN1.68
SUSCLK_R: length 12.9
  BOTTOM w0.089: CPU1.BA17 121.97,64.27 121.93,64.18 121.93,63.52
  BOTTOM w0.14: 121.93,63.52 121.62,63.21 121.62,62.34 121.71,62.25 121.71,61.59 v2(121.72,61.58) 121.71,61.57 121.71,61.23 122.21,60.73 122.21,55.7 122.56,55.36 R1813.1 123.32,54.15 EC1803.2 R1817.1
SUSCLK_WLAN: length 5.2
  TOP w0.14: R6117.2 37.15,55.61 v2(36.32,55.61) 35.81,55.61 v1(34.67,56.75)
  BOTTOM w0.14: WLAN1.50 34.92,56.5 v1(34.67,56.75)
SYS_PRES1#: length 5.5
  BOTTOM w0.508: R4301.2 238.63,31.61 237.49,30.47 v2(237.49,29.83) 237.49,28.69 237.9,28.28 BATT1.7
SYS_PWROK: length 161.2
  TOP w0.127: v1(209.85,27.57) 209.68,27.39 209.68,26.78 208.45,25.55 204.16,25.55 204.15,25.54 KBC24.89
  L4 w0.127: v1(132.54,90.56) 132.54,90.41 132.04,89.9 132.04,89.35 132.77,88.62 132.77,84.3 131.75,83.28 131.75,77.5 132.01,77.23 132.01,74.31 132.88,73.44 133.24,73.44 134.38,72.3 134.38,71.84 138.42,67.79 138.42,65.26 141.26,62.43 141.26,55.06 143.57,52.75 143.57,51.36 142.93,50.71 142.93,50.2 144.76,48.37 151.24,48.37 153.29,46.33 169.2,46.33 169.96,45.57 171.45,45.57 172.28,46.4 172.7,46.4 173.2,45.9 173.2,45.9 173.53,45.57 180.95,45.57 181.45,46.06 184.06,46.06 184.54,45.58 184.6,45.51 191.63,45.51 192.27,46.15 194.37,46.15 196.7,48.49 201.5,48.49 202.24,47.75 202.24,47.75 202.5,47.49 202.5,47.12 202.28,46.9 202.28,46.21 203.54,44.94 207.01,44.94 v1(207.09,44.87)
  L6 w0.127: v1(209.85,27.57) 209.85,28.74 210.57,29.45 210.57,34.38 211.26,35.08 212.56,35.08 212.81,35.33 212.81,36.79 211.04,38.56 211.04,39.76 210.77,40.03 210.77,41.06 210.11,41.72 210.11,43.7 208.81,44.99 207.21,44.99 v1(207.09,44.87)
  BOTTOM w0.127: v1(132.54,90.56) 132.11,90.99 v2(132.11,91.22) 132.21,91.32 EC1702.1 R1717.1 131.32,90.87 132,90.18 132,89.55 131.63,89.17 131.63,88.49 130,86.86 130,86.61 129.75,86.37 129.54,86.37 129.09,85.91 CPU1.B6
T_CRIT#: length 7.7
  BOTTOM w0.102: R2604.2 R2601.2 78.38,89.65 77.88,90.16 77.88,93.67 v2(77.69,93.86) 77.67,93.86 76.73,94.81 THM26.4
TESTEN: length 10.8
  BOTTOM w0.102: R7903.1 191.07,89.77 R7902.2 190.58,89.28 190.58,87.44 190.12,86.98 v2(190.12,86.92) 190.12,86.35 189.36,85.59 185.16,85.59 184.75,86 GPU1.K7
THERM_SYS_SHDN#: length 6.4
  BOTTOM w0.102: v2(79.3,88.91) 79.22,88.83 79.02,88.83 78.5,88.31 R2601.1 77.6,87.55 R2602.1 77.36,87.31 77.06,87.31 77.01,87.37 75.05,87.37 74.14,88.28 Q2602.S
THM_SML1_CLK: length 13.6
  BOTTOM w0.14: RN2602.4 76.4,89.86 76.16,90.1 Q2601.4 76.66,91.32 77.32,91.98 v2(77.32,92.42) 77.32,93.36 75.44,95.24 75.44,96.51 74.59,97.35 THM26.8 71.25,97.35 C2608.1
THM_SML1_DATA: length 11.9
  BOTTOM w0.14: RN2602.3 75.38,89.85 v2(74.6,89.85) 74.3,90.16 74.3,92.63 Q2601.1 74.86,95.81 73.97,96.7 THM26.7 71.11,96.7 C2609.1
TOPAZ_OCP: length 41
  TOP w0.254: v1(183.82,81.95) 183.93,81.95 184.44,81.44 184.92,81.44 185.42,81.95 185.42,83 185.7,83.28 185.7,84 186.11,84.41 188.79,84.41 189.05,84.16 189.05,82.95 188.64,82.54 188.64,80.57 188.44,80.38 188.44,79.74 189.23,78.95 189.23,77.01 188.04,75.82 188.04,71.55 v1(189.06,70.53)
  L3 w0.254: v1(189.06,70.53) 189.06,70.45 192.15,67.36 192.15,65.98 194.44,63.69 194.59,63.69 v1(198.63,59.65)
  BOTTOM w0.254: PR8511.1 200.15,58.79 199.9,58.53 v2(199.52,58.53) 199.47,58.53 198.63,59.37 v1(198.63,59.65) ; GPU1.T8 183.72,81.85 v1(183.82,81.95)
TOUCH_PANEL_INTR#: length 239.3
  TOP w0.127: v1(200.23,56.04) 199.9,55.71 199.9,51.16 v2(201.82,49.24) 203.52,47.54 203.52,46.66 204.21,45.97 204.58,45.97 204.84,46.23 204.84,48.06 206.08,49.3 207.45,49.3 207.71,49.04 209.37,49.04 210.33,50 210.69,50 210.95,49.74 210.95,48.23 210.46,47.73 210.46,46.37 210.81,46.02 R2429.1 211.96,45.01 D2402.A
  L3 w0.127: v1(150.62,78.09) 150.53,78.18 150.53,79.68 146.69,83.53 146.69,85.92 144.33,88.28 136.77,88.28 136.25,88.8 135.97,88.8 133.76,91.01 132.35,91.01 130.94,89.6 v1(129.7,89.6)
  L4 w0.127: v1(150.62,78.09) 150.62,75.92 149.17,74.47 149.04,74.47 148.78,74.21 148.78,73.84 149.04,73.58 149.41,73.58 150.04,74.22 151.64,74.22 151.94,73.92 152.3,73.92 154.68,76.3 157.62,76.3 166.22,67.7 168.93,67.7 170.41,66.22 172.35,66.22 172.88,65.68 176.26,65.68 178.24,63.7 178.24,63.39 178.5,63.13 178.56,63.13 180.09,61.6 180.09,58.65 180.59,58.14 181.39,58.14 181.53,58.28 182.09,58.28 182.98,57.39 183.34,57.39 185.45,59.49 194,59.49 194.82,58.67 197.6,58.67 v1(200.23,56.04) ; v1(42.42,81.14) 42.68,81.14 43.12,80.69 43.49,80.69 44.05,81.25 45.74,81.25 46.42,80.57 46.79,80.57 47.31,81.09 50.82,81.09 55.38,85.65 56.75,85.65 57.19,85.21 57.19,84.84 57.01,84.66 57.01,84.26 57.27,84 57.64,84 58.84,85.2 58.84,85.62 59.56,86.35 60.53,86.35 61.46,85.42 63.07,85.42 63.98,84.5 68.56,84.5 69.78,83.28 69.88,83.18 82.07,83.18 84.53,85.65 84.99,85.65 88.07,88.72 94.78,88.72 94.92,88.87 101.79,95.74 106.79,95.74 110.34,92.19 117.89,92.19 118.99,93.29 124.52,93.29 125.13,92.68 126.4,92.68 128.12,90.96 128.34,90.96 v1(129.7,89.6)
  BOTTOM w0.127: CPU1.A7 128.41,86.94 129.16,87.68 129.16,87.76 129.16,87.77 129.16,89.05 v1(129.7,89.6) ; v1(42.42,81.14) 42.32,81.24 42.32,83.3 42.43,83.41 43.22,83.41 43.78,83.97 43.78,85.37 43.65,85.5 RN5501.4
TOUCHPAD_INTR#: length 25.4
  BOTTOM w0.102: R410.2 141.73,51.48 R411.2 R414.2 140.08,54.15 D401.A 139.83,54.6 139.57,54.34 139.57,53.07 139.33,52.82 136.44,52.82 135.22,54.05 134.74,54.05 134.27,54.52 134.27,55.38 132.77,56.88 v2(132.77,57.14) 132.77,57.6 131.17,59.2 131.17,60.46 130.26,61.36 130.26,63.25 129.79,63.72 129.79,64.32 CPU1.BA5
TP1_AY4: length 5.8
  BOTTOM w0.102: TP610.1 131.44,60.72 130.52,61.64 130.52,64.44 130.36,64.59 130.36,64.89 CPU1.AY4
TP2_BB3: length 4.5
  BOTTOM w0.102: CPU1.BB3 130.82,64.01 133.58,61.25 TP611.1
TP4_BB5: length 4.4
  BOTTOM w0.102: CPU1.BB5 129.42,64.09 129.42,63.82 130.07,63.17 130.07,61.05 TP609.1
TP5_AU5: length 2.2
  TOP w0.102: v1(128.09,66.69) 128.24,66.53 TP607.1
  BOTTOM w0.102: v1(128.09,66.69) 128.17,66.76 128.73,66.76 129.17,67.2 CPU1.AU5
TP6_AT5: length 1.6
  TOP w0.102: TP608.1 129.46,67.63 128.91,68.18 v1(128.78,68.18)
  BOTTOM w0.102: v1(128.78,68.18) 129.11,67.85 CPU1.AT5
TP_EN#: length 55.8
  TOP w0.127: KBC24.49 208.72,37.59 207.4,38.91 207.09,38.91 206.25,39.75 v1(206.25,40.37) 205.99,40.63 205.99,42.55 205.23,43.31 205.23,44.18 206.08,45.03 206.08,45.21 206.87,46 207.05,46 207.48,46.43 RN2406.1
  L6 w0.127: v1(193.8,18.27) 195.35,19.82 195.35,24.75 194.93,25.17 194.93,27.71 195.49,28.27 195.49,31.72 195.67,31.9 195.67,35.83 193.68,37.83 v1(193.68,42.78)
  BOTTOM w0.127: v1(193.68,42.78) 193.74,42.85 194.37,42.85 194.41,42.8 198.98,42.8 200.21,44.03 v2(200.94,44.03) 201.22,44.03 201.54,44.35 203.77,44.35 204.72,43.39 204.72,42.82 204.74,42.81 204.74,42.02 206.25,40.5 v1(206.25,40.37) ; v1(193.8,18.27) 193.36,17.83 R6516.1
TP_LOCK#: length 48
  TOP w0.127: v1(138.07,6.3) 139.92,6.3 AFTP6242.1 141.77,8.15 171.03,8.15 172.27,9.39 174.27,9.39 174.67,9 179.55,9 180.4,9.85 v1(180.4,10.06) TPAD1.6
  BOTTOM w0.127: v1(138.07,6.3) 138.62,5.74 RN6501.1 ; D2405.A 180.34,10 v1(180.4,10.06)
TP_ON#_GATE: length 8.2
  BOTTOM w0.127: Q6505.G 193.58,15.96 194.25,16.63 R6516.2 C6503.1 195.14,17.97 194.72,18.39 194.72,19.59 195.52,20.39 Q6504.G 196.07,20.91 v2(196.67,21.51)
TP_PMODE_XDP_RST_R_N: length 6.1
  TOP w0.102: R9933.2 60.45,87.62 v2(60.71,87.87) 60.96,88.12 61.27,88.12 61.59,88.45 61.59,88.81 61.13,89.27 59.82,89.27 59.5,89.59 XDP1.46
TP_RESET: length 12.7
  TOP w0.102: v1(41.15,74.28) 41.02,74.41 C5540.1
  BOTTOM w0.102: v1(41.15,74.28) LCD1.38 41.15,76.16 40.82,76.49 40.82,77.39 42.05,78.62 42.23,78.62 42.33,78.73 42.33,80.17 41.48,81.03 v2(41.48,81.82) 41.62,81.96 41.62,83.78 42.14,84.3 RN5501.2
TP_RS: length 13.9
  TOP w0.102: C5541.1 41.91,74.41 v1(42.04,74.28) 41.51,73.75 v2(41.37,73.75)
  BOTTOM w0.102: v1(42.04,74.28) 41.65,74.67 LCD1.37 41.65,76.32 41.35,76.62 41.35,77.63 42.14,78.42 42.31,78.42 42.54,78.64 42.54,80.26 41.91,80.88 41.91,83.44 42.12,83.65 43.03,83.65 43.23,83.85 RN5501.1
TP_VDD: length 137.9
  TOP w0.305: RN6505.1 131.39,7.66 ; 131.28,9.24 130.35,8.31 RN6505.2
  TOP w0.381: 135.38,6.46 135,6.84 132.21,6.84 131.28,7.77 131.28,9.24 131.96,9.92 136.86,9.92 137.17,10.23 143.1,10.23 143.73,9.6 169.51,9.6 AFTP6239.1 169.54,10.72 FC9711.1 R6513.1 C6504.1 173.93,10.97 174.11,11.15 TPAD1.1 ; R6522.1 192.85,10.33 192.77,10.37 R6517.2 192.51,11.32 193.18,11.99 193.18,12.02 193.21,12.04 193.21,12.09 194.12,13 194.12,14.09 194.08,14.13 194.08,14.18 v1(193.57,14.69)
  L3 w0.381: v1(135.13,5.68) 142.9,5.68 145.86,8.64 175.07,8.64 175.37,8.34 184.3,8.34 184.6,8.64 189.17,8.64 189.51,8.98 189.51,9.97 190.14,10.59 193,10.59 194.12,11.71 194.12,14.15 v1(193.57,14.69)
  BOTTOM w0.305: RN6502.2 136.55,7.66 136.91,8.02 v1(136.91,8.27) 136.86,8.31 RN6502.1
  BOTTOM w0.381: v1(193.57,14.69) 193.4,14.69 192.77,15.32 192.77,19.25 193.45,19.92 Q6504.D
TPAN_VDD: length 14.5
  TOP w0.508: C5501.1 v1(43.69,74.52) EL5503.5 ; R5520.1 37.44,74.51 F5502.2 37.54,73.95 38.35,73.14 40.13,73.14 v1(40.26,73.01)
  BOTTOM w0.305: LCD1.40 40.15,74.28
  BOTTOM w0.508: v1(43.69,74.52) 43.69,74.03 42.55,72.88 v2(41.4,72.88) 40.39,72.88 v1(40.26,73.01) 40.15,73.12 40.15,74.28
TPAN_VDD_F:
  vias: v2(40.01,76.29)
TPCLK_C: length 55.2
  TOP w0.14: 140.84,5.33 139.94,5.33 139.45,5.83 138.56,5.83 138.05,5.32 138.05,4.5 137.86,4.31 137.59,4.31 137.4,4.5 RN6503.4 ; 140.84,5.33 AFTP6238.1 ; 140.84,5.33 141.37,5.33 143.77,7.74 172.13,7.74 172.27,7.6 173.99,7.6 175.64,5.95 177.8,5.95 179.07,7.22 182.12,10.27 183.08,10.27 183.18,10.37 183.18,11.72 182.58,12.33 182.32,12.33 182.02,12.02 182.02,11.94 182.4,11.55 TPAD1.8
TPDATA_C: length 56.5
  TOP w0.14: TPAD1.7 181.4,11.59 181.75,11.94 181.75,12.14 182.21,12.6 182.69,12.6 183.45,11.83 183.45,10.26 183.19,10.01 182.23,10.01 179.18,6.96 177.91,5.69 175.53,5.69 173.88,7.34 172.16,7.34 172.02,7.47 143.88,7.47 141.48,5.07 139.83,5.07 139.34,5.56 138.94,5.56 ; 138.94,5.56 AFTP6236.1 ; 138.94,5.56 138.67,5.56 138.32,5.2 138.32,4.39 137.97,4.04 137.59,4.04 137.4,3.85 RN6503.3
TPM_GPIO0: length 2.5
  TOP w0.127: v2(249.93,24.44) 249.93,24.44 v1(249.93,25.23) U9104.29
  BOTTOM w0.127: v1(249.93,25.23) 250.01,25.15 R9141.1
TPM_GPIO2: length 225.8
  TOP w0.127: Q9104.D 254.03,26.95 ; 254.03,26.95 254.03,30.3 Q9102.D ; 254.03,26.95 253.72,27.25 253.72,27.34 v1(253.52,27.54) 253.12,27.94 U9104.3
  L3 w0.127: v1(253.52,27.54) 253.48,27.51 247.64,27.51 245.66,25.52 245.66,25.02 245.36,24.73 245.36,22.15 245.37,22.13 245.37,21.87 245.36,21.85 245.36,21.13 243.8,19.57 243.8,18.64 241.72,16.56 241.72,16.32 241.46,16.06 241.03,16.06 241.02,16.07 238.97,16.07 234.23,11.32 234.23,10.55 233.61,9.93 232.9,9.93 230.45,12.38 228.65,12.38 226.07,14.96 218.85,14.96 218.84,14.95 216.41,14.95 215.54,15.81 215.54,18.21 215.41,18.34 214.85,18.34 214.76,18.42 214.4,18.42 214.31,18.34 207.63,18.34 207.09,17.79 204.14,17.79 203.84,18.1 202.69,18.1 202.49,17.89 v1(202.36,17.89)
  L4 w0.127: v1(202.36,17.89) 202.36,18.22 201.8,18.78 195.11,18.78 194.15,17.83 191.02,17.83 190.02,18.83 186.48,18.83 182.58,14.93 182.58,14.01 180.29,11.72 179.95,11.72 178.94,10.71 128.48,10.71 128.45,10.74 123.45,10.74 122.85,10.15 120.39,10.15 119.34,11.2 118.97,11.2 118.71,10.94 118.71,10.92 117.31,9.52 115.38,9.52 115.05,9.19 112.58,9.19 112.33,9.45 110.74,9.45 109.62,10.56 91.91,10.56 91.78,10.43 91.78,10.01 89.57,7.8 86.18,7.8 85.67,8.3 76.35,8.3 75.42,9.23 v1(74.4,9.23)
  BOTTOM w0.127: R9142.1 248.34,26.13 248.34,28.76 248.93,29.35 251.16,29.35 v2(252.72,27.78) 252.96,27.54 v1(253.52,27.54) 253.94,27.96 R9120.1 ; R9131.1 R9138.2 71.85,8.92 72.16,9.23 v1(74.4,9.23)
TPM_GPIO4: length 5.7
  TOP w0.127: R9133.1 245.85,34.26 245.85,33.49 v2(246,33.34) 246.56,32.78 248.41,32.78 249.43,31.76 U9104.13
TPM_VDD14: length 7.6
  TOP w0.305: U9104.14 248.93,31.74 248.3,32.37 246.28,32.37 246.18,32.27 v2(245.39,32.27) 244.82,32.27 v1(244.79,32.24) 244.78,32.26 244.78,33.16 244.17,33.77 C9115.2
  BOTTOM w0.508: v1(244.79,32.24) 244.92,32.37 R9147.2
TPM_VDD22: length 4.5
  TOP w0.305: U9104.22 246.47,27.94 246.2,27.67 246.1,27.67 v1(246.05,27.62)
  BOTTOM w0.508: v1(246.05,27.62) 246.76,28.33 v2(246.76,28.69) 246.57,28.88 R9149.2 C9116.2
TPM_VSB: length 3.1
  TOP w0.305: v1(253.31,26.3) 252.68,26.94 U9104.1
  BOTTOM w0.508: v2(254.02,26.3) 254.02,26.3 v1(253.31,26.3) 253.31,26.5 253.1,26.72 R9144.2
TS#_DIMM0_1: length 2.9
  TOP w0.127: R1215.2 77.98,10.02 v1(77.97,10.02) 77.97,9.77 v2(78.36,9.38)
  BOTTOM w0.127: DM1.134 v1(77.97,10.02)
TS#_DIMM1_1: length 3.1
  TOP w0.127: R1312.2 155.03,13.03 v1(154.98,12.98) 155.53,12.98 v2(155.67,12.84)
  BOTTOM w0.127: DM2.134 v1(154.98,12.98)
U4101_OUT:
  vias: v2(149.73,49.13)
UART0_CTS#: length 6.7
  BOTTOM w0.089: 134.45,77.41 132.69,77.41 132.54,77.56 132.02,77.56 132.01,77.57 131.74,77.67 131.47,77.67 131.38,77.64 131.18,77.64 131.09,77.67 130.82,77.67 130.73,77.64 130.24,77.64 CPU1.U4
  BOTTOM w0.114: TP2014.1 136.35,77.5 134.54,77.5 134.45,77.41
UART0_RTS#: length 6.6
  BOTTOM w0.089: 132.78,78.09 132.41,78.09 132.35,78.15 132.19,78.3 132.11,78.34 131.8,78.34 131.71,78.3 131.25,78.3 130.85,77.9 CPU1.U3
  BOTTOM w0.114: 132.78,78.09 132.85,78.02 133.86,78.02 134.12,78.28 134.64,78.28 135.03,78.67 TP2013.1
UART0_TXD: length 4.4
  BOTTOM w0.089: 134.81,78.09 134.22,78.09 133.95,77.83 132.77,77.83 132.7,77.89 132.68,77.91 132.33,77.91 132.12,78.13 132.03,78.16 131.83,78.16 131.74,78.12 131.51,78.12 CPU1.U2
  BOTTOM w0.114: TP2012.1 134.99,78.27 134.81,78.09
UART1_CTS#: length 4.2
  TOP w0.114: v1(133.25,75.82) 133.22,75.79 133.22,75.65 TP2017.1
  BOTTOM w0.089: 132.21,75.51 130.24,75.51 CPU1.AB4
  BOTTOM w0.114: 132.21,75.51 132.3,75.42 132.78,75.42 133.16,75.8 133.17,75.8 133.19,75.82 v1(133.25,75.82)
UART1_RTS#: length 5.5
  BOTTOM w0.089: CPU1.AC3 130.71,74.18 131.38,74.18 131.47,74.15 131.74,74.15 131.83,74.18 132.03,74.18 132.07,74.17 132.41,74.13
  BOTTOM w0.114: 132.41,74.13 132.72,74.44 133.68,74.44 133.69,74.45 134.26,74.45 134.93,73.77 TP2016.1
UART1_RXD: length 5.8
  BOTTOM w0.114: TP2015.1 137.05,74.52 134.75,74.52 134.42,74.85 133.03,74.85 133.02,74.83 132.56,74.83 132.31,74.58 CPU1.AC1
UIM_CLK: length 29.8
  TOP w0.14: v1(79.91,123.43) 79.91,123.28 80.7,122.48 SIM1.3 ; R6223.2 90.54,111.67 88.26,111.67 84.71,108.12 84.71,108 C6306.2 83.88,107.94 EC6304.1 83.69,107.74 82.31,107.74 ; 82.31,107.74 82.91,108.34 82.91,110.5 AFTP6313.1 82.55,111.11 v1(82.8,111.36) ; 82.31,107.74 ED6301.3
  BOTTOM w0.14: v1(82.8,111.36) 81.13,113.04 81.13,122.32 80.02,123.43 v1(79.91,123.43)
UIM_CLK_C: length 1.9
  TOP w0.14: v2(86.11,108.95) 86.33,108.72 R6301.2 85.6,108 C6306.1
UIM_CLK_R: length 6.2
  TOP w0.14: v1(92.52,111.02) 92.61,111.11 92.61,111.64 v2(92.53,111.72) 92.38,111.87 R6223.1
  BOTTOM w0.14: WWAN1.32 94.84,112 93.87,111.02 v1(92.52,111.02)
UIM_DATA: length 33.9
  TOP w0.14: v1(81.03,111.11) 80.77,110.86 AFTP6309.1 80.39,110.41 EC6305.1 79.25,107.92 ED6301.4 79.57,107.74 80.14,108.32 v1(80.14,109.33) ; R6206.2 90.45,112.68 v1(89.97,112.2) ; SIM1.7 79.61,122.72 v1(78.92,123.4)
  BOTTOM w0.14: v1(89.97,112.2) 87.68,112.2 84.2,108.72 80.75,108.72 v1(80.14,109.33) ; v1(78.92,123.4) 78.92,113.98 81.03,111.87 v1(81.03,111.11)
UIM_DATA_R: length 6.5
  TOP w0.14: v1(93.24,111.67) 93.29,111.72 v2(93.29,112.71) 91.66,112.71 R6206.1
  BOTTOM w0.14: WWAN1.34 94.07,112.5 v1(93.24,111.67)
UIM_DET: length 27.9
  TOP w0.127: R6304.2 77.72,107.17 78.36,107.81 v2(78.36,109.66) 78.36,110.35 79.76,111.75 80.26,111.75 v1(80.39,111.62)
  L4 w0.127: v1(80.39,111.62) 80.61,111.83 85.56,111.83 v1(85.6,111.87)
  BOTTOM w0.127: WWAN1.66 94.35,120.5 92.52,118.67 92.42,118.67 91.88,118.13 91.88,116.38 90.95,115.44 89.22,115.44 85.65,111.87 v1(85.6,111.87)
UIM_DET#: length 7.3
  TOP w0.127: SIM1.DSW2 76.18,111.13 AFTP6312.1 76.77,110.54 R6227.2 76.64,107.81 76.58,107.81 75.95,107.17 R6305.1
UIM_DET#_G: length 3.1
  TOP w0.127: v2(73.91,103.77) 74.11,103.97 Q6301.G 75.12,104.19 75.56,104.63 75.56,105.08 R6305.2
UIM_DET_D: length 5.8
  TOP w0.127: R6304.1 R6303.1 77.03,105.27 Q6301.D 77.03,102.61 v2(78.44,101.2)
UIM_PWR: length 42.7
  TOP w0.508: AFTP6310.1 84.45,111.39 v1(84.33,111.39) ; ED6301.5 80.26,106.79 v1(80.77,107.3) 80.9,107.43 80.9,108.51 EC6302.1 81.72,109.33 v1(82.37,109.33) ; SIM1.1 85.1,121.88 85.98,122.76 v1(85.98,123.44)
  L3 w0.508: v1(82.37,109.33) 82.37,109.57 84.19,111.39 v1(84.33,111.39)
  BOTTOM w0.305: 93.74,113.23 95.57,113.23 95.8,113 WWAN1.36
  BOTTOM w0.508: v1(85.98,123.44) 85.98,114.51 84.33,112.86 v1(84.33,111.39) ; v1(80.77,107.3) 81.53,106.54 83.44,106.54 83.69,106.79 87.71,106.79 89.76,108.85 90.07,108.85 91.53,110.31 91.53,111.02 93.74,113.23
UIM_RESET: length 34.9
  TOP w0.127: AFTP6315.1 83.82,109.86 v1(83.69,109.99) ; v1(84.48,123.43) 84.45,123.43 83.57,122.54 83.44,122.54 82.91,122.01 SIM1.2 ; v1(84.48,106.11) 84.43,106.06 84.23,106.06 83.63,105.46 EC6301.1 83.19,105.84 ED6301.1 82.12,104.66 v1(82.06,104.61) ; v1(88.09,109.97) 88.09,110.69 R6228.2
  L3 w0.127: v1(88.09,109.97) 87.63,110.42 86.89,110.42 85.09,108.62 85.09,106.72 v1(84.48,106.11) ; v1(82.06,104.61) 82.06,105.29 83.69,106.92 v1(83.69,109.99)
  BOTTOM w0.127: v1(84.48,123.43) 84.48,116.04 83.19,114.74 83.19,111.9 83.69,111.39 v1(83.69,109.99)
UIM_RESET_R: length 8.3
  TOP w0.127: R6228.1 89.17,110.88 v2(89.94,110.88) 91.95,110.88 92.43,110.4 v1(93.12,110.4)
  BOTTOM w0.127: WWAN1.30 95.51,111.5 94.41,110.4 v1(93.12,110.4)
UIM_RFU: length 6.4
  TOP w0.305: v2(93.01,109.84) 92.48,109.84 v1(92.4,109.76)
  TOP w0.508: R6219.1 91.92,110.25 92.28,109.89 92.28,109.89 v1(92.4,109.76)
  BOTTOM w0.305: WWAN1.28 95.8,111 94.54,109.74 92.43,109.74 92.41,109.76 v1(92.4,109.76)
UIM_VPP: length 54.1
  TOP w0.508: SIM1.6 81.81,122.38 82.22,122.79 v1(82.22,123.35) ; R6219.2 v1(89.94,110.25) ; v1(91.44,123.81) 91.44,124.19 AFTP6317.1 ; EC6303.1 80.39,104.44 80.39,106.03 v1(80.52,106.16) 80.26,106.16 79.95,105.84 ED6301.6 78.93,105.84 78.49,106.28 v1(78.49,107.05)
  BOTTOM w0.508: v1(80.52,106.16) 79.88,106.79 79.88,107.55 80.52,108.19 84.53,108.19 87.12,110.78 88.47,110.78 89,110.25 v1(89.94,110.25) ; v1(78.49,107.05) 78.11,107.05 77.22,107.94 77.22,108.57 76.71,109.08 76.71,110.09 77.85,111.24 77.85,123.23 78.79,124.17 81.4,124.17 v1(82.22,123.35) 83.29,124.42 88.6,124.42 89.2,123.81 v1(91.44,123.81)
USB2_ID: length 22.1
  L3 w0.127: v1(129.68,71.77) 130.05,71.41 130.05,70.71 132.32,68.44 132.68,68.44 134.25,66.87 134.25,64.1 v1(134.13,63.98)
  BOTTOM w0.089: v1(129.68,71.77) 129.68,71.84 130.14,72.29 130.33,72.29 CPU1.AG3
  BOTTOM w0.127: R1601.1 143.51,63.64 142.67,64.48 142.17,64.48 142.03,64.61 139.64,64.61 139.55,64.7 v2(139.09,64.7) 138.63,64.7 138.19,64.26 136.54,64.26 135.72,63.45 134.66,63.45 v1(134.13,63.98)
USB2_VBUSSENSE: length 22.7
  L3 w0.127: v1(129.54,72.86) 130.82,72.86 134.75,68.94 134.75,63.85 v1(134.13,63.23)
  BOTTOM w0.127: R1602.1 142.62,63.5 v2(141.88,64.24) 141.65,64.01 137.03,64.01 136.22,63.19 134.17,63.19 v1(134.13,63.23) ; v1(129.54,72.86) 129.81,72.6 CPU1.AG4
USB3_PRX_CTX_N1_C: length 11.4
  BOTTOM w0.127: USB1.5 12.87,46.85 13,46.98 13.43,46.98 14.18,47.74 14.86,47.74 16.21,49.08 16.21,49.77 ; 16.21,49.77 16.21,50.15 16.03,50.33 16.03,50.72 16.23,50.92 16.36,50.92 16.48,50.8 ED3601.1 ED3601.10 18.63,50.8 18.69,50.86 19.67,50.86 R3608.2 ; 16.21,49.77 v2(16.41,49.77)
USB3_PRX_CTX_N3_C: length 13.2
  BOTTOM w0.127: 16.99,23.34 17.46,23.34 17.55,23.25 17.56,23.24 ED3603.1 ED3603.10 19.18,23.26 20.03,23.26 20.29,23 20.87,23 R3612.2 ; 16.99,23.34 16.65,23.34 16.07,23.92 16.07,24.88 15.28,25.67 15.28,27.13 14.68,27.73 14.24,27.73 13.49,26.98 13,26.98 12.87,26.85 USB2.5 ; 16.99,23.34 v2(16.99,23.18)
USB3_PRX_CTX_P1_C: length 11.1
  BOTTOM w0.127: R3607.2 19.94,51.1 18.75,51.1 18.57,51.28 ED3601.9 ED3601.2 16.48,51.28 16.36,51.16 16.13,51.16 15.79,50.82 15.79,50.23 15.96,50.05 15.96,49.18 14.76,47.98 14.08,47.98 13.33,47.22 13,47.22 12.87,47.35 USB1.6
USB3_PRX_CTX_P3_C: length 13.3
  BOTTOM w0.127: v2(16.48,24.6) 16.31,24.6 ; 16.31,24.6 16.31,24.02 16.75,23.58 17.45,23.58 17.59,23.72 ED3603.2 ED3603.9 19.52,23.72 19.74,23.51 20.13,23.51 20.39,23.24 20.9,23.24 R3611.2 ; 16.31,24.6 16.31,24.98 15.52,25.77 15.52,27.23 14.78,27.97 14.14,27.97 13.39,27.22 13,27.22 12.87,27.35 USB2.6
USB3_PTX_CRX_N1_C: length 8.6
  BOTTOM w0.127: USB1.8 12.87,52.85 13,52.98 13.44,52.98 14,52.42 16.26,52.42 16.36,52.32 ED3601.4 ED3601.7 18.74,52.32 18.98,52.56 19.33,52.56 19.51,52.74 19.82,52.74 R3606.2
USB3_PTX_CRX_N1_R: length 2.8
  BOTTOM w0.127: R3606.1 21.41,52.82 21.84,52.82 22.01,52.65 22.01,52.27 22.33,51.95 22.77,51.95 C3601.2
USB3_PTX_CRX_N3_C: length 15.9
  BOTTOM w0.127: v2(16.48,26.22) 16.68,26.22 ; 16.68,26.22 16.68,28.93 15.37,30.24 15.37,31.61 14.72,32.26 14,32.26 13.27,32.98 13,32.98 12.87,32.85 USB2.8 ; 16.68,26.22 16.68,25.47 17.28,24.87 17.71,24.87 17.82,24.76 ED3603.4 ED3603.7 19.79,24.76 20.17,25.15 21,25.15 R3610.2
USB3_PTX_CRX_N3_R: length 1.8
  BOTTOM w0.127: R3610.1 22.56,25.28 23.41,25.28 C3604.2
USB3_PTX_CRX_P1_C: length 8.6
  BOTTOM w0.127: R3605.2 19.81,53.13 19.55,53.13 19.21,52.8 ED3601.6 ED3601.5 16.42,52.8 16.28,52.66 14.1,52.66 13.54,53.22 13,53.22 12.87,53.35 USB1.9
USB3_PTX_CRX_P1_R: length 3.1
  BOTTOM w0.127: R3605.1 21.41,53.06 21.94,53.06 22.01,52.99 ; 22.01,52.99 22.25,52.75 22.25,52.37 22.43,52.19 22.58,52.19 C3602.2 ; 22.01,52.99 v2(22.15,53.12)
USB3_PTX_CRX_P3_C: length 15.9
  BOTTOM w0.127: USB2.9 12.87,33.35 13,33.22 13.37,33.22 14.1,32.5 14.82,32.5 15.61,31.71 15.61,30.34 16.92,29.03 16.92,28.69 ; R3609.2 20.79,25.41 20.09,25.41 19.92,25.24 ED3603.6 ED3603.5 17.84,25.24 17.71,25.12 17.38,25.12 16.92,25.57 16.92,28.69 ; v2(17.07,28.69) 16.92,28.69
USB3_PTX_CRX_P3_R: length 1.8
  BOTTOM w0.127: R3609.1 22.54,25.52 23.31,25.52 C3605.2
USB3_RXN3_R: length 4.2
  TOP w0.127: v2(101.85,110.07) 101.85,110.6 v1(101.73,110.73) R6226.2
  BOTTOM w0.127: v1(101.73,110.73) 102.05,111.05 102.56,111.05 102.89,111.38 103.12,111.38 103.25,111.25 WWAN1.29
