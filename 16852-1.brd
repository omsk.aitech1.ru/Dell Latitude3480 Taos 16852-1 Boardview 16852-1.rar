# Allegro board 16852-1.brd (continued)
## Nets (continued)
PWR_1D35V_FB_A: PC8662.1 PG8653.1 PR8675.1
PWR_1D35V_ILMT: PR8671.1 PR8677.1 PU8651.13
PWR_1D35V_PG: PR8673.2 PU8651.9 PU8651.10
PWR_1D35V_PH: PC8656.2 PL8651.1 PU8651.6 PU8651.19 PU8651.20
PWR_1D35V_VCC: PC8654.1 PR8677.2 PU8651.16 PU8651.17
PWR_2D5V: PC5402.1 PC5404.1 PC5405.2 PG5404.1 PG5405.1 PR5403.1 PU5402.6
PWR_2D5V_FB: PC5405.1 PR5403.2 PR5404.1 PU5402.7
PWR_2D5V_PG: PG5112.1 PR5114.1 PR5415.2 PU5402.1
PWR_3D3V: PC4504.1 PG4501.2 PG4502.2 PG4503.2 PG4506.1 PG4522.2 PG4526.2 PL4501.1 PT4501.1
PWR_3D3V_BOOT: PR4503.2 PU4501.9
PWR_3D3V_BOOT_A: PC4503.2 PR4503.1
PWR_3D3V_CS: PR4505.1 PU4501.5
PWR_3D3V_EN: PC4505.1 PR4502.2 PU4501.6
PWR_3D3V_FB: PC4506.2 PR4516.2 PR4517.1 PU4501.4
PWR_3D3V_FB_A: PC4506.1 PR4506.2
PWR_3D3V_FB_B: PG4506.2 PR4506.1 PR4516.1
PWR_3D3V_HG: PU4501.10 PU4502.4
PWR_3D3V_LG: PU4501.11 PU4503.4
PWR_3D3V_PH: PC4503.1 PL4501.2 PU4501.8 PU4502.1 PU4502.2 PU4502.3 PU4503.5 PU4503.6 PU4503.7 PU4503.8
PWR_3D3V_VREG: PC4510.1 PG4507.2 PU4501.3
PWR_5V: PC4516.1 PG4509.1 PG4516.1 PG4517.1 PG4518.1 PG4519.1 PG4520.1 PG4521.1 PG4523.1 PL4502.2 PT4502.1
PWR_5V_BOOT: PR4509.1 PU4501.17
PWR_5V_BOOT_A: PC4509.1 PR4509.2
PWR_5V_CS: PR4510.1 PU4501.1
PWR_5V_EN: PC4508.1 PR4507.1 PU4501.20
PWR_5V_FB: PC4517.2 PR4514.2 PR4515.1 PU4501.2
PWR_5V_FB_A: PC4517.1 PR4512.2
PWR_5V_HG: PU4501.16 PU4504.4
PWR_5V_LG: PU4501.15 PU4505.4
PWR_5V_PH: PC4509.2 PL4502.1 PU4501.18 PU4504.1 PU4504.2 PU4504.3 PU4505.5 PU4505.6 PU4505.7 PU4505.8
PWR_5V_VO: PG4509.2 PR4512.1 PR4514.1 PU4501.14
PWR_CHG_1: PD4402.K PD4405.K PR4407.1
PWR_CHG_ACDET: PC4413.1 PR4408.2 PR4409.1 PU4401.6
PWR_CHG_ACN: PC4402.1 PC4404.2 PG4403.2 PR4404.1 PU4401.1
PWR_CHG_ACOK: D1703.K PR4416.2 PR4432.1 PR4435.2 PR4463.2 PU4401.5 R2469.1
PWR_CHG_ACP: PC4402.2 PC4403.2 PG4402.2 PR4404.2 PU4401.2
PWR_CHG_BATPRES#: PG4416.2 PU4401.15
PWR_CHG_BATSRC: PR4414.1 PU4401.17
PWR_CHG_BTST: PC4414.1 PU4401.25
PWR_CHG_CMPIN: PR4421.2 PR4424.1 PU4401.13
PWR_CHG_CMPOUT: PU4401.14 TP4404.1
PWR_CHG_CMSRC: PR4410.2 PU4401.3
PWR_CHG_HIDRV: PU4401.26 PU4404.4
PWR_CHG_IADP: PG4401.1 PU4401.7
PWR_CHG_IDCHG: PG4414.1 PU4401.8
PWR_CHG_ILIM: PR4420.2 PR4423.1 PU4401.21
PWR_CHG_LODRV: PU4401.23 PU4405.4
PWR_CHG_PHASE: PC4414.2 PL4401.1 PU4401.27 PU4404.1 PU4404.2 PU4404.3 PU4405.5 PU4405.6 PU4405.7 PU4405.8
PWR_CHG_PHASE_1: PG4412.2 PL4401.2 PR4415.1 PU4403.5 PU4403.6 PU4403.7 PU4403.8
PWR_CHG_PMON: PG4415.1 PU4401.9
PWR_CHG_PROCHOT#: PR4418.2 PU4401.10
PWR_CHG_REGN: PC4401.2 PR4435.1 PU4401.24
PWR_CHG_SCL: PG4410.1 PU4401.12
PWR_CHG_SDA: PG4409.1 PU4401.11
PWR_CHG_SRN: PR4419.1 PU4401.19
PWR_CHG_SRN_1: PC4420.2 PC4422.1 PG4413.1 PR4419.2
PWR_CHG_SRP: PR4417.1 PU4401.20
PWR_CHG_SRP_1: PC4420.1 PC4421.1 PG4412.1 PR4417.2
PWR_CHG_STAT#: PU4401.16 TP4405.1
PWR_CHG_VCC: PC4412.2 PR4407.2 PU4401.28
PWR_DCBATOUT_1D0V: PC5307.1 PC5308.1 PC5309.1 PG5307.2 PG5308.2 PG5309.2 PR5301.2 PU5301.7 PU5301.8 PU5301.9
PWR_DCBATOUT_1D35V: PC8651.1 PC8652.1 PC8653.1 PG8651.2 PG8652.2 PU8651.2 PU8651.3 PU8651.4 PU8651.5
PWR_DCBATOUT_3D3V: PC4501.1 PC4502.1 PC4515.1 PG4504.2 PG4505.2 PU4502.5 PU4502.6 PU4502.7 PU4502.8
PWR_DCBATOUT_5V: PC4512.1 PC4513.1 PC4514.1 PG4510.2 PG4511.2 PG4512.2 PU4504.5 PU4504.6 PU4504.7 PU4504.8
PWR_DCBATOUT_VDDQ: PC5111.1 PC5115.1 PC5116.1 PG5105.2 PG5110.2 PU5101.2 PU5101.3 PU5101.4 PU5101.5
PWR_DCBATOUT_VGA_CORE1: EC8536.2 PC8526.1 PC8527.1 PC8528.1 PC8529.1 PC8530.2 PG8511.2 PG8512.2 PG8513.2 PG8514.2 PG8515.2 PG8516.2 PU8502.2 PU8502.3 PU8502.4 PU8502.10 PU8503.2 PU8503.3 PU8503.4 PU8503.10
PWR_DCBATOUT_VGA_CORE2: EC8537.2 PC8519.1 PC8520.1 PC8521.2 PC8551.1 PC8552.1 PG8501.2 PG8502.2 PG8503.2 PG8504.2 PG8505.2 PG8506.2 PU8504.2 PU8504.3 PU8504.4 PU8504.10 PU8505.2 PU8505.3 PU8505.4 PU8505.10
PWR_LED: EC6406.1 Q6405.C R6409.1
PWR_LED#: KBC24.70 Q2418.4 RN2405.4(A)
PWR_LED#_B: Q6405.B Q6407.D
PWR_LED#_R: AFTP6105.1 EC6404.1 PWR1.3 R6409.2
PWR_LED#_S: Q2418.3 Q6407.S
PWR_VCCGT_BOOTA: PR4802.1 PU4801.35
PWR_VCCGT_BOOTA_RC: PC4809.1 PR4802.2
PWR_VCCGT_COMP: PC4617.2 PC4618.2 PU4601.4
PWR_VCCGT_COMP_R: PC4618.1 PR4631.2
PWR_VCCGT_CSCOMP: PC4620.1 PC4621.1 PR4634.2 PR4639.2 PR4640.1 PU4601.6
PWR_VCCGT_CSNA: PG4809.1 PR4646.2
PWR_VCCGT_CSP1: PC4623.2 PR4651.2 PU4601.10
PWR_VCCGT_CSP2: PR4603.2 PU4601.9
PWR_VCCGT_CSPA: PG4808.1 PR4637.1 PR4651.1
PWR_VCCGT_CSREF: PC4623.1 PC4626.1 PR4646.1 PU4601.8
PWR_VCCGT_CSSUM: PC4620.2 PC4621.2 PR4637.2 PR4638.2 PU4601.7
PWR_VCCGT_DIFFOUT: PR4625.1 PR4626.1 PU4601.2
PWR_VCCGT_DISB#_A: PR4808.2 PU4801.2
PWR_VCCGT_FB: PC4614.2 PC4617.1 PR4626.2 PR4631.1 PU4601.3
PWR_VCCGT_FB_R: PC4614.1 PR4625.2
PWR_VCCGT_GL1: PU4801.8 PU4801.9 PU4801.10 PU4801.11
PWR_VCCGT_ICCMAX: PR4662.1 PU4601.18
PWR_VCCGT_ILIM: PR4640.2 PU4601.5
PWR_VCCGT_ILIM_R: PR4634.1 PR4638.1 PR4639.1
PWR_VCCGT_IOUT: PC4615.2 PR4632.2 PU4601.1
PWR_VCCGT_NTC: PR4655.1 PR4656.2 PR4661.1
PWR_VCCGT_PHASEDA: PC4809.2 PU4801.32 PU4801.34
PWR_VCCGT_PWMA: PU4601.16 PU4801.4
PWR_VCCGT_SNUB_1: PC4810.1 PR4804.2
PWR_VCCGT_SWA: PG4808.2 PL4801.1 PR4804.1 PU4801.12 PU4801.13 PU4801.14 PU4801.15 PU4801.16 PU4801.17 PU4801.18
PWR_VCCGT_TSENSE: PC4630.1 PR4655.2 PU4601.11
PWR_VCCGT_VCCA: PC4808.1 PR4803.1 PU4801.6
PWR_VCCGT_VSN: PC4612.2 PR4619.1 PU4601.48
PWR_VCCGT_VSN_R: PC4611.2 PC4612.1 PR4618.2 PR4619.2
PWR_VCCGT_VSP: PC4611.1 PR4617.2 PU4601.47
PWR_VCCSA_BST: PR5013.1 PU5001.1
PWR_VCCSA_BST_RC: PC5008.1 PR5013.2
PWR_VCCSA_COMP: PC4602.2 PC4604.2 PU4601.43
PWR_VCCSA_COMP_R: PC4602.1 PR4602.2
PWR_VCCSA_CSN: PC4606.1 PC4607.1 PG5022.1 PR4606.2 PU4601.41
PWR_VCCSA_CSN_NTC: PR4606.1 PR4609.2
PWR_VCCSA_CSP: PG5021.1 PR4612.2
PWR_VCCSA_CSP1B: PC4606.2 PC4607.2 PR4609.1 PR4612.1 PU4601.40
PWR_VCCSA_DRVH: PU5001.8 PU5002.4
PWR_VCCSA_DRVL: PU5001.5 PU5003.4
PWR_VCCSA_ICCMAX: PR4660.1 PU4601.20
PWR_VCCSA_ILIM: PC4632.1 PR4611.1 PU4601.42
PWR_VCCSA_IOUT: PC4609.1 PR4613.1 PU4601.39
PWR_VCCSA_PWM: PU4601.36 PU5001.2
PWR_VCCSA_SNUB: PC5031.1 PR5014.2
PWR_VCCSA_SW: PC5008.2 PG5021.2 PL5001.1 PR5014.1 PU5001.7 PU5002.1 PU5002.2 PU5002.3 PU5003.5 PU5003.6 PU5003.7 PU5003.8
PWR_VCCSA_VSN: PC4603.2 PR4605.2 PU4601.44
PWR_VCCSA_VSN_R: PC4603.1 PC4605.2 PR4604.2 PR4605.1
PWR_VCCSA_VSP: PC4608.2 PR4608.2 PU4601.45
PWR_VCCSA_VSP_R: PC4605.1 PR4607.2 PR4608.1 PR4616.1
PWR_VCCSA_VSP_RC: PC4608.1 PR4616.2
PWR_VCORE_ADDR_BOOT: PR4663.1 PU4601.21
PWR_VCORE_ALERT#: PR4666.1 PU4601.33
PWR_VCORE_BOOT: PR4701.1 PU4701.35
PWR_VCORE_BOOT_RC: PC4706.1 PR4701.2
PWR_VCORE_COMP: PC4601.1 PC4619.1 PU4601.26
PWR_VCORE_COMP_R: PC4601.2 PR4636.1
PWR_VCORE_CSN: PC4616.2 PC4634.2 PG4708.1 PR4633.1 PU4601.28
PWR_VCORE_CSNNTC: PR4629.2 PR4633.2
PWR_VCORE_CSP: PG4707.1 PR4627.2
PWR_VCORE_CSP_1A: PC4616.1 PC4634.1 PR4627.1 PR4629.1 PU4601.29
PWR_VCORE_DISB#: PR4704.2 PU4701.2
PWR_VCORE_DRVON: PR4704.1 PR4808.1 PU4601.35 PU5001.3
PWR_VCORE_EN: PR4630.1 PU4601.37
PWR_VCORE_GL: PU4701.8 PU4701.9 PU4701.10 PU4701.11
PWR_VCORE_ICCMAX: PR4658.1 PU4601.19
PWR_VCORE_ILIM: PC4633.1 PR4635.1 PU4601.27
PWR_VCORE_IOUT: PC4613.1 PR4628.1 PU4601.30
PWR_VCORE_NTC: PR4650.1 PR4652.1 PR4653.2
PWR_VCORE_PHASED: PC4706.2 PU4701.32 PU4701.34
PWR_VCORE_PWM: PU4601.22 PU4701.4
PWR_VCORE_ROSC_COREGT: PR4664.1 PU4601.14
PWR_VCORE_ROSC_SAUS: PR4659.1 PU4601.15
PWR_VCORE_SCLK: PR4665.2 PU4601.34
PWR_VCORE_SDIO: PR4667.2 PU4601.32
PWR_VCORE_SNUB: PC4709.1 PR4703.2
PWR_VCORE_SW: PG4707.2 PL4701.1 PR4703.1 PU4701.12 PU4701.13 PU4701.14 PU4701.15 PU4701.16 PU4701.17 PU4701.18
PWR_VCORE_TSENSE: PC4628.1 PR4650.2 PU4601.23
PWR_VCORE_VCC: PC4708.1 PR4702.1 PU4701.6
PWR_VCORE_VCC_R: PC4631.1 PR4657.2 PU4601.13
PWR_VCORE_VR_RDY: PR4670.1 PU4601.38
PWR_VCORE_VRHOT#: PR4668.1 PU4601.31
PWR_VCORE_VRMP: PC4629.1 PR4601.2 PU4601.12
PWR_VCORE_VSN: PC4622.2 PR4644.1 PU4601.25
PWR_VCORE_VSN_R: PC4622.1 PC4625.1 PR4644.2 PR4645.2
PWR_VCORE_VSP: PR4647.1 PR4649.1 PU4601.24
PWR_VCORE_VSP_R: PC4625.2 PC4627.2 PR4647.2 PR4648.2
PWR_VCORE_VSP_RC: PC4627.1 PR4649.2
PWR_VDDQ: PC5104.1 PC5105.1 PC5107.1 PC5109.1 PC5118.1 PC5122.1 PG5106.1 PG5107.1 PG5108.1 PG5109.1 PG5111.1 PG5113.2 PL5101.2 PU5102.1 PU5102.2
PWR_VDDQ_BOOT: PR5102.1 PU5101.1
PWR_VDDQ_BOOT_A: PC5114.1 PR5102.2
PWR_VDDQ_EN: PG5112.2 PR5105.1 PU5101.11
PWR_VDDQ_FB: PC5113.2 PR5101.1 PR5107.2 PU5101.14
PWR_VDDQ_FB_A: PC5113.1 PG5113.1 PR5107.1
PWR_VDDQ_ILMT: PR5103.1 PR5106.2 PU5101.13
PWR_VDDQ_PG: PG5114.2 PR5104.2 PU5101.9 PU5101.10
PWR_VDDQ_PH: PC5114.2 PL5101.1 PU5101.6 PU5101.19 PU5101.20
PWR_VDDQ_VCC: PC5112.1 PR5103.2 PU5101.16 PU5101.17
PWR_VGA_CORE__BOOT1_1: PC8510.1 PR8515.2
PWR_VGA_CORE__BOOT2_1: PC8507.1 PR8507.2
PWR_VGA_CORE_BOOT1: PR8515.1 PU8501.21
PWR_VGA_CORE_BOOT2: PR8507.1 PU8501.30
PWR_VGA_CORE_COMP: PC8514.2 PC8515.1 PR8528.1 PU8501.19
PWR_VGA_CORE_COMP_1: PC8516.1 PR8527.2
PWR_VGA_CORE_EN_R#: PQ8501.5 PQ8501.6 PR8539.1
PWR_VGA_CORE_ENABLE: PR8514.2 PU8501.8
PWR_VGA_CORE_FB: PC8514.1 PR8523.2 PR8525.1 PR8526.2 PR8527.1 PU8501.18
PWR_VGA_CORE_FB2_R: PC8515.2 PR8526.1
PWR_VGA_CORE_FB_R: PC8513.2 PR8523.1
PWR_VGA_CORE_IMON: PC8511.1 PR8516.1 PU8501.10
PWR_VGA_CORE_IMON_NB: PR8508.2 PU8501.2
PWR_VGA_CORE_ISEN1: PC8518.1 PR8519.1 PR8543.1 PU8501.13
PWR_VGA_CORE_ISEN2: PC8517.1 PR8522.1 PR8538.1 PU8501.12
PWR_VGA_CORE_ISUMN: PR8536.2 PU8501.15
PWR_VGA_CORE_ISUMP: PC8522.1 PC8523.1 PR8517.1 PR8529.1 PR8532.1 PR8537.1 PU8501.14
PWR_VGA_CORE_LGATE1: PU8501.24 PU8502.8 PU8503.8
PWR_VGA_CORE_LGATE2: PU8501.27 PU8504.8 PU8505.8
PWR_VGA_CORE_LGATE_NB: PR8501.2 PU8501.34
PWR_VGA_CORE_NTC: PR8524.2 PU8501.11
PWR_VGA_CORE_NTC_NB: PR8506.2 PU8501.1
PWR_VGA_CORE_PGOOD: PC8512.1 PR8518.2 PR8520.1 PR8544.2 PU8501.20
PWR_VGA_CORE_PH1: PG8507.1 PR8517.2 PR8519.2
PWR_VGA_CORE_PH2: PG8509.1 PR8537.2 PR8538.2
PWR_VGA_CORE_PHASE1: PC8510.2 PG8507.2 PL8501.1 PR8541.1 PU8501.23 PU8502.9 PU8503.9
PWR_VGA_CORE_PHASE2: PC8507.2 PG8509.2 PL8502.1 PR8542.1 PU8501.28 PU8504.9 PU8505.9
PWR_VGA_CORE_PWROK: PR8544.1 PU8501.9
PWR_VGA_CORE_RTN: PC8501.2 PR8530.1 PU8501.17
PWR_VGA_CORE_SVC: PR8509.2 PU8501.3
PWR_VGA_CORE_SVD: PR8512.2 PU8501.5
PWR_VGA_CORE_SVT: PR8513.2 PU8501.7
PWR_VGA_CORE_UGATE1: PU8501.22 PU8502.1 PU8503.1
PWR_VGA_CORE_UGATE2: PU8501.29 PU8504.1 PU8505.1
PWR_VGA_CORE_UGATE_LX_NB: PR8502.2 PU8501.32 PU8501.33
PWR_VGA_CORE_VDD: PC8509.1 PR8510.2 PU8501.25
PWR_VGA_CORE_VDDIO: PC8503.2 PR8505.2 PR8546.2 PU8501.6 R7923.2 R7924.2 R7940.2
PWR_VGA_CORE_VO1: PG8508.1 PR8521.2 PR8522.2
PWR_VGA_CORE_VO2: PG8510.1 PR8540.2 PR8543.2
PWR_VGA_CORE_VR_HOT#: PR8511.2 PU8501.4
PWR_VGA_CORE_VSEN: PC8513.1 PC8524.1 PR8525.2 PR8534.1 PU8501.16
PWR_VGA_CORE_VSUM-: PC8517.2 PC8518.2 PC8522.2 PC8523.2 PC8525.1 PR8521.1 PR8532.2 PR8533.2 PR8536.1 PR8540.1
PWR_VGA_SNUB1: PC8506.1 PR8541.2
PWR_VGA_SNUB2: PC8533.1 PR8542.2
PWRGOOD_TEST: GPU1.N10 R7601.1
PX_EN: GPU1.AB16 TP7904.1
Q502_G: Q501.D Q502.G R507.2
Q4009_G: Q2702.G R2728.2 R2729.2
Q6204_G: Q6503.2 Q6503.5 R6512.1
Q6205_Q: Q6505.D R6522.2
Q9102.G: Q9102.G R9129.1
QSAN_0: GPU1.H27 VRAM1.B7
QSAN_1: GPU1.A27 VRAM1.G3
QSAN_2: GPU1.C23 VRAM2.B7
QSAN_3: GPU1.C19 VRAM2.G3
QSAN_4: GPU1.C15 VRAM4.G3
QSAN_5: GPU1.E9 VRAM3.B7
QSAN_6: GPU1.C5 VRAM3.G3
QSAN_7: GPU1.H4 VRAM4.B7
QSAP_0: GPU1.H28 VRAM1.C7
QSAP_1: GPU1.C27 VRAM1.F3
QSAP_2: GPU1.A23 VRAM2.C7
QSAP_3: GPU1.E19 VRAM2.F3
QSAP_4: GPU1.E15 VRAM4.F3
QSAP_5: GPU1.D10 VRAM3.C7
QSAP_6: GPU1.D6 VRAM3.F3
QSAP_7: GPU1.G5 VRAM4.C7
RASA0#: GPU1.G22 VRAM1.J3 VRAM2.J3
RASA1#: GPU1.G17 VRAM3.J3 VRAM4.J3
RESET_OUT#: EC1704.1 KBC24.73 Q2602.G Q4001.3 R1706.1
RING2: EC2906.1 HDA27.17 R2911.1 RN2901.4(B)
RING2_HPMIC1: ED2903.2 HPMIC1.4 R2911.2
RSMRST_PWRGD#: D4002.3 R4029.2 R4030.2 R4031.2 R4032.2 R4033.2
RSVD_TP_AK12: CPU1.AK12 TP606.1
RSVD_TP_AK13: CPU1.AK13 TP605.1
RSVD_TP_AW70: CPU1.AW70 TP615.1
RSVD_TP_AW71: CPU1.AW71 TP614.1
RSVD_TP_BA68: CPU1.BA68 TP602.1
RSVD_TP_BA70: CPU1.BA70 TP601.1
RSVD_TP_BB68: CPU1.BB68 TP603.1
RSVD_TP_BB69: CPU1.BB69 TP604.1
RTC_AUX_S5: C2503.1 D2501.3 R1730.1 R2106.1 R2473.2 R2712.2 RN1801.1(A) RN1801.2(A)
RTC_DET#: CPU1.P1 Q2505.D RN2013.4(B)
RTC_PWR: D2501.2 Q2505.G R2502.1 R2504.1
RTC_RST#: C1805.1 CPU1.AM16 EC1807.1 G1801.2 Q1802.D RN1801.3(B)
RTC_X1: C1804.1 CPU1.AM18 R1815.1 X1802.1
RTC_X2: C1803.1 CPU1.AM20 R1815.2 X1802.2
RTCRST_ON: EC1808.1 KBC24.31 Q1802.G R1837.1
RUNPWROK: KBC24.48 R2481.1
SA0_CHA_DIM0: DM1.256 R1204.1 R1205.2
SA0_CHB_DIM0: DM2.256 R1302.1 R1303.2
SA1_CHA_DIM0: DM1.260 R1208.1 R1210.2
SA1_CHB_DIM0: DM2.260 R1306.1 R1307.1
SA2_CHA_DIM0: DM1.166 R1211.1 R1212.2
SA2_CHB_DIM0: DM2.166 R1310.1 R1311.2
SATA#/BATT_LED_MUXCTL: Q6401.G R6401.2 U9601.11
SATA_DE1_HDD: R5612.1 R5613.2 U5601.9
SATA_DE2_HDD: R5614.1 R5615.2 U5601.8
SATA_EQ1_HDD: R5610.1 R5611.2 U5601.17
SATA_EQ2_HDD: R5608.1 R5609.2 U5601.19
SATA_LED#_R: CPU1.H1 Q6401.S R1609.2
SATA_RN1/PERN6_L0: CPU1.G21 R6207.1
SATA_RP1/PERP6_L0: CPU1.F21 R6205.1
SATA_RX_CON_N0: C6004.2 ED6001.4 ED6001.7 HDD1.5
SATA_RX_CON_P0: C6003.2 ED6001.5 ED6001.6 HDD1.6
SATA_RX_CPU_N0: C5620.2 CPU1.F20
SATA_RX_CPU_N0_R: C5620.1 U5601.4
SATA_RX_CPU_P0: C5619.2 CPU1.E20
SATA_RX_CPU_P0_R: C5619.1 U5601.5
SATA_RX_R_N0: C6004.1 U5601.12
SATA_RX_R_P0: C6003.1 U5601.11
SATA_TN1/PETN6_L0: C6205.1 CPU1.D21
SATA_TP1/PETP6_L0: C6204.1 CPU1.C21
SATA_TX_CON_N0: C6005.2 ED6001.2 ED6001.9 HDD1.3
SATA_TX_CON_P0: C6006.2 ED6001.1 ED6001.10 HDD1.2
SATA_TX_CPU_N0: C5618.1 CPU1.B21
SATA_TX_CPU_N0_R: C5618.2 U5601.2
SATA_TX_CPU_P0: C5617.1 CPU1.A21
SATA_TX_CPU_P0_R: C5617.2 U5601.1
SATA_TX_R_N0: C6005.1 U5601.14
SATA_TX_R_P0: C6006.1 U5601.15
SD_RCOMP: CPU1.AB7 R1901.1
SD_READ_MODE#: CPU1.AN5 EC2001.1 IOBD3.9 R2050.2
SERIRQ: CPU1.AY11 KBC24.55 RN2001.4(A)
SERIRQ_TPM: R9148.1 U9104.27
SIO_EXT_SCI#: KBC24.66 R2411.1
SIO_EXT_SCI#_R: CPU1.J3 R1608.2 R2411.2
SIO_EXT_SMI#: KBC24.10 R2412.1
SIO_EXT_SMI#_R: CPU1.L6 R802.1 R2412.2
SIO_EXT_WAKE#: CPU1.AD3 KBC24.116 RN2013.3(B)
SIO_PWRBTN#: CPU1.BA15 KBC24.52 R9926.1
SIO_RCIN#: CPU1.AW13 KBC24.53 R1838.2
SIO_SLP_A#: CPU1.AN16 TP1706.1
SIO_SLP_S3#: CPU1.AP15 KBC24.4 PR5126.1 Q4001.2 R2728.1 R4010.1 R4020.1
SIO_SLP_S4#: CPU1.BA16 KBC24.67 PR5405.1 R4023.1 U4005.2
SIO_SLP_S5#: CPU1.AY16 TP1703.1
SIO_SLP_SUS#: CPU1.AN15 KBC24.96 PR5306.1 PR5413.1 R1729.2 R4104.1
SKTOCC#: CPU1.A65 TP402.1
SLEEVE: EC2905.1 HDA27.18 R2906.1 RN2901.3(B)
SLEEVE_HPMIC1: ED2901.1 HPMIC1.3 R2906.2
SLP_LAN#: CPU1.AW15 TP1704.1
SM_DRAMRST#: CPU1.AT13 ED502.2 R504.1 R505.2
SM_INTRUDER#: CPU1.AP16 R1730.2
SM_PGCNTL: CPU1.AW67 Q501.G
SM_PGCNTL_R: PR5125.1 Q502.D R506.2
SM_RCOMP_0: CPU1.AR18 R501.1
SM_RCOMP_1: CPU1.AT18 R502.1
SM_RCOMP_2: CPU1.AU18 R503.1
SMB_CLK_VGA: GPU1.U7 R7912.2
SMB_CLK_VGA_GPUT8: C2619.1 R7947.1 THM263.8
SMB_CLK_VGA_R: Q7901.1 R7912.1 R7947.2 RN7902.2(A)
SMB_DATA_VGA: GPU1.U8 R7914.2
SMB_DATA_VGA_GPUT8: C2620.1 R7948.1 THM263.7
SMB_DATA_VGA_R: Q7901.4 R7914.1 R7948.2 RN7902.1(A)
SMBCLK1: ED4306.3 KBC24.9 PG4410.2 PR4412.2 RN2402.3(B) RN4302.3(A)
SMBCLK2: KBC24.12 Q2604.3 R2474.1 R2483.1 RN2407.4(B)
SMBDA1: ED4305.3 KBC24.8 PG4409.2 PR4411.2 RN2402.4(B) RN4302.2(A)
SMBDA2: KBC24.11 Q2604.6 R2471.1 R2482.1 RN2407.3(B)
SML0_SMBCLK: CPU1.R9 RN1807.5(B)
SML0_SMBDATA: CPU1.W2 RN1807.8(B)
SML1_SMBCLK: CPU1.W3 Q2601.3 Q2604.4 Q7901.6 R2483.2 RN1807.7(B)
SML1_SMBDATA: CPU1.V3 Q2601.6 Q2604.1 Q7901.3 R2482.2 RN1807.6(B)
SPI0_MOSI_XDP: R1826.1 R9909.2 R9910.1
SPI0_MOSI_XDP_R: C9903.1 R9910.2 XDP1.47
SPI1_CLK_ROM_R: EC2505.1 R2511.1 SPI252.6
SPI1_HOLD_ROM_R: R2509.1 RN2502.2(A) SPI252.7
SPI1_SI_ROM_R: EC2506.1 R2512.1 SPI252.5
SPI1_SO_ROM_R: EC2504.1 R2513.2 SPI252.2
SPI1_WP_ROM_R: R2514.2 RN2502.1(A) SPI252.3
SPI3_CLK_ROM: R2459.1 R2519.2
SPI3_CLK_ROM_R: EC2508.1 R2519.1 SPI241.6
SPI3_HOLD_ROM_R: R2455.1 SPI241.7
SPI3_SI_ROM: R2460.1 R2521.2
SPI3_SI_ROM_R: EC2509.1 R2521.1 SPI241.5
SPI3_SO_ROM: R2457.2 R2522.1
SPI3_SO_ROM_R: EC2507.1 R2522.2 SPI241.2
SPI3_WP_ROM_R: R2456.2 SPI241.3
SPI_CLK_CPU: CPU1.AV2 RN1805.7(B)
SPI_CLK_ROM: R2511.2 R9132.1 R9151.1 RN1805.2(A) RN2401.1(A) RN2503.3(A)
SPI_CLK_ROM_R: EC2503.1 FC2501.1 RN2503.6(B) SKT25.6 SPI25.6
SPI_CLK_ROM_TPM1: R9151.2 U9101.6
SPI_CLK_ROM_TPM2: R9132.2 U9104.19
SPI_CS2#_R: Q9104.G R1816.1 R9129.2 R9130.1 R9133.2 R9137.1
SPI_CS2#_R_TPM1: R9137.2 U9101.1
SPI_CS2#_R_TPM2: R9130.2 R9140.2 U9104.20
SPI_CS_CPU_N0: CPU1.AU3 R1812.2
SPI_CS_CPU_N1: CPU1.AU2 R1828.2
SPI_CS_ROM_N0: R1812.1 R2490.2 R2501.1 SKT25.1 SPI25.1
SPI_CS_ROM_N1: R1828.1 R2515.1 SPI252.1
SPI_HOLD_CPU: CPU1.AU4 R1811.2 RN1802.4(B)
SPI_HOLD_ROM: R1811.1 R2503.2 R2509.2
SPI_HOLD_ROM_R: R2503.1 RN2501.2(A) SKT25.7 SPI25.7
SPI_IRQ#: R9117.1 R9119.2 R9135.1
SPI_IRQ#_TPM1: C9103.1 R9117.2 U9101.7
SPI_IRQ#_TPM2: R9135.2 U9104.18
SPI_SI_CPU: CPU1.AV3 R1824.2 R1825.1 R1826.2 RN1805.8(B)
SPI_SI_ROM: R2512.2 R9139.1 R9150.1 RN1805.1(A) RN2401.2(A) RN2503.4(A)
SPI_SI_ROM_R: EC2501.1 RN2503.5(B) SKT25.5 SPI25.5
SPI_SI_ROM_TPM1: R9150.2 U9101.5
SPI_SI_ROM_TPM2: R9139.2 U9104.21
SPI_SO_CPU: CPU1.AW3 RN1805.6(B)
SPI_SO_ROM: R2513.1 R9134.1 R9152.1 RN1805.3(A) RN2401.3(A) RN2503.1(A)
SPI_SO_ROM_R: EC2502.1 RN2503.8(B) SKT25.2 SPI25.2
SPI_SO_ROM_TPM1: R9152.2 U9101.2
SPI_SO_ROM_TPM2: R9134.2 U9104.24
SPI_WP_CPU: CPU1.AW2 R1827.2 RN1802.3(B) RN1805.5(B)
SPI_WP_ROM: R2514.1 RN1805.4(A) RN2503.2(A)
SPI_WP_ROM_R: RN2501.1(A) RN2503.7(B) SKT25.3 SPI25.3
SPKR: CPU1.AW5 R2006.2 RN2701.2(A)
SPV10: C8055.1 C8056.1 GPU1.H8 L8003.2
SPV18: C8053.1 C8054.1 GPU1.H7 L8002.2
SRTC_RST#: C1806.1 CPU1.AN18 EC1806.1 RN1801.4(B)
SUS_CLK: R1813.2 R2428.2
SUS_CLK_WLAN_WWAN: R1817.2 R6117.1 R6213.2
SUS_STAT#/LPCPD#: CPU1.BA11 R1814.2
SUSACK#: KBC24.34 R1703.1
SUSACK#_R: CPU1.AP11 R1703.2 R1708.2
SUSCLK_NGFF_C: AFTP6255.1 R6213.1 WWAN1.68
SUSCLK_R: CPU1.BA17 EC1803.2 R1813.1 R1817.1
SUSCLK_WLAN: R6117.2 WLAN1.50
SYS_PRES1#: BATT1.7 R4301.2
SYS_PWROK: CPU1.B6 EC1702.1 KBC24.89 R1717.1
T_CRIT#: R2601.2 R2604.2 THM26.4
TESTEN: GPU1.K7 R7902.2 R7903.1
THERM_SYS_SHDN#: Q2602.S R2601.1 R2602.1
THM_SML1_CLK: C2608.1 Q2601.4 RN2602.4(B) THM26.8
THM_SML1_DATA: C2609.1 Q2601.1 RN2602.3(B) THM26.7
TOPAZ_OCP: GPU1.T8 PR8511.1
TOUCH_PANEL_INTR#: CPU1.A7 D2402.A R2429.1 RN5501.4(B)
TOUCHPAD_INTR#: CPU1.BA5 D401.A R410.2 R411.2 R414.2
TP1_AY4: CPU1.AY4 TP610.1
TP2_BB3: CPU1.BB3 TP611.1
TP4_BB5: CPU1.BB5 TP609.1
TP5_AU5: CPU1.AU5 TP607.1
TP6_AT5: CPU1.AT5 TP608.1
TP_EN#: KBC24.49 R6516.1 RN2406.1(A)
TP_LOCK#: AFTP6242.1 D2405.A RN6501.1(A) TPAD1.6
TP_ON#_GATE: C6503.1 Q6504.G Q6505.G R6516.2
TP_PMODE_XDP_RST_R_N: R9933.2 XDP1.46
TP_RESET: C5540.1 LCD1.38 RN5501.2(A)
TP_RS: C5541.1 LCD1.37 RN5501.1(A)
TP_VDD: AFTP6239.1 C6504.1 FC9711.1 Q6504.D R6513.1 R6517.2 R6522.1 RN6501.3(B) RN6501.4(B) RN6502.1(A) RN6502.2(A) RN6504.1(A) RN6504.2(A) RN6505.1(A) RN6505.2(A) TPAD1.1
TPAN_VDD: C5501.1 EL5503.5 F5502.2 LCD1.40 R5520.1
TPAN_VDD_F: F5502.1 R5520.2 R5522.2 R5527.1
TPCLK_C: AFTP6238.1 RN6503.4(B) TPAD1.8
TPDATA_C: AFTP6236.1 RN6503.3(B) TPAD1.7
TPM_GPIO0: R9141.1 U9104.29
TPM_GPIO2: Q9102.D Q9104.D R9120.1 R9131.1 R9138.2 R9142.1 U9104.3
TPM_GPIO4: R9133.1 U9104.13
TPM_VDD14: C9115.2 R9147.2 U9104.14
TPM_VDD22: C9116.2 R9149.2 U9104.22
TPM_VSB: R9144.2 U9104.1
TS#_DIMM0_1: DM1.134 R1215.2
TS#_DIMM1_1: DM2.134 R1312.2
U4101_OUT: R4103.1 U4101.6 U4101.7 U4101.8
UART0_CTS#: CPU1.U4 TP2014.1
UART0_RTS#: CPU1.U3 TP2013.1
UART0_TXD: CPU1.U2 TP2012.1
UART1_CTS#: CPU1.AB4 TP2017.1
UART1_RTS#: CPU1.AC3 TP2016.1
UART1_RXD: CPU1.AC1 TP2015.1
UIM_CLK: AFTP6313.1 C6306.2 EC6304.1 ED6301.3 R6223.2 SIM1.3
UIM_CLK_C: C6306.1 R6301.2
UIM_CLK_R: R6223.1 WWAN1.32
UIM_DATA: AFTP6309.1 EC6305.1 ED6301.4 R6206.2 SIM1.7
UIM_DATA_R: R6206.1 WWAN1.34
UIM_DET: R6304.2 WWAN1.66
UIM_DET#: AFTP6312.1 R6227.2 R6305.1 SIM1.DSW2
UIM_DET#_G: Q6301.G R6305.2
UIM_DET_D: Q6301.D R6303.1 R6304.1
UIM_PWR: AFTP6310.1 EC6302.1 ED6301.5 SIM1.1 WWAN1.36
UIM_RESET: AFTP6315.1 EC6301.1 ED6301.1 R6228.2 SIM1.2
UIM_RESET_R: R6228.1 WWAN1.30
UIM_RFU: R6219.1 WWAN1.28
UIM_VPP: AFTP6317.1 EC6303.1 ED6301.6 R6219.2 SIM1.6
USB2_ID: CPU1.AG3 R1601.1
USB2_VBUSSENSE: CPU1.AG4 R1602.1
USB3_PRX_CTX_N1_C: ED3601.1 ED3601.10 R3608.2 USB1.5
USB3_PRX_CTX_N3_C: ED3603.1 ED3603.10 R3612.2 USB2.5
USB3_PRX_CTX_P1_C: ED3601.2 ED3601.9 R3607.2 USB1.6
USB3_PRX_CTX_P3_C: ED3603.2 ED3603.9 R3611.2 USB2.6
USB3_PTX_CRX_N1_C: ED3601.4 ED3601.7 R3606.2 USB1.8
USB3_PTX_CRX_N1_R: C3601.2 R3606.1
USB3_PTX_CRX_N3_C: ED3603.4 ED3603.7 R3610.2 USB2.8
USB3_PTX_CRX_N3_R: C3604.2 R3610.1
USB3_PTX_CRX_P1_C: ED3601.5 ED3601.6 R3605.2 USB1.9
USB3_PTX_CRX_P1_R: C3602.2 R3605.1
USB3_PTX_CRX_P3_C: ED3603.5 ED3603.6 R3609.2 USB2.9
USB3_PTX_CRX_P3_R: C3605.2 R3609.1
USB3_RXN3_R: R6226.2 WWAN1.29
USB3_RXP3_R: R6221.2 WWAN1.31
USB3_TXN3_R: C6208.2 WWAN1.35
USB3_TXP3_R: C6207.2 WWAN1.37
USB20_VCCA: AFTP6311.1 C3515.1 C3517.1 C3518.1 EC3701.1 ED3701.5 IOBD3.11 IOBD3.12 IOBD3.13 IOBD3.14 R3502.1 U3503.1
USB30_RX_CPU_N1: CPU1.H8 R3608.1
USB30_RX_CPU_N2: CPU1.J6 R6226.1
USB30_RX_CPU_N3: CPU1.J10 R3612.1
USB30_RX_CPU_P1: CPU1.G8 R3607.1
USB30_RX_CPU_P2: CPU1.H6 R6221.1
USB30_RX_CPU_P3: CPU1.H10 R3611.1
USB30_TX_CPU_N1: C3601.1 CPU1.C13
USB30_TX_CPU_N2: C6208.1 CPU1.B13
USB30_TX_CPU_N3: C3604.1 CPU1.B15
USB30_TX_CPU_P1: C3602.1 CPU1.D13
USB30_TX_CPU_P2: C6207.1 CPU1.A13
USB30_TX_CPU_P3: C3605.1 CPU1.A15
USB30_VCCB: C3509.1 C3514.1 C3516.1 C3519.1 EC3618.1 ED3604.5 R3501.1 TC3502.1 U3502.1 USB2.1
USB30_VCCC: C3401.1 C3403.1 C3404.1 C3405.1 EC3619.1 ED3602.5 R3401.1 U3401.12 USB1.1
USB_CAMERA_PN4: EL5501.3 EL5503.3 LCD1.30
USB_CAMERA_PP4: EL5501.2 EL5503.4 LCD1.31
USB_CHG_EN: RN9601.1(A) U3401.5 U9601.10
USB_CON_PN6: AFTP5806.1 R6110.1 WLAN1.5
USB_CON_PN7: EL5503.1 LCD1.34 R5535.1
USB_CON_PP6: AFTP5807.1 R6111.1 WLAN1.3
USB_CON_PP7: EL5503.6 LCD1.35 R5536.1
USB_CPU_PN0: CPU1.AB9 U3401.2
USB_CPU_PN1: CPU1.AD6 EL3602.1
USB_CPU_PN2: CPU1.AH3 EL3701.4
USB_CPU_PN3: CPU1.AD9 R9203.1
USB_CPU_PN4: CPU1.AJ1 EL5501.4
USB_CPU_PN5: CPU1.AF6 EL3301.4
USB_CPU_PN6: CPU1.AH1 R6110.2
USB_CPU_PN7: CPU1.AF8 R5535.2
USB_CPU_PP0: CPU1.AB10 U3401.3
USB_CPU_PP1: CPU1.AD7 EL3602.4
USB_CPU_PP2: CPU1.AJ3 EL3701.1
USB_CPU_PP3: CPU1.AD10 R9204.1
USB_CPU_PP4: CPU1.AJ2 EL5501.1
USB_CPU_PP5: CPU1.AF7 EL3301.1
USB_CPU_PP6: CPU1.AH2 R6111.2
USB_CPU_PP7: CPU1.AF9 R5536.2
USB_EN#: KBC24.13 Q2401.S R2461.2 R2479.2
USB_OC0#: CPU1.A9 RN1602.7(B) U3401.13
USB_OC1#: CPU1.C9 RN1602.5(B) U3502.3
USB_OC2#: CPU1.D9 RN1602.8(B) U3503.3
USB_OC3#: CPU1.B9 RN1602.6(B)
USB_PN0_C: ED3602.1 EL3601.3 USB1.2
USB_PN0_R: EL3601.4 U3401.11
USB_PN1_C: ED3604.1 EL3602.2 USB2.2
USB_PN2_C: AFTP6301.1 ED3701.6 EL3701.3 IOBD3.3
USB_PN3_C: AFTP8903.1 EC9202.2 ED9201.1 FPR1.4 R9203.2
USB_PN5_C: AFTP6304.1 ED3701.4 EL3301.3 IOBD3.6
USB_PP0_C: ED3602.6 EL3601.2 USB1.3
USB_PP0_R: EL3601.1 U3401.10
USB_PP1_C: ED3604.6 EL3602.3 USB2.3
USB_PP2_C: AFTP6302.1 ED3701.1 EL3701.2 IOBD3.4
USB_PP3_C: AFTP8904.1 EC9201.2 ED9201.6 FPR1.3 R9204.2
USB_PP5_C: AFTP6303.1 ED3701.3 EL3301.2 IOBD3.7
USB_PWR_EN#: Q2401.D R2434.2 R2479.1 U3502.4 U3503.4
USB_UART_SEL_D9: CPU1.P2 TP2006.1
USB_WWAN_N_R: R6222.2 WWAN1.9
USB_WWAN_P_R: R6210.2 WWAN1.7
USB_WWAN_PN8: CPU1.AG1 R6222.1
USB_WWAN_PP8: CPU1.AG2 R6210.1
USBCHARGER_CB0: KBC24.118 R2447.1 U3401.6
USBCOMP: CPU1.AB6 R1603.1
V_SM_VREF_CNTA: C1222.1 CPU1.AY67 R1206.2
V_SM_VREF_CNTB: C1323.1 CPU1.BA67 R1305.2
VCI_IN1#: KBC24.126 R2452.1
VGA_CORE: C8018.1 C8019.1 C8020.1 C8021.1 C8022.1 C8023.1 C8025.1 C8026.1 C8027.1 C8028.1 C8029.1 C8030.1 C8035.1 C8036.1 C8037.1 C8038.1 C8039.1 C8040.1 C8041.1 C8046.1 C8047.1 C8048.1 C8049.1 C8050.1 C8051.1 C8052.1 C8058.1 C8059.1 C8060.1 C8061.1 C8062.1 C8063.1 C8064.1 C8066.1 GPU1.AA12 GPU1.AA15 GPU1.M11 GPU1.M13 GPU1.M15 GPU1.M16 GPU1.M17 GPU1.M18 GPU1.M20 GPU1.M21 GPU1.N12 GPU1.N15 GPU1.N17 GPU1.N20 GPU1.R13 GPU1.R16 GPU1.R18 GPU1.T12 GPU1.T15 GPU1.T17 GPU1.T20 GPU1.U11 GPU1.U13 GPU1.U16 GPU1.U18 GPU1.V15 GPU1.V17 GPU1.V20 GPU1.V21 GPU1.Y13 GPU1.Y16 GPU1.Y18 GPU1.Y21 PC8534.1 PC8535.1 PG8508.2 PG8510.2 PL8501.2 PL8502.2 PR8535.1 PR8545.2 PT8501.1 PT8506.1 PT8507.1
VGA_RST#: C7609.1 GPU1.AL27 R7621.2
VGA_SVC: PR8509.1 R7919.1 R7923.1 R7939.2 R7946.1
VGA_SVD: PR8512.1 R7920.1 R7925.2 R7940.1 R7944.1
VGA_SVT: PR8513.1 R7924.1 R7934.2 R7945.1
VGA_VDD_RUN_FB_H: PR8534.2 PR8535.2 TP8502.1
VGA_VDD_RUN_FB_L: PR8530.2 PR8531.1 TP8501.1
VGA_VSUM-_1: PR8529.2 PR8533.1
VPP_EN_R: PC5401.1 PR5405.2 PR5407.1 PU5402.2
VR_CAP: C2418.1 KBC24.18
VR_EN: PR4630.2 R4002.2
VR_RDY: PR4614.2 PR4670.2
VR_SVID_ALERT#: PR4622.2 PR4666.2 R727.2 R728.1
VR_SVID_CLK: PR4621.2 PR4665.1 R723.2 R732.2
VR_SVID_DATA: PR4623.2 PR4667.1 R709.2
VRAM_ID1: CPU1.AP8 R2023.2 R2024.1
WEA0#: GPU1.G25 VRAM1.L3 VRAM2.L3
WEA1#: GPU1.H10 VRAM3.L3 VRAM4.L3
WHITE_LED_BAT: EC6403.1 Q6404.C R6406.1
WIFI_RF_EN: D6101.K R1503.2 R1504.2 R1709.1 R1710.1
WLAN_CLKREQ_WLAN#: AFTP5802.1 R6112.1 WLAN1.53
WLAN_DISABLE#1: AFTP5803.1 D6101.A WLAN1.56
WWAN_PERST#: AFTP6204.1 R6215.1 WWAN1.50
WWAN_PWR_EN_D: Q6201.2 R6212.2 R6224.1
WWAN_PWR_OFF#: AFTP6256.1 R6217.1 WWAN1.6
WWAN_RADIO_DIS#: D6202.K R9612.1 U9601.16
WWAN_RADIO_DIS#_D: AFTP6259.1 D6202.A WWAN1.8
WWAN_RESET#: TC6204.1 WWAN1.67
XCLK_BIASREF: CPU1.E42 R1803.1
XDP_BPM0: CPU1.C55 XDP1.21
XDP_BPM1: CPU1.D55 XDP1.23
XDP_BPM2: CPU1.B54 TP9901.1
XDP_BPM3: CPU1.C56 TP9902.1
XDP_DBRESET#: CPU1.B5 EC1706.1 R1701.2 R9925.2
XDP_DBRESET_XDP#: C9905.1 R9925.1 XDP1.48
XDP_PRDY#: CPU1.D56 XDP1.5
XDP_PREQ#: CPU1.D61 XDP1.3
XDP_PRSNT_PIN1: R9902.2 XDP1.1
XDP_SMBCLK: R9912.2 XDP1.53
XDP_SMBDAT: R9911.2 XDP1.51
XDP_SPI0_IO2: R1827.1 R9929.2 R9931.1 XDP1.60
XDP_TCK_JTAGX: CPU1.A59 R417.1 R9915.2
XDP_TCLK: CPU1.B61 R406.1 R9915.1 XDP1.57
XDP_TCLK1: R9914.1 XDP1.55
XDP_TDI: CPU1.D60 R422.1 R9916.1 XDP1.56
XDP_TDO_CPU: CPU1.A61 R423.1 R9919.1
XDP_TMS: CPU1.C60 R421.1 R9917.1 XDP1.58
XDP_TRST#: CPU1.B59 CPU1.C61 R402.1 XDP1.54
XO_IN: GPU1.AC22 RN7904.2(A)
XO_IN2: GPU1.AB22 RN7904.1(A)
XTAL1: C2425.2 KBC24.123 X2401.1
XTAL2: KBC24.125 R2428.1 R2458.2
XTAL24_IN: CPU1.E37 R1802.1 R1810.1
XTAL24_IN_R: C1801.2 R1810.2 X1801.1
XTAL24_OUT: C1802.2 CPU1.E35 R1802.2 X1801.3
XTAL_KBC_2: C2424.2 R2458.1 X2401.2
XTL_27M_X1_VGA: C7901.1 GPU1.AM28 R7901.1 X7901.1
XTL_27M_X2_VGA: C7903.1 GPU1.AK28 R7901.2 X7901.3
ZVM#: CPU1.AR56 TP616.1

Pads without a net: CPU1 A3 A4 A11 A23 A25 A26 A27 A29 A31 A33 A36 A38 A40 A45 A47 A50 A52 A69 AB1 AB11 AB12 AB13 AB62 AC63 AD11 AD12 AE62 AE63 AF11 AF12 AF13 AG62 AH7 AH8 AH9 AH10 AH11 AH12 AJ62 AK6 AK7 AK9 AK10 AK32 AK42 AK43 AK45 AK46 AK48 AK50 AK52 AK53 AK55 AK56 AK58 AK60 AK62 AK70 AL25 AL27 AL43 AL46 AL50 AL53 AL56 AL60 AL61 AL63 AM1 AM2 AM3 AM4 AM22 AM23 AM48 AM50 AM52 AM53 AM56 AM58 AN1 AN2 AN3 AN8 AN13 AN55 AP1 AP2 AP3 AP4 AP5 AP7 AP53 AT15 AU11 AU56 AU58 AU63 AW1 AW7 AW20 AW48 AW56 AW68 AW69 AY1 AY2 AY3 AY8 AY20 AY21 AY56 AY68 B2 B3 B11 B23 B25 B26 B27 B29 B31 B33 B36 B38 B40 B45 B47 B50 B69 B70 BA3 BA4 BA7 BA9 BB2 BB4 BB57 BB66 C1 C2 C4 C7 C11 C12 C15 C23 C24 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C51 C54 C70 C71 D1 D3 D4 D5 D7 D8 D12 D15 D23 D24 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D51 D54 D71 E1 E2 E3 E10 E22 E23 E25 E27 E28 E30 E61 F6 F10 F25 F30 F46 F50 F52 F60 F61 F65 G46 G50 G61 G65 H5 H11 J5 J68 J71 K32 K45 K46 N9 N11 P4 P62 U9 U11 U12 V62 W7 W10 W11 W12; D4002 2; DCIN1 3; DM1 87 88 91 92 95 97 100 101 104 105 162 165; DM2 87 88 91 92 95 97 100 101 104 105 162 165; ED3602 3 4; ED3604 3 4; ED5703 5 6; ED9201 3 4; FAN1 1; FPR1 2 5; GPU1 AA5 AA6 AA29 AA31 AB2 AB4 AB7 AB8 AB9 AB11 AB12 AB13 AB23 AB25 AB26 AB27 AB30 AC1 AC3 AC5 AC6 AC7 AC8 AC10 AC11 AC13 AC14 AC16 AC20 AC23 AC25 AD2 AD4 AD7 AD9 AD10 AD11 AD13 AD16 AD20 AD22 AD23 AD24 AE1 AE3 AE5 AE6 AE8 AE9 AE10 AE11 AE13 AE16 AE19 AE22 AE23 AE24 AE25 AE26 AF2 AF4 AF6 AF7 AF8 AF9 AF10 AF11 AF13 AF16 AF17 AF19 AF20 AF22 AF23 AF24 AF25 AG1 AG3 AG5 AG6 AG7 AG8 AG9 AG10 AG11 AG13 AG14 AG15 AG16 AG17 AG18 AG19 AG20 AG21 AG22 AG23 AG24 AG25 AG26 AH1 AH3 AH5 AH6 AH8 AH12 AH14 AH16 AH18 AH20 AH22 AH24 AH26 AJ7 AJ9 AJ13 AJ15 AJ17 AJ19 AJ21 AJ23 AJ25 AK1 AK3 AK5 AK6 AK8 AK14 AK16 AK18 AK20 AK22 AK24 AK26 AL7 AL9 AL13 AL15 AL17 AL19 AL21 AL23 AL25 AM3 AM5 AM6 AM8 AM12 AM14 AM16 AM18 AM20 AM22 AM24 J8 J22 J25 K13 K30 L9 L29 L31 M27 M28 M30 N3 N5 N6 N7 N9 N26 N29 N31 P7 P23 P24 P26 P27 P28 P30 R1 R3 R29 R31 T7 T10 T23 T24 T26 T27 T28 T30 U5 U10 U12 U23 U24 U26 U29 U31 V2 V4 V6 V12 V27 V28 V30 W1 W3 W5 W6 W7 W8 W9 W10 W23 W24 W29 W31 Y2 Y4 Y6 Y7 Y8 Y9 Y11 Y12 Y23 Y24 Y26 Y27 Y28 Y30; HDA27 11 12 14 23 24 48; HDD1 12 17 25; HDMI1 13 14; IOBD3 10 15 17; IOBD4 3; IRCCD1 3; KB1 2 3; KBLIT1 3; LCD1 3 33 39; LEDBD1 3 4; PU4401 4 18; PU4501 19; PU4601 17; PU4701 1 33; PU4801 1 33; PU5101 12; PU5401 5; PU5402 5; PU8501 35; PU8601 5; PU8651 12; PWR1 1; RN2401 4 5; RN4302 4 5; RN5502 4 5; U3401 9 15; U4005 1; U4101 5; U9102 1 2 3 4 5 6 7 8 10 12 13 14 15 17 28 29 30 31; U9103 5 7; U9104 2 4 5 6 7 10 11 12 15 25 26 28 30 31; U9601 5 6 8; VRAM1 J1 J9 L1 L9; VRAM2 J1 J9 L1 L9; VRAM3 J1 J9 L1 L9; VRAM4 J1 J9 L1 L9; WLAN1 6 16 17 19 20 21 22 25 26 27 28 31 32 34 48 59 60 61 62 64 65 66 67 68 71 73; WWAN1 10 20 22 23 24 25 40 42 44 46 48 56 58 59 60 61 62 63 64 65; X1801 2 4; XDP1 61 62 63 64

## Via types
v1: diameter 0.508, hole 0.254, TOP to BOTTOM, 4411 vias
v2: diameter 0.356, hole 0.178, TOP to BOTTOM, 1586 vias
v3: diameter 0.711, hole 0.406, TOP to BOTTOM, 745 vias
v4: diameter 0.559, hole 0.305, TOP to BOTTOM, 16 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
1.8V_RUN_FB: length 5
  TOP w0.254: PU5401.7 161.05,50.26 160.53,50.79 160.53,51.48 PR5411.1 ; PR5411.1 PC5410.2 PR5410.2 ; PR5411.1 160.4,51.61 v2(160.4,52.56)
3.3V_ALW_1: length 8.6
  BOTTOM w0.102: PC8603.2 PC8601.2 PR8619.2 ; PC8603.2 182.28,65.94 PQ8609.G 181.6,64.44 181.36,64.68 PQ8604.6 180.61,65.6 v2(180.34,65.87) 180.34,65.59 179.96,65.21 PQ8604.5 ; PC8603.2 PR8606.2
3.3V_RUN_VGA_1: length 98.9
  TOP w0.102: v1(167.73,57.6) 167.54,57.8 166.79,57.8 166.55,57.55 162.09,57.55 v2(160.91,56.37) 160.45,56.83 158.71,56.83 158.47,57.07 D8601.3
  L3 w0.102: v1(205.36,113.27) 208.84,109.79 208.84,103.06 207.23,101.45 204.56,101.45 198.59,95.47 198.59,94.93 194.69,91.03 194.69,85.5 191.47,82.28 191.47,81.96 190.85,81.34 190.85,76.91 188.13,74.18 188.13,71.99 185.5,69.36 185.5,69.36 185.01,68.87 184.54,68.87 183,67.33 183,67.01 181.23,65.24 178.54,65.24 178.28,64.98 178.28,64.45 178.69,64.04 v1(178.69,63.57) 178.63,63.57 176.89,61.83 174.77,61.83 174.67,61.94 172.92,61.94 172.22,62.63 170.76,62.63 168.63,60.5 168.63,58.4 167.83,57.6 v1(167.73,57.6)
  BOTTOM w0.102: PR8609.1 177.92,62.3 178.42,62.8 PQ8604.3 179.31,63.02 178.75,63.57 v1(178.69,63.57) ; v1(205.36,113.27) 205.36,113.59 D8602.3
3.3V_WLAN_EN: length 3.9
  TOP w0.127: v2(47.58,66.83) 47.58,65.93 R6101.1 R6104.2 48.02,64.6 Q6101.2
3.3V_WLAN_ENABLE: length 5.7
  TOP w0.127: R6103.2 47.73,61.92 C6113.1 ; R6103.2 49.25,61.87 U6101.3 49.27,63.69 Q6101.3 ; R6103.2 47.31,61.87 47.09,61.66 v2(46.76,61.66)
3.3V_WLAN_ENABLE#: length 4.3
  TOP w0.127: R6102.2 50.57,66.76 v2(50.93,66.41) 51.41,65.92 Q6101.6 51.99,65.25 52.11,65.13 52.11,64.73 51.99,64.6 Q6101.5
3.3V_WWAN_ENABLE: length 10.2
  TOP w0.127: C6206.1 89.74,106.87 89.08,106.21 Q6201.3 89.71,105.79 R6220.2 90.76,104.74 91.45,104.74 v2(91.59,104.89) 91.59,104.91 92.04,105.36 93.86,105.36 94.12,105.1 94.12,103.76 93.4,103.03 U6201.3
3.3V_WWAN_ENABLE#: length 5.5
  TOP w0.127: 87.88,105.14 Q6201.5 86,105.14 v2(85.9,105.04) ; 87.88,105.14 87.88,104.74 87.63,104.49 Q6201.6 ; 87.88,105.14 88.01,105.27 88.01,106.35 R6211.2
3V5V_CT1: length 3.1
  TOP w0.203: 54.86,52.35 55.11,52.59 U4001.12
  TOP w0.254: C4001.1 54.25,50.44 v2(54.25,51.78) 54.29,51.78 54.86,52.35
3V5V_CT2: length 3.5
  TOP w0.203: U4001.10 54.31,52.65 54.31,52.64 54.31,52.51
  TOP w0.254: C4002.1 53.37,50.06 v2(53.37,50.94) 53.37,51.57 54.31,52.51
3V5V_S0_ON: length 14.1
  TOP w0.127: U4001.5 54.31,55.74 54.25,55.8 v1(54.25,57.52) v2(54.83,56.93) 55.16,56.61 55.16,55.78 55.11,55.74 U4001.3 ; R4010.2 49.28,57.14 49.15,57.26 48.51,57.26 v1(47.75,56.5)
  L4 w0.127: v1(47.75,56.5) 47.94,56.31 49.39,56.31 50.6,57.52 v1(54.25,57.52)
3V_5V_EN: length 24.4
  TOP w0.127: D4001.A 53.28,36.47 R4009.1 ; D4001.A 54.05,36.64 54.52,37.11 57.9,37.11 58.45,37.65 58.88,37.65 59.23,38.01 59.23,41.18 v2(58.67,41.75) 58.67,43.35 58.28,43.74 58.28,46.99 57.68,47.58 C4009.1 56.9,48.19 55.96,48.19 54.88,47.11 R4006.1 54.69,47.11 54.39,47.41 54.39,47.54 54.05,47.88 PR4502.1 ; D4001.A 53.85,37.04 PR4507.2
3V_5V_POK: length 278
  TOP w0.127: PU4501.7 52.54,44.91 53.47,45.83 v1(53.47,46.21) 53.34,46.34 52.96,46.34 52.27,47.03 PR4508.2 ; v1(171.12,40.55) 170.54,40.55 169.93,41.16 PR5412.1 169.93,42.78 168.57,44.14 168.57,47.34 172.21,50.99 v1(172.21,52.18) ; v1(171.36,37.39) 171.21,37.39 170.95,37.13 164.73,37.13 164.73,37.14 162.73,37.14 162.37,36.77 157.95,36.77 157.2,37.53 156.73,38 151.96,42.75 151.18,43.53 151.04,43.66 147.68,43.66 123.09,43.66 117.73,38.3 64.56,38.3 62.74,40.12 62.74,40.7 61.8,41.64 61.8,42.71 v1(61.9,42.81) 62.18,43.09 62.89,43.09 63.2,42.78 109.98,42.78 115.82,48.63 121.92,48.63 v1(123.44,50.15) ; PR5308.1 49.34,27.29 R4033.1 50.1,28.18 EC1705.1 50.36,28.37 50.93,27.8 51.82,27.8 53.19,29.18 53.19,33.44 53.09,33.55 53.09,34.78 53.95,35.65 v1(54.13,35.65)
  L3 w0.127: v1(54.13,35.65) 56.01,37.53 56.01,43.14 53.47,45.68 v1(53.47,46.21)
  L4 w0.127: v1(150.77,63.1) 152.91,60.97 152.91,58.15 159.11,51.95 164.53,51.95 164.75,52.18 172.21,52.18 v1(172.21,52.18)
  BOTTOM w0.127: v1(54.13,35.65) 54.55,35.23 54.55,34.84 55.19,34.2 56.75,34.2 57.06,34.5 57.06,34.88 56.07,35.87 56.07,37.04 61.84,42.81 v1(61.9,42.81) ; v1(123.44,50.15) 123.43,50.16 122.65,50.16 122.41,50.4 121.48,50.4 R1718.2 ; v1(171.36,37.39) 171.12,37.64 v1(171.12,40.55) ; R1728.2 150.34,65.93 150.34,64.66 EC1711.1 150.37,64.56 v2(150.37,63.61) 150.77,63.21 v1(150.77,63.1)
3V_5V_POK#: length 4.6
  BOTTOM w0.127: Q1701.5 156.34,68.69 156.46,68.57 156.46,68.17 156.34,68.04 Q1701.6 155.75,67.43 R1726.1 156.53,65.78 v2(156.57,65.75)
3V_5V_POK_C: length 5.4
  BOTTOM w0.127: R1729.1 R1728.1 150.5,67.3 v2(151,67.8) 151.13,67.93 151.96,67.93 R1727.2 152.34,67.61 153.42,68.69 Q1701.2
5V_AUX_S5: length 3.8
  TOP w0.203: PC4511.1 49.28,42.91 49.4,43.04 49.78,43.04 49.98,42.84 PU4501.13
  TOP w0.305: v2(47.96,41.49) 48.01,41.49 48.59,42.07 PC4511.1
5V_HDD_S0: length 4.9
  BOTTOM w0.305: HDD1.13 v1(264.15,18.28) ; HDD1.14 263.65,18.65 v1(263.4,18.4) 263.15,18.65 HDD1.15 ; HDD1.16 v1(262.65,18.4)
5V_HDMI_S0: length 16.8
  TOP w0.508: v1(14.53,77.18) v2(15.27,77.18) 16.42,77.18 EC5702.1 16.57,77.07 EC5701.1 ; C5702.1 15.61,79.61 v1(15.49,79.73)
  L4 w0.508: HDMI1.18 14.53,76.38 v1(14.53,77.18)
  BOTTOM w0.508: v1(15.49,79.73) 15.73,79.49 15.88,79.49 16,79.36 17.02,79.36 17.14,79.49 17.78,79.49 18.02,79.73 D5702.2
  BOTTOM w0.635: v1(15.49,79.73) 14.53,78.76 v1(14.53,77.18)
5V_S0: length 292.7
  TOP w0.508: R6705.1 v1(112.04,8.75) ; v1(39.62,9.89) 40.59,8.93 40.69,8.93 40.74,8.88 v2(47.12,8.88) FC6003.1 57.78,8.88 58.67,7.99 v1(59.44,7.99) ; R2703.2 16.41,18.63 15.11,19.92 15.11,21.96 15.88,22.72 v1(19.3,22.72) ; EC9720.1 33.97,81.33 v1(34.8,80.5) ; ED9201.5 267.97,24.24 267.61,24.6 267.61,25.49 v1(267.59,25.51) 267.59,25.64 268.25,26.3 v2(274.57,26.3) 277.24,26.3 280.44,23.11 280.44,20.57 278.62,18.76 v1(277.11,18.76)
  TOP w0.61: v1(208.91,49.58) 208.91,50.55 209.59,51.23 EC9718.1 ; v1(16.64,77.96) 16.64,78.41 C5710.1
  TOP w0.762: R5527.2 37.74,79.49 35.81,79.49 v1(34.8,80.5)
  L3 w0.508: v3(30.07,22.24) 30.07,23.71 29.03,24.75 21.49,24.75 19.46,22.72 v1(19.3,22.72)
  L3 w0.61: v1(208.91,49.58) 208.91,49.87 207.05,51.74 201.3,51.74 198.25,54.79 198.25,55.99 198.25,56 198.25,56.56 197.63,57.19 191.39,57.19 191,56.79 v3(190.87,56.79)
  L3 w0.762: v1(34.8,80.5) 35.56,79.74 35.56,76.57 36.45,75.68 36.45,74.03 v1(35.69,73.26) 35.69,72.22 37.59,70.32 37.59,65.5 40.64,62.45 40.64,55.4 43.09,52.94 48.31,52.94 48.51,52.75 49.29,52.75 v1(49.53,52.51)
  L4 w0.508: v1(128.04,9.33) 127.33,10.04 123.74,10.04 123.14,9.45 119.17,9.45 119.03,9.59 118.49,9.59 117.09,8.19 112.6,8.19 v1(112.04,8.75) 106.38,8.75 105.87,9.26 v1(98.3,9.26)
  L4 w0.635: 263.75,26.27 264.08,26.6 266.88,26.6 267.59,25.89 v1(267.59,25.51)
  L4 w0.762: v1(49.53,52.51) 51.21,50.84 56.36,50.84 v3(57.23,51.7)
  L6 w0.508: 33.53,19.97 33.53,17.1 34.47,16.17 36.71,16.17 37.27,15.61 37.96,14.91 37.96,11.55 v1(39.62,9.89)
  L6 w0.61: v1(35.69,73.26) 35.69,72.78 35.11,72.2 32.79,72.2 31.36,73.63 29.58,73.63 v1(29.21,73.26)
  BOTTOM w0.508: v1(277.11,18.76) v2(277.11,19.54) R9202.2 ; v1(98.3,9.26) 92.27,9.26 FC9714.1 91.88,8.88 91.11,8.88 89.71,7.48 86.49,7.48 86.36,7.35 84.71,7.35 84.33,7.73 83.31,7.73 81.69,9.36 77.74,9.36 77.23,9.87 71.57,9.87 69.98,8.28 69.98,8.23 69.61,7.86 68.53,7.86 67.59,8.8 66.05,8.8 FC9715.1 65.72,8.81 64.87,9.66 60.47,9.66 59.44,8.63 v1(59.44,7.99) ; v3(258.47,27.87) 258.7,28.1 C6001.1 ; FAN261.2 210.19,50.12 209.64,49.58 v1(208.91,49.58) ; R6512.2 127.9,8.69 127.9,9.19 v1(128.04,9.33) ; v1(186.26,59.05) 186.39,58.92 186.39,56.97 FC6001.1
  BOTTOM w0.61: C2605.1 209.77,53.59 210.26,53.1 C2611.1 210.19,52.46 FAN261.2 ; v1(16.64,77.96) 16.78,77.82 D5702.3 17.66,78.46 17.96,78.29 18.29,77.96 18.8,77.96 19.3,78.47 19.3,78.52 19.44,78.65 19.44,80.09 20.87,81.52 26.66,81.52 27.66,80.51 27.66,79.98 25.92,78.23 25.92,78.23 D5701.3 24.89,76.06 26.07,74.88 Q5701.G 27.24,73.32 R5710.1 27.43,72.12 28.13,72.82 EC9722.1 28.77,72.82 v1(29.21,73.26)
  BOTTOM w0.635: R6504.1 v3(185.17,48.09)
  vias: v1(30.68,20.86) v1(189.61,56.07) v2(29.21,22.34) v2(67.18,48.5) v2(257.81,28.31) v3(30.1,21.32) v3(56.77,53.33) v3(56.79,52.49) v3(57.71,53.33) v3(57.71,52.49) v3(66.29,49.69) v3(66.29,48.78) v3(66.29,47.81) v3(216.79,9.94) v3(217.47,9.26) v3(237.01,7.15) v3(237.72,7.88) v3(259.66,27.62)
5V_S5: length 448.3
  TOP w0.203: PU8501.26 205.03,67.1 v1(205.1,67.17) ; PU8501.31 202.03,65.29 v1(201.8,65.52) ; U4001.4 v1(54.71,56.05)
  TOP w0.305: v3(27.8,54.85) 27.84,54.89 U3401.1 ; R3405.1 30.66,58.25 v1(30.84,58.43)
  TOP w0.508: 25.53,60.09 25.53,60.82 26.13,61.42 28.2,61.42 28.6,61.03 28.6,60.33 PR4303.1 ; v1(203.53,88.61) 203.02,88.61 201.99,89.63 199.76,89.63 193.68,83.55 193.68,80.35 188.75,75.42 188.75,72.22 189.67,71.3 189.67,70.28 189,69.61 188.14,69.61 v1(185.72,72.02) ; v1(142.62,121.78) 142.37,122.03 142.36,122.03 141.86,122.53 141.86,123.94 140.87,124.93 138.15,124.93 137.67,124.45 134.98,124.45 130.21,119.67 130.2,119.67 129.22,118.69 129.22,118.03 129.87,117.38 129.97,117.38 ; Q6403.E v1(206.88,7.19) Q6404.E 204.52,8.35 204.52,9.12 205.68,10.27 Q6405.E ; v1(114.1,116.89) 114.93,116.06 v1(114.93,115.43) 114.96,115.45 115.65,115.45 116.2,114.89 116.2,113.95 115.47,113.22 PC4807.1 115.11,112.86 v1(114.6,112.35) ; Q6502.E 172.21,42.63 172.21,42.02 v1(172.37,41.85) ; v3(252.4,23.35) 251.49,22.44 247.9,22.44 245.95,24.39 242.04,24.39 v1(241.43,23.78) ; 129.97,117.38 129.03,116.44 v1(127.18,116.44) 127.1,116.44 126.47,117.08 126.47,117.35 126.44,117.37 126.44,117.9 126.47,117.93 126.47,120.29 v1(126.31,120.45) ; 129.97,117.38 v1(130.07,117.38) ; v1(203.48,70.57) 203.48,69.75 PR8510.1 ; PR5118.2 65.38,47.03 64.97,47.03 64.52,47.48 v1(64.52,47.89) ; v1(165.99,58.3) 165.97,58.3 165.65,58.62 162.53,58.62 v1(160.73,60.41) ; v1(166.94,43.86) 166.94,46.43 171.2,50.68 171.2,54.85 171.93,55.59 v1(171.93,55.61)
  TOP w0.635: PU5401.4 163.61,44.56 166.25,44.56 v1(166.94,43.86) 167.23,43.57 PC5407.1
  L3 w0.457: v1(117.58,113.45) 116.48,112.35 v1(114.6,112.35) ; v1(142.62,121.78) 143,121.4 143,113.92 142.37,113.28 142.36,113.28 141.88,112.81 141.33,112.81 140.84,112.33 v1(140.84,110.07) ; v1(151.26,85.3) 151.03,85.08 151.03,82.86 151.1,82.79 151.1,82.21 152.65,80.66 152.65,77.65 155.52,74.78 155.52,71.22 156.16,70.59 156.16,67.07 157.2,66.03 160.06,66.03 160.3,65.78 160.3,65.63 160.32,65.61 160.32,64.56 159.48,63.72 159.48,62.24 159.92,61.81 159.92,61.81 160.58,61.15 160.58,60.56 v1(160.73,60.41)
  L3 w0.508: v1(126.31,120.45) 119.88,120.45 116.64,117.21 116.64,114.49 117.58,113.55 v1(117.58,113.45) ; v1(203.53,88.61) 203.53,89.2 207.14,92.81 207.14,96.58 v1(207.57,97.01) ; 28.45,54.98 28.45,56.5 v3(25.78,59.17) ; v1(171.93,55.61) 170.88,56.66 166.5,56.66 166.05,57.12 166.05,58.24 v1(165.99,58.3) 165.99,59.58 167.02,60.6 167.02,61.08 171.42,65.49 171.42,65.78 171.8,66.15 172.47,66.15 172.59,66.03 175.39,66.03 175.9,65.52 176.4,65.52 176.47,65.58 177.05,65.58 179.66,68.19 182.35,68.19 183.85,69.68 183.85,70.57 185.29,72.02 v1(185.72,72.02) ; v1(30.84,58.43) 29.46,57.06 29.46,54.85 ; v1(142.89,106.33) 142.89,106.34 142.62,106.61 142.62,106.65 141.94,107.33 141.73,107.33 140.84,108.21 v1(140.84,110.07) ; v1(201.8,65.52) 201.14,64.86 201.14,57.9 201.53,57.51 201.68,57.51 202.05,57.14 202.05,56.05 202.44,55.66 203.97,55.66 204.71,54.93 205.53,54.93 206.87,53.58 209.56,53.58 218.64,44.5 229.31,44.5 232.39,41.42 232.68,40.89 233.22,40.26 234.42,39.31 234.42,37.15 237.64,33.92 237.64,30.31 238,29.96 238.74,29.96 239.9,28.8 239.9,28.31 240.92,27.29 240.92,26.59 240.86,26.53 240.86,24.83 241.43,24.27 v1(241.43,23.78)
  L4 w0.457: v1(151.26,85.3) 151.76,85.81 151.76,91.6 153.67,93.51 153.67,96.76 145.57,104.86 143.18,104.86 142.89,105.15 v1(142.89,106.33)
  L4 w0.508: v1(203.53,88.61) 203.53,88.45 202.44,87.36 199.14,87.36 197.61,85.84 197.61,68.06 200.15,65.52 v1(201.8,65.52)
  L4 w0.635: v1(166.94,43.86) 167.46,43.86 168.22,43.1 169.71,43.1 170.88,41.93 172.3,41.93 v1(172.37,41.85)
  BOTTOM w0.203: PU4801.7 113.99,113.2 114.17,113.02 ; PU4701.7 126.36,116.76 ; v1(114.93,115.43) 114.75,115.25 PU4801.3 ; PU4801.36 v1(114.1,116.89) ; PU4701.36 v1(126.31,120.45)
  BOTTOM w0.305: EC9734.1 162.7,59.56 163,59.86 U4002.3 ; PU5001.4 142.36,122.04 v1(142.62,121.78) 143.27,121.78 PC5001.1 ; v1(151.26,85.3) 150.88,85.3 150.43,85.75 150.43,85.9 149.85,86.48 C4034.1
  BOTTOM w0.381: U4006.3 148.8,87.09 149.4,86.48 C4034.1
  BOTTOM w0.508: U3503.5 276.72,26.33 277.5,25.56 277.5,24.02 277.23,23.76 276.52,23.76 v2(275.85,23.08) 275.49,22.73 275.49,20.71 275.7,20.5 R9201.1 ; v1(206.88,7.19) 205.47,7.19 EC9733.1 206.29,6.55 207.52,5.32 208.91,5.32 v1(209.8,4.43) ; v1(130.07,117.38) 129.87,117.38 129.82,117.43 PR4702.2 ; v1(142.89,106.33) 143.2,106.33 143.42,106.55 144.31,106.55 144.53,106.77 144.53,107.03 PR4603.1 ; PR4657.1 141.58,110.13 141.52,110.07 v1(140.84,110.07) ; EC9734.1 160.58,60.26 v1(160.73,60.41) ; v1(201.8,65.52) 203.01,65.52 PC8508.1 203.14,65.83 204.14,66.84 204.77,66.84 v1(205.1,67.17) 205.1,67.55 203.48,69.17 v1(203.48,70.57) ; PC4707.1 v1(127.18,116.44) 126.68,116.44 126.36,116.76 ; v3(25.78,59.17) 25.88,59.07 C3406.1 ; v1(117.58,113.45) 116.91,113.45 PR4803.2 ; v1(114.6,112.35) 114.6,112.58 114.17,113.02 ; v1(207.57,97.01) 207.57,97.19 207.77,97.39 207.77,98.53 207.9,98.66 207.9,98.67 207.9,101.08 209.12,102.3 DB2.1
  BOTTOM w0.635: v1(64.52,47.89) 64.29,48.11 64.29,51.88 61.66,54.52 58.7,54.52 v3(57.18,56.04)
  vias: v1(105.66,3.8) v1(106.68,3.8) v1(275.92,25.36) v1(276.63,25.33) v2(28.45,27.04) v2(46.61,21.45) v2(53.21,7.86) v2(56.26,58.02) v2(106.07,3.24) v2(120.51,4.5) v3(19.68,35.42) v3(20.7,35.42) v3(25.78,28.31) v3(25.78,27.42) v3(26.62,26.15) v3(26.67,28.31) v3(26.67,27.42) v3(27.64,28.36) v3(27.56,27.42) v3(27.61,26.22) v3(27.81,53.96) v3(27.87,53.12) v3(33.12,51.95) v3(33.93,52.28) v3(39.55,8.25) v3(40.39,8.19) v3(44.32,24.34) v3(45.6,24.72) v3(54.03,6.94) v3(55.83,56.25) v3(56.01,57.08) v3(56.5,55.46) v3(56.82,56.8) v3(122.96,5.47) v3(123.88,5.45) v3(124.87,5.45) v3(125.98,5.45) v3(254.81,23.68)
+3V_1D8V_AVDD: length 6.7
  TOP w0.203: v2(29.34,9.36) 28.98,9.71 28.98,9.94 28.1,10.82 HDA27.40
  TOP w0.508: R2713.2 32.38,8.31 C2721.1 31.44,8.28 C2715.1 30.33,8.41 29.68,9.07 29.63,9.07 v2(29.34,9.36)
+3V_AVDD: length 13.4
  TOP w0.203: HDA27.1 26.54,14.85 26.54,14.84 v1(26.67,14.84) ; HDA27.9 22.93,15.87 v1(22.78,16.01)
  TOP w0.508: R2731.2 19.56,18.52 19.82,18.25 R2722.1 19.84,18.06 19.84,17.87 20.32,17.38 v1(20.32,17.13)
  BOTTOM w0.508: C2719.1 23.66,15.16 C2716.1 24.35,15.16 C2717.1 25.72,15.16 26.04,14.84 v1(26.67,14.84) 26.67,15.42 R2724.1 ; C2719.1 21.95,15.16 21.67,15.44 v2(21.67,15.45) 21.66,15.45 21.21,15.9 21.21,16.24 v1(20.32,17.13) ; C2719.1 22.86,15.94 v1(22.78,16.01)
+3VLP: length 4
  TOP w0.102: R2454.1 212.34,18.4 v2(212.78,18.83) 212.32,19.29 R2467.2 211.89,19.3 211.89,21.17 KBC24.120
+5V_AVDD: length 18.2
  TOP w0.203: 21.72,7.83 22.13,8.24 HDA27.26
  TOP w0.508: 21.72,7.83 21.49,7.83 v2(20.95,7.3) 20.55,6.89 20.09,6.89 19.56,6.36 C2710.1 18.58,6.14 C2711.1 17.81,5.98 17.4,6.39 15.67,6.39 v1(15.39,6.67) ; v1(15.98,14.56) 15.98,14.95 16.41,15.38 R2703.1
  L3 w0.508: v1(15.39,6.67) 15.39,13.06 15.98,13.64 v1(15.98,14.56)
+5V_KB_BL: length 5.8
  TOP w0.508: AFTP6248.1 185.92,46.96 185.92,47.6 v4(186.31,47.99) 186.73,48.41 KBLIT1.1
  BOTTOM w0.508: v4(186.31,47.99) 186.31,48.31 C6501.1 184.06,49.45 R6504.2
+5V_PVDD:
  vias: v1(29.72,15.83) v1(30.15,16.32) v1(35.56,9.1) v1(36.2,9.08) v2(30.43,17.08) v2(30.81,9.66)
+V1.00A_SIP: length 55.3
  TOP w0.305: v1(133.02,78.42) 133.02,78.62 133.01,78.63 133.01,80.39 133.44,80.82 133.44,80.88 133.72,81.16 v3(133.83,81.16)
  TOP w0.508: R2111.1 145.58,83.18 141.72,83.18 141.43,83.47
  L3 w0.508: v1(126.2,89.29) 126.11,89.29 v1(124.46,87.64) ; v1(121.52,80.03) 121.52,79.81 121.93,79.4 121.95,79.4 v1(122.18,79.16)
  L4 w0.305: v1(107.31,90.16) 108.02,90.16 109.08,91.21 118.52,91.21 120.9,88.83 123.27,88.83 v1(124.46,87.64)
  BOTTOM w0.127: v3(133.83,81.16) 133.48,81.52 132.72,81.52 132.43,81.23 131.84,81.23 131.83,81.23 131.8,81.21 CPU1.L1 ; CPU1.AB20 120.46,75.31 120.24,75.31 ; 121.57,80.85 121.57,80.62 121.52,80.57 v1(121.52,80.03)
  BOTTOM w0.152: CPU1.A14 124.13,87.06 124.38,87.31 124.38,87.56 v1(124.46,87.64)
  BOTTOM w0.178: v1(133.02,78.42) 132.99,78.39 132.63,78.39 132.46,78.56 CPU1.T1
  BOTTOM w0.203: CPU1.K17 122.08,80.85 120.32,80.85 CPU1.L21 ; CPU1.P18 122.18,79.09 v1(122.18,79.16)
  BOTTOM w0.254: v1(126.2,89.29) 126.2,88.99 126.61,88.59 CPU1.A10
  BOTTOM w0.305: CPU1.AK20 120.56,71.3 120.25,71.61 v1(120.25,71.65)
  BOTTOM w0.508: v1(107.31,90.16) 107.42,90.05 107.85,90.05 107.95,90.16 R1803.2 C2104.1 ; R2108.1 141.48,86.47 v1(141.6,86.6) 141.25,86.95 R2107.1 141.25,88.48 140.89,88.84 139.42,88.84 R2109.1 ; C2116.1 125.73,90.42 126.2,89.95 v1(126.2,89.29)
  vias: v1(120.23,75.81) v2(118.54,73.77)
+V1.00A_XDP: length 2.7
  BOTTOM w0.254: R9927.2 C9904.1 C9902.1 59.44,84.5 R9932.1
+V1.00U_CPU: length 44
  TOP w0.254: 133.68,90.31 132.29,88.92 132.17,88.92 131.1,87.85 131.1,81.32 130.07,80.3 130.07,80.14 129.73,79.79 124.11,79.79 123.66,80.24 FC708.1 ; C721.1 C720.1 118.65,81.33 v1(118.21,80.89) ; v1(134.57,95.34) 134.67,95.24 141.8,95.24 v1(144.53,92.5)
  BOTTOM w0.254: v1(144.53,92.5) 143.55,92.5 R4025.2 ; R4036.1 R2492.1 130.24,97.84 130.45,98.05 132.38,98.05 134.06,96.38 134.82,96.38 C4012.1 134.85,95.62 v1(134.57,95.34) ; CPU1.K20 CPU1.K21 119.56,80.93 118.6,80.93 118.55,80.89 v1(118.21,80.89)
  vias: v2(127.57,79.27)
+V1.00U_CPU_LS:
  vias: v2(143.23,87.79)
+V1.8A_SIP: length 70.6
  TOP w0.305: v2(156.62,63.38) v1(156.03,63.38)
  L3 w0.305: v1(122.17,74.14) 122.2,74.16 122.52,74.16 123.77,75.42 125.86,75.42 125.97,75.53 132.32,75.53 v1(132.61,75.82)
  L3 w0.508: v1(156.03,63.38) 156.03,63.62 156.08,63.67 156.08,64.19 154.32,65.96 154.32,67.59 154.29,67.62 154.29,74.21 152.23,76.26 151.55,76.26 149.99,77.83 149.99,78.35 150.09,78.46 150.09,79.5 146.02,83.56 146.02,85.96 144.33,87.65 136.77,87.65 136.21,88.21 v1(136.01,88.21)
  L4 w0.508: v1(136.01,88.21) 135.98,88.25 135.52,88.25 133.69,86.43 133.69,84.23 133.79,84.13 133.79,82.75 132.34,81.3 132.34,77.75 132.61,77.48 v1(132.61,75.82)
  BOTTOM w0.203: v1(122.17,74.14) 122.62,74.14 123.03,73.73 CPU1.AF16
  BOTTOM w0.254: v1(132.61,75.82) 132.52,75.91 CPU1.AA1
  BOTTOM w0.508: v1(156.03,63.38) 156.59,62.82 C1122.1 157.31,62.46 C2108.1 157.28,61.69 157.28,61.1 157.66,60.72 R1139.2
+V3.3A_SIP: length 65.6
  TOP w0.305: R1731.1 126.15,73.36 124.87,73.36 v1(124.38,72.87)
  TOP w0.381: 123.49,71.56 122.24,71.56 122.07,71.73 R2101.1
  TOP w0.508: v1(134.15,92.82) 134.15,92.8 134.5,92.44 134.5,89.52 134.72,89.3 134.72,88.22 133.2,86.7 v1(133.2,83.88) ; v1(119.2,75.83) 119.2,75.71 118.94,75.44 C2105.1
  L3 w0.305: v1(124.29,78.14) 124.29,78.21 124.74,78.66 124.74,79.51 124.48,79.78 124.14,79.78 123.74,80.18 123.74,81.9 124.36,82.52 124.45,82.52 124.74,82.81 124.74,84.62 125.23,85.11 127.45,85.11 127.58,85.24 131.84,85.24 v1(133.2,83.88) ; v1(119.36,71.96) 119.56,72.16 120.43,72.16 120.44,72.14 120.46,72.14 120.62,71.98 124.21,71.98 v1(124.34,71.85)
  L3 w0.508: v1(124.29,78.14) 124.25,78.14 122.56,76.44 119.81,76.44 v1(119.2,75.83)
  BOTTOM w0.203: v1(124.29,78.14) 124.29,78.16 124.11,78.35 123.58,78.35 CPU1.T16 ; CPU1.V19 121.21,77.09 120.74,76.62 119.79,76.62 119.2,76.03 v1(119.2,75.83) ; CPU1.AJ16 123.6,72.5 123.95,72.5 124.32,72.87 v1(124.38,72.87) ; CPU1.AK15 123.44,70.85 122.81,70.85 122.51,71.15 CPU1.AK17
  BOTTOM w0.254: CPU1.AD15 123.81,74.52 v1(124.33,74) 124.33,73.99 124.33,73.64 124.13,73.44 124.13,73.42 123.81,73.11 CPU1.AG15 ; CPU1.AK15 124.34,71.74 v1(124.34,71.85)
  BOTTOM w0.305: v1(124.27,75.93) 123.95,76.25 CPU1.Y15 CPU1.Y16 ; v1(119.36,71.96) 119.46,72.06 CPU1.AJ21
  BOTTOM w0.508: v1(134.15,92.82) 134.14,92.81 134.14,92.72 134.11,92.7 R1701.1 ; R1112.2 145.06,71.23 C1183.1 144.86,71.44 143.89,71.44 143.38,70.93 140.44,70.93 v2(140.26,70.75) 140.26,70.77 140.13,70.9 137.13,70.9 v3(136.93,70.7)
+VCCAMPHYPLL_1P0: length 28.2
  TOP w0.203: v1(124.23,81.69) 124.08,81.85 123.12,81.85 122.86,82.11 122.86,83.85 122.3,84.41 C2122.1
  TOP w0.254: v2(123.37,85.35) 122.68,84.67 C2122.1
  L3 w0.254: v1(124.23,81.69) 124.79,81.14 125.35,81.14 125.6,81.39 125.6,83.86 125.88,84.14 127,84.14 127.73,84.87 131.54,84.87 133,83.41 134.44,83.41 135.05,84.02 135.05,85.12 135.36,85.43 137.11,85.43 137.26,85.58 v1(138.05,85.58)
  BOTTOM w0.254: CPU1.L15 CPU1.K15 123.97,81.43 123.99,81.43 124.23,81.68 v1(124.23,81.69) ; R2110.2 v1(138.05,85.58)
+VCCAMPHYPLL_1P0_L: length 6.9
  TOP w0.254: C1181.1 146.35,86.01 145.14,84.8 R1102.2 144.41,84.62 C1172.1 143.48,85.54 v2(143.48,85.61) 142.77,85.61 v1(142.11,84.95)
  BOTTOM w0.254: R2110.1 141.48,85.58 v1(142.11,84.95)
+VCCAPLL_1P0: length 29
  TOP w0.254: v1(124.87,77.09) 125.3,76.66 125.9,76.66 126.5,77.26 126.5,77.28 126.83,77.6 127.81,77.6 128.08,77.33 128.08,77.09 128.66,76.52 130.35,76.52 130.91,77.07 133.45,77.07 135.89,79.51 138.73,79.51 141.35,82.13 142.37,82.13 142.77,82.54 v2(143.64,82.54) 146.13,82.54 R2111.2 147.96,82.36 C2123.1
  BOTTOM w0.254: v1(124.87,77.09) 123.82,77.09 CPU1.V15
