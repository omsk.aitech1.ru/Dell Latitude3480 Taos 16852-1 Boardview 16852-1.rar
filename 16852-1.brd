# Allegro board 16852-1.brd (continued)
## Nets (continued)
VCC_CORE: C1101.1 C1102.1 C1103.1 C1116.1 C1117.1 CPU1.A30 CPU1.A34 CPU1.A39 CPU1.A44 CPU1.AK33 CPU1.AK35 CPU1.AK37 CPU1.AK38 CPU1.AK40 CPU1.AL33 CPU1.AL37 CPU1.AL40 CPU1.AM32 CPU1.AM33 CPU1.AM35 CPU1.AM37 CPU1.AM38 CPU1.G30 CPU1.G32 CPU1.G33 CPU1.G35 CPU1.G37 CPU1.G38 CPU1.G40 CPU1.G42 CPU1.J30 CPU1.J33 CPU1.J37 CPU1.J40 CPU1.K33 CPU1.K35 CPU1.K37 CPU1.K38 CPU1.K40 CPU1.K42 CPU1.K43 FC701.1 FC702.1 FC1001.1 FC1002.1 FC1003.1 FC4702.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1030.1 PG4708.2 PL4701.2 PT4702.1 R719.1
VCC_OPC_1P8_H63: CPU1.H63 TP704.1
VCC_SENSE: CPU1.E32 PR4648.1 R719.2
VCCGT_SENSE: CPU1.J70 PR4617.1 R721.2
VCCRTCEXT: C2112.1 CPU1.BB10
VCCSA_SENSE: CPU1.H20 PR4607.1 R735.2
VCCSTG_EN: R4014.1 R4018.2 R9936.1 U4003.4
VCCSTG_EN_R: R4014.2 U4002.4
VCCSTU_EN: EC4001.1 R4023.2 R4024.1 R4026.2 U4005.4
VCCSTU_EN_R: R4024.2 U4006.4
VDD10: C3102.1 C3103.1 C3105.1 C3106.1 C3111.1 C3113.1 C3114.1 C3117.1 L3101.2 LOM31.3 LOM31.8 LOM31.22 LOM31.30
VDDREG: C3107.1 C3116.1 LOM31.23 R3103.2
VSS_AY71: CPU1.AY71 R602.1
VSS_MECH1: GPU1.A32 TP7701.1
VSS_MECH2: GPU1.AM1 TP7702.1
VSS_MECH3: GPU1.AM32 TP7703.1
VSS_SENSE: CPU1.E33 PR4645.1 R720.1
VSSGT_SENSE: CPU1.J69 PR4618.1 R722.1
VSSRHA: GPU1.L16 TP7801.1
VSSSA_SENSE: CPU1.H21 PR4604.1 R734.1
0D6V_PWR: PC5124.1 PG5120.1 PG5121.1 PU5102.3 PU5102.5
0D6V_S0: C1223.1 C1224.1 C1225.1 C1226.1 C1227.1 C1230.1 C1324.1 C1325.1 C1326.1 C1327.1 DM1.258 DM2.258 FC1301.1 FC9712.2 FC9713.2 PG5120.2 PG5121.2
0D95V_VGA_EN: PR8603.1 PR8621.1 PR8625.2
0D95V_VGA_EN_R: D8601.2 PC8607.1 PR8621.2 PU8601.7
0D95V_VGA_S0: C8010.1 C8011.1 C8012.1 C8013.1 C8015.1 C8016.1 C8057.1 C8065.1 GPU1.L23 GPU1.L24 GPU1.L25 GPU1.L26 GPU1.M22 GPU1.N22 GPU1.N23 GPU1.N24 GPU1.R21 GPU1.R22 GPU1.T22 GPU1.U21 GPU1.U22 GPU1.V22 L8003.1 PG8603.2 PG8604.2 R7618.1 R7622.1 R7705.1
0D95V_VGA_S0_PG: PG8655.1 PR8624.2 PU8601.2
1D0V_PWR: PC5301.1 PC5303.1 PC5305.1 PC5306.1 PG5301.1 PG5302.1 PG5303.1 PG5304.1 PG5305.1 PG5306.1 PG5310.2 PG5311.1 PG5312.1 PL5301.2
1D0V_S5: C4013.1 C4016.1 EC1716.1 PG5301.2 PG5302.2 PG5303.2 PG5304.2 PG5305.2 PG5306.2 PG5311.2 PG5312.2 R1117.1 R1118.1 R1724.1 R1735.1 R2402.1 R9927.1 U4002.1 U4002.2 U4002.9 U4006.1 U4006.2 U4006.9 XDP1.43 XDP1.44
1D0V_S5_PWRGD: PR5305.1 R4029.1
1D2V_S3: C718.1 C719.1 C1202.1 C1203.1 C1204.1 C1205.1 C1206.1 C1208.1 C1209.1 C1210.1 C1214.1 C1215.1 C1216.1 C1217.1 C1218.1 C1219.1 C1221.1 C1303.1 C1304.1 C1305.1 C1306.1 C1307.1 C1308.1 C1309.1 C1310.1 C1315.1 C1316.1 C1317.1 C1318.1 C1319.1 C1320.1 C1321.1 C1322.1 CPU1.AL23 CPU1.AU23 CPU1.AU28 CPU1.AU35 CPU1.AU42 CPU1.BB23 CPU1.BB32 CPU1.BB41 CPU1.BB47 CPU1.BB51 DM1.12 DM1.33 DM1.54 DM1.75 DM1.96 DM1.111 DM1.112 DM1.117 DM1.118 DM1.123 DM1.124 DM1.129 DM1.130 DM1.135 DM1.136 DM1.141 DM1.142 DM1.147 DM1.148 DM1.153 DM1.154 DM1.159 DM1.160 DM1.163 DM1.178 DM1.199 DM1.220 DM1.241 DM2.12 DM2.33 DM2.54 DM2.75 DM2.96 DM2.111 DM2.112 DM2.117 DM2.118 DM2.123 DM2.124 DM2.129 DM2.130 DM2.135 DM2.136 DM2.141 DM2.142 DM2.147 DM2.148 DM2.153 DM2.154 DM2.159 DM2.160 DM2.163 DM2.178 DM2.199 DM2.220 DM2.241 EC1001.1 EC1002.1 EC1004.1 EC1059.1 EC1060.1 EC1062.1 EC1063.1 EC1220.1 FC705.1 FC1005.1 FC1006.1 FC9711.2 FC9716.2 PC1055.1 PC1056.1 PC1057.1 PC1058.1 PC1061.1 PC1064.1 PG5106.2 PG5107.2 PG5108.2 PG5109.2 PG5111.2 R505.1 R705.1 R1215.1 R1312.1 RN1201.1(A) RN1301.1(A)
1D2V_VTT_PWRGD: PG5114.1 R4011.1
1D5V_VGA_S0: C8001.1 C8003.1 C8004.1 C8005.1 C8006.1 C8007.1 C8009.1 C8014.1 C8031.1 C8032.1 C8033.1 C8034.1 C8042.1 C8129.1 C8130.1 C8131.1 C8132.1 C8133.1 C8134.1 C8135.1 C8136.1 C8137.1 C8138.1 C8139.1 C8140.1 C8141.1 C8142.1 C8143.1 C8144.1 C8145.1 C8148.1 C8149.1 C8150.1 C8151.1 C8152.1 C8153.1 C8154.1 C8155.1 C8156.1 C8157.1 C8158.1 C8201.1 C8202.1 C8203.1 C8204.1 C8205.1 C8206.1 C8207.1 C8208.1 C8209.1 C8210.1 C8211.1 C8212.1 C8213.1 C8214.1 C8215.1 C8216.1 C8217.1 C8218.1 C8219.1 C8220.1 C8222.1 C8223.1 C8224.1 C8225.1 C8226.1 C8227.1 C8228.1 C8229.1 EC9725.1 GPU1.H13 GPU1.H16 GPU1.H19 GPU1.J9 GPU1.J10 GPU1.J23 GPU1.J24 GPU1.K9 GPU1.K10 GPU1.K23 GPU1.K24 GPU1.L11 GPU1.L12 GPU1.L13 GPU1.L20 GPU1.L21 GPU1.L22 PG8656.2 PG8657.2 PG8658.2 PG8660.2 R7802.1 R7807.1 R7810.1 R7817.1 R8204.1 VRAM1.A1 VRAM1.A8 VRAM1.B2 VRAM1.C1 VRAM1.C9 VRAM1.D2 VRAM1.D9 VRAM1.E9 VRAM1.F1 VRAM1.G7 VRAM1.H2 VRAM1.H9 VRAM1.K2 VRAM1.K8 VRAM1.N1 VRAM1.N9 VRAM1.R1 VRAM1.R9 VRAM2.A1 VRAM2.A8 VRAM2.B2 VRAM2.C1 VRAM2.C9 VRAM2.D2 VRAM2.D9 VRAM2.E9 VRAM2.F1 VRAM2.G7 VRAM2.H2 VRAM2.H9 VRAM2.K2 VRAM2.K8 VRAM2.N1 VRAM2.N9 VRAM2.R1 VRAM2.R9 VRAM3.A1 VRAM3.A8 VRAM3.B2 VRAM3.C1 VRAM3.C9 VRAM3.D2 VRAM3.D9 VRAM3.E9 VRAM3.F1 VRAM3.G7 VRAM3.H2 VRAM3.H9 VRAM3.K2 VRAM3.K8 VRAM3.N1 VRAM3.N9 VRAM3.R1 VRAM3.R9 VRAM4.A1 VRAM4.A8 VRAM4.B2 VRAM4.C1 VRAM4.C9 VRAM4.D2 VRAM4.D9 VRAM4.E9 VRAM4.F1 VRAM4.G7 VRAM4.H2 VRAM4.H9 VRAM4.K2 VRAM4.K8 VRAM4.N1 VRAM4.N9 VRAM4.R1 VRAM4.R9
1D8V_EN#: Q2702.D R2715.2 R2733.1
1D8V_EN_R#: C2722.2 Q2701.G R2733.2
1D8V_PWR: PC5409.1 PC5410.1 PC5412.1 PG5401.1 PG5402.1 PR5410.1 PU5401.6
1D8V_S0: C2725.1 Q2701.D R2713.1 R2726.1
1D8V_S5: C2722.1 C2724.1 PC8634.1 PC8635.1 PG5401.2 PG5402.2 PQ8607.S PR8650.1 Q2701.S R1139.1 R2715.1
1D8V_S5_PWROK: PR5414.1 R4030.1
1D8V_VGA_EN: D8601.1 PC8612.1 PQ8608.G PR8603.2
1D8V_VGA_EN#: PQ8608.D PR8650.2 PR8651.1
1D8V_VGA_EN_R#: PC8634.2 PQ8607.G PR8651.2
1D8V_VGA_S0: C7904.1 C8002.1 C8008.1 C8017.1 GPU1.AA20 GPU1.AA21 GPU1.AB20 GPU1.AB21 GPU1.AD17 GPU1.AM30 L8001.1 L8002.1 PC8636.1 PQ8607.D PR8546.1 R7704.1 R7926.1 R7928.1 R7930.1 R7932.1 RN7905.3(B) RN7905.4(B)
2D5V_S3: C1207.1 C1211.1 C1212.1 C1213.1 C1231.1 C1232.1 C1311.1 C1312.1 C1313.1 C1314.1 C1330.1 C1331.1 DM1.257 DM1.259 DM2.257 DM2.259 FC9715.2 PG5404.2 PG5405.2
3D3V_AUX_KBC_33: C2423.1 KBC24.54 R2462.1
3D3V_AUX_KBC_R: DB3.1 R2476.1
3D3V_AUX_S5: D2501.1 PG4507.1 PR4420.1 PR4421.1 R1726.2 R1727.1 R1737.1 R2467.1 R2472.2 R4004.1 R6102.1 R6211.1
3D3V_CAMERA_S0: C5539.1 FC5503.1 LCD1.32 R5532.2
3D3V_CPM_Z32H: C9107.1 C9108.1 C9109.1 C9110.1 R9122.1 R9123.1 U9102.9 U9102.20 U9102.25
3D3V_LAN_S5: C3101.1 C3109.1 C3115.1 C3118.1 C3120.1 LOM31.11 LOM31.32 Q3104.D R3103.1
3D3V_MSATA_S0: C6012.1 C6013.1 C6014.1 FC6005.1 HDD1.26 HDD1.27 HDD1.28 HDD1.29 HDD1.30 R6008.2 R6009.2
3D3V_RUN_FFS: C6701.1 C6702.1 C6703.1 R6701.2 U6701.2 U6701.3 U6701.9 U6701.10
3D3V_S0: C1228.1 C1328.1 C1329.1 C2601.1 C2602.1 C4004.1 C5505.1 C5621.1 C5622.1 C5623.1 C6010.1 C6011.1 C9111.1 DB1.1 DM1.255 DM2.255 EC9735.1 EC9736.1 EC9737.1 FC6002.1 FC9705.1 FC9706.1 FC9707.1 FC9708.1 FC9709.1 FC9710.2 FC9738.1 IOBD3.16 IOBD4.2 PC8601.1 PQ8609.S PR4614.1 PR8601.1 PR8619.1 Q1801.2 Q1801.5 Q2601.2 Q2601.5 Q5702.2 Q5702.5 Q5703.C Q9101.G R414.1 R506.1 R802.2 R803.1 R804.1 R1204.2 R1208.2 R1211.2 R1216.1 R1302.2 R1306.2 R1310.2 R1608.1 R1609.1 R1818.2 R1838.1 R2002.1 R2005.1 R2006.1 R2017.1 R2023.1 R2046.2 R2048.2 R2049.2 R2050.1 R2051.1 R2052.1 R2429.2 R2430.2 R2603.1 R2604.1 R2729.1 R2731.1 R3107.1 R4005.1 R5521.1 R5522.1 R5529.2 R5532.1 R5608.2 R5610.2 R5612.2 R5614.2 R5617.1 R5619.1 R6008.1 R6009.1 R6401.1 R6517.1 R6520.2 R6701.1 R6702.1 R6703.1 R6704.1 R9102.2 R9120.2 R9122.2 R9141.2 R9145.1 R9937.1 RN801.1(A) RN801.2(A) RN1803.1(A) RN1803.2(A) RN1803.3(A) RN1803.4(A) RN1804.3(B) RN1804.4(B) RN1810.1(A) RN1810.2(A) RN2001.5(B) RN2001.6(B) RN2001.7(B) RN2001.8(B) RN2002.1(A) RN2002.2(A) RN2007.3(B) RN2007.4(B) RN2008.3(B) RN2008.4(B) RN2602.1(A) RN2602.2(A) THM26.1 U4001.8 U4001.9 U5501.4 U5501.5 U5601.7 U5601.10 U5601.20 U9103.2 U9103.6
3D3V_S5: C2415.1 C2416.1 C2421.1 C3121.1 C3122.1 C4014.1 C4102.1 C7002.1 FC2402.1 FC2403.1 FC5402.1 LIDSW1.2 PC5110.1 PC5403.1 PC5408.1 PC8603.1 PC8655.1 PD4302.2 PG4501.1 PG4502.1 PG4503.1 PG4522.1 PG4526.1 PG8601.1 PG8602.1 PR4304.1 PR4450.2 PR4508.1 PR5104.1 PR5409.1 PR5415.1 PR8539.2 PR8606.1 PR8624.1 PR8673.1 PU5101.15 PU5401.3 PU5402.3 PU8651.15 Q2417.2 Q2417.5 Q2418.2 Q2418.5 Q3104.S R507.1 R1504.1 R1610.1 R1711.1 R1714.1 R2413.2 R2434.1 R2438.2 R2442.1 R2443.1 R2446.1 R3106.2 R3109.1 R4026.1 R4031.1 R4101.1 R6118.1 R6521.2 R7001.2 R9101.2 R9123.2 R9143.1 R9601.1 R9602.1 R9603.1 R9604.2 R9606.2 R9608.2 R9610.2 R9612.2 R9805.1 R9909.1 R9929.1 RN1701.5(B) RN1701.6(B) RN1701.7(B) RN1701.8(B) RN2405.5(B) RN2405.6(B) RN2405.7(B) RN2405.8(B) RN2406.3(B) RN2406.4(B) U4001.6 U4001.7 U4003.5 U4005.5 U4101.2 U4101.3 U6101.1 U6101.2 U6101.5 U6101.6 U6201.1 U6201.2 U6201.5 U6201.6
3D3V_S5_IT8010: C9601.1 R9601.2 U9601.18
3D3V_S5_KBC: C2410.1 C2411.1 C2412.1 C2413.1 C2414.1 C2417.1 C2420.1 C2422.1 C2429.1 ED4304.2 ED4305.2 ED4306.2 FC2401.1 FC9713.1 FC9714.2 KBC24.5 KBC24.19 KBC24.22 KBC24.43 KBC24.65 KBC24.82 KBC24.103 KBC24.115 PR4411.1 PR4412.1 R2414.2 R2415.2 R2420.2 R2446.2 R2450.2 R2455.2 R2456.1 R2462.2 R2476.2 R2478.2 R2496.2 R2518.2 R2607.1 R4032.1 RN2402.1(A) RN2402.2(A) RN2403.1(A) RN2403.2(A) RN2403.3(A) RN2403.4(A) RN2404.1(A) RN2404.2(A) RN2404.3(A) RN2404.4(A) RN2407.1(A) RN2407.2(A) RN2409.1(A) RN2409.2(A) RN2409.3(A) RN2409.4(A) RN2410.1(A) RN2410.2(A) RN2410.3(A) RN2410.4(A) RN2411.1(A) RN2411.2(A) RN2411.3(A) RN2411.4(A) RN2412.1(A) RN2412.2(A) RN2412.3(A) RN2412.4(A)
3D3V_S5_PCH: C2501.1 C2502.1 C2504.1 C2505.1 C4101.1 Q2401.G Q2604.2 Q2604.5 R411.1 R1112.1 R1814.1 R1820.1 R1821.2 R1822.1 R1824.1 R2007.1 R2039.1 R2461.1 R2501.2 R2515.2 R4101.2 R4103.2 R9103.2 R9146.1 RN1602.1(A) RN1602.2(A) RN1602.3(A) RN1602.4(A) RN1802.1(A) RN1802.2(A) RN1807.1(A) RN1807.2(A) RN1807.3(A) RN1807.4(A) RN1811.1(A) RN1811.2(A) RN2013.1(A) RN2013.2(A) RN2501.3(B) RN2501.4(B) RN2502.3(B) RN2502.4(B) SKT25.8 SPI25.8 SPI252.8
3D3V_S5_WLAN: AFTP5801.1 C6107.1 C6108.1 C6109.1 C6110.1 C6111.1 C6112.1 FC6101.1 R6118.2 U6101.4 WLAN1.2 WLAN1.4 WLAN1.72 WLAN1.74
3D3V_S5_WWAN: AFTP6252.1 C6201.1 C6202.1 C6203.1 FC6201.1 R6201.2 R6202.2 R6203.2 R6204.2 R6208.2 R6209.1 R6217.2 R6227.1 R6302.2 R6303.2 TC6201.1 U6201.4 WWAN1.2 WWAN1.4 WWAN1.70 WWAN1.72 WWAN1.74
3D3V_SPIVCC2: C2506.1 C2507.1 R2420.1 SPI241.8
3D3V_TP_S5_R: C6503.2 Q6504.S R6520.1 R6521.1
3D3V_TPM: C9101.1 C9102.1 C9104.1 C9105.1 C9112.1 Q9102.S Q9103.G R9101.1 R9102.1 R9103.1 R9114.1 R9119.1 R9138.1 R9140.1 R9147.1 R9149.1 U9101.8
3D3V_TPM_1: C9106.1 C9113.1 R9143.2 R9144.1
3D3V_VGA_S0: C2621.1 C2622.1 C8024.1 GPU1.AA17 GPU1.AA18 GPU1.AB17 GPU1.AB18 PC8604.1 PC8605.1 PQ8609.D PR8503.1 PR8505.1 PR8518.1 PR8601.2 PR8609.2 PR8625.1 Q2606.G Q7901.2 Q7901.5 R2616.1 R2617.1 R7625.1 R7903.2 R7921.1 R7935.1 R7942.1 RN7902.3(B) RN7902.4(B) THM263.1
81208_AGND: PC4604.1 PC4609.2 PC4613.2 PC4615.1 PC4619.2 PC4626.2 PC4628.2 PC4629.2 PC4630.2 PC4631.2 PC4632.2 PC4633.2 PG4601.1 PR4602.1 PR4611.2 PR4613.2 PR4628.2 PR4632.1 PR4635.2 PR4636.2 PR4658.2 PR4659.2 PR4660.2 PR4662.2 PR4663.2 PR4664.2 PU4601.49
+DC_IN: AFTP4303.1 AFTP4305.1 AFTP4306.1 EL4301.2 EL4302.2 PC4301.1 PC4302.1 PD4301.K PQ4305.2 PR4307.1 PR4312.1 PR4314.1 PU4301.1 PU4301.2 PU4301.3
+DC_IN_C: DCIN1.1 DCIN1.2 EC4301.1 EC4302.1 EC4303.1 EC4304.1 EL4301.1 EL4302.1
+RTC_VCC: AFTP2502.1 R2502.2 RTC1.1
+SDC_IN: PG4402.1 PR4402.1 PR4403.1 PR4410.1 PU4402.1 PU4402.2 PU4402.3
+UZ12_TPM: C9114.1 C9117.1 R9145.2 R9146.2 U9104.8
+V_VREF_PATH1: C1222.2 R1209.1
+V_VREF_PATH2: C1323.2 R1309.1
A5_TP: CPU1.A5 TP2309.1
A67_TP: CPU1.A67 TP2311.1
A70_TP: CPU1.A70 TP2310.1
A_A0: R9608.1 R9609.2 U9601.3
A_A1: R9606.1 R9607.2 U9601.2
A_A2: R9604.1 R9605.2 U9601.1
AC_DIS: KBC24.69 PQ4304.B PQ4306.5 PQ4403.G
AC_DIS_M: PQ4403.D PR4422.2 PU4403.4
AC_IN#_G: PQ4306.2 PR4312.2 PR4313.1
AC_IN_KBC#: AFTP4316.1 PQ4306.6
AC_PRESENT: CPU1.AY15 D1703.A EC1707.1 Q1702.3 RN1701.4(A)
ACAV_IN: KBC24.128 R2469.2
ACOK_IN: PQ4402.2 PR4416.1
AD+: FC4301.1 PC4303.1 PC4304.1 PC4305.1 PC4306.1 PD4402.A PR4405.1 PR4408.1 PR4422.1 PR4430.1 PR4431.1 PU4301.5 PU4301.6 PU4301.7 PU4301.8 PU4402.5 PU4402.6 PU4402.7 PU4402.8
AD+_G_1: PQ4402.5 PQ4402.6 PR4406.1
AD+_G_2: PR4403.2 PR4406.2 PU4402.4
AD_IA: PC4423.1 PG4401.2 R2421.1
AD_OFF_L: PQ4304.C PQ4305.1
AD_OFF_R: PC4301.2 PQ4305.3 PR4307.2 PR4308.1 PU4301.4
ALL_SYS_PWRGD: D4002.1 EC1709.1 R1716.1 R2481.2 R4002.1 R4005.2 R4011.2
ALWON: KBC24.121 R4009.2
AMBER_LED_BAT: EC6402.1 Q6403.C R6407.1
ATI_RST#: D7601.3 R7621.1 R7623.2 R7625.2
AUD_AGND: C2702.1 C2705.1 C2710.2 C2711.2 C2712.1 C2713.2 C2715.2 C2721.2 EC2703.1 EC2704.1 EC2705.1 EC2706.1 EC2707.1 EC2905.2 EC2906.2 EC2907.2 EC2908.2 EC9739.1 EC9743.1 EC9744.1 EC9745.1 HDA27.25 HDA27.38 HPMIC1.MS R2706.1 R2707.2 R2711.1 R2727.1 R2730.1 R2901.2 R2919.2 R2920.2
AUD_HP1_JACK_L: HDA27.32 R2908.1
AUD_HP1_JACK_L1: EC2907.1 R2907.1 R2908.2 R2912.2 R2919.1 R2922.2
AUD_HP1_JACK_R: HDA27.33 R2910.1
AUD_HP1_JACK_R1: EC2908.1 R2909.1 R2910.2 R2913.2 R2920.1 R2921.2
AUD_PC_BEEP_3246: HDA27.16 R2723.1
AUD_PC_BEEP_C: C2720.1 D2701.3 R2717.1
AUD_PC_BEEP_R: C2720.2 R2723.2
AUD_PORTA_L_HPMIC1: ED2903.1 HPMIC1.1 R2907.2
AUD_PORTA_R_HPMIC1: ED2901.2 HPMIC1.2 R2909.2
AUD_SENSE: R2709.2 R2923.2
AUD_SENSE_A: HDA27.13 R2709.1 R2722.2
AUD_SPK_L+: EC2904.2 EL2904.2 HDA27.42
AUD_SPK_L+_C: AFTP2902.1 EC2909.1 EL2904.1 SPK1.1
AUD_SPK_L-: EC2903.2 EL2903.2 HDA27.43
AUD_SPK_L-_C: AFTP2901.1 EC2910.1 EL2903.1 SPK1.2
AUD_SPK_R+: EC2902.2 EL2902.2 HDA27.45
AUD_SPK_R+_C: AFTP2904.1 EC2911.1 EL2902.1 SPK1.3
AUD_SPK_R-: EC2901.2 EL2901.2 HDA27.44
AUD_SPK_R-_C: AFTP2903.1 EC2912.1 EL2901.1 SPK1.4
AUD_VREF: C2705.2 HDA27.28
AUX_EN_WOWL: R1721.2 R6104.1 R9613.2
AUX_EN_WOWL_GP0: R9613.1 U9601.9
AUX_EN_WOWL_R: CPU1.BB17 R1721.1
B71_TP: CPU1.B71 TP2312.1
BA1_TP: CPU1.BA1 TP2305.1
BA2_TP: CPU1.BA2 TP2306.1
BA71_TP: CPU1.BA71 TP2303.1
BAT1_LED#: KBC24.1 Q2417.1 RN2405.1(A)
BAT2_LED#: KBC24.106 Q2417.4 RN2405.2(A)
BAT_AMBER: AFTP6308.1 LEDBD1.1 R6407.2
BAT_WHITE: AFTP6307.1 LEDBD1.2 R6406.2
BATT_WHITE_LED#: Q2417.6 Q6401.D Q6406.4
BATT_WHITE_LED#_M: Q6406.3 R6404.1
BATT_WHITE_LED_R#: Q6404.B R6404.2
BB67_TP: CPU1.BB67 TP2302.1
BB70_TP: CPU1.BB70 TP2301.1
BEEP: KBC24.45 RN2701.1(A)
BKLGT_PWM: KBC24.44 Q6501.G R6505.1
BKLT_CTRL: D5503.3 R5524.1 RN5502.6(B) RN5503.7(B)
BLON_OUT: R2439.1 R2480.2 RN5503.6(B)
BLON_OUT_C: LCD1.21 RN5502.8(B) RN5503.3(A)
BLUETOOTH_EN: CPU1.AB2 D6102.K R2002.2
BLUETOOTH_EN_NGFF: AFTP5804.1 D6102.A WLAN1.54
BOARD_ID: C2408.2 KBC24.111 R2443.2 R2444.1
BOARD_ID2: CPU1.AB3 R2005.2 R2008.1
BOOST_MON: PC4424.1 PG4414.2 R2423.1
BP_PWRGD_RST#: C9901.1 R9926.2 XDP1.41
BT+: AFTP4313.1 AFTP4314.1 AFTP4315.1 BATT1.1 BATT1.2 BATT1.3 EC4314.1 PC4415.1 PC4416.1 PC4417.1 PC4418.1 PC4419.1 PD4304.K PD4405.A PG4413.2 PG4417.2 PR4415.2
BT+_1: PG4417.1 PR4414.2
CAP_LED: AFTP6243.1 KB1.4 R6506.2
CAP_LED#: KBC24.93 Q2418.1 RN2405.3(A)
CAP_LED#_S: EC6507.1 Q2418.6 R6508.1
CAP_LED_Q: Q6502.C R6506.1
CAP_LED_R#: Q6502.B R6508.2
CASA0#: GPU1.G19 VRAM1.K3 VRAM2.K3
CASA1#: GPU1.G16 VRAM3.K3 VRAM4.K3
CBN: C2703.1 HDA27.35
CBP: C2703.2 HDA27.37
CFG0: CPU1.E68 R9611.1 XDP1.9
CFG1: CPU1.B67 XDP1.11
CFG2: CPU1.D65 XDP1.15
CFG3: CPU1.D67 R604.1 R9902.1 XDP1.17
CFG4: CPU1.E70 R605.1 XDP1.27
CFG5: CPU1.C68 XDP1.29
CFG6: CPU1.D68 XDP1.33
CFG7: CPU1.C67 XDP1.35
CFG8: CPU1.F71 XDP1.10
CFG9: CPU1.G69 XDP1.12
CFG10: CPU1.F70 XDP1.16
CFG11: CPU1.G68 XDP1.18
CFG12: CPU1.H70 XDP1.28
CFG13: CPU1.G71 XDP1.30
CFG14: CPU1.H69 XDP1.34
CFG15: CPU1.G70 XDP1.36
CFG16: CPU1.E63 XDP1.6
CFG17: CPU1.F63 XDP1.4
CFG18: CPU1.E66 XDP1.24
CFG19: CPU1.F66 XDP1.22
CFG_RCOMP: CPU1.E60 R601.1
CHARGER_SRC: PC4405.1 PC4407.1 PC4409.1 PC4410.1 PC4411.1 PG4404.2 PG4405.2 PG4406.2 PG4407.2 PU4404.5 PU4404.6 PU4404.7 PU4404.8
CHG_AGND: PC4403.1 PC4404.1 PC4412.1 PC4421.2 PC4422.2 PC4423.2 PC4424.2 PG4411.1 PR4423.2 PR4424.2 PR4425.2 PU4401.29
CHG_AMBER_LED#: Q2417.3 Q6406.1
CHG_AMBER_LED#_M: Q6406.6 R6405.1
CHG_AMBER_LED_R#: Q6403.B R6405.2
CKEA0: GPU1.K20 VRAM1.K9 VRAM2.K9
CKEA1: GPU1.J17 VRAM3.K9 VRAM4.K9
CL_CLK: CPU1.G3 R6109.1
CL_CLK_R: R6109.2 WLAN1.42
CL_DATA: CPU1.G2 R6119.1
CL_DATA_R: R6119.2 WLAN1.40
CL_RST#: CPU1.G1 EC1805.1 R6108.1
CL_RST#_R: R6108.2 WLAN1.38
CLK_ITE8010: R2474.2 R9602.2 U9601.19
CLK_LAN_REQ4#_R: LOM31.12 R3113.2
CLK_PCI_LPC: DB1.9 R9121.2 R9127.2
CLK_PCI_LPC_MEC: EC1801.1 KBC24.57 R1805.2
CLK_PCI_LPC_R: R9127.1 U9103.8
CLK_PCIE_N5_WWAN#: CPU1.E40 WWAN1.53
CLK_PCIE_P5_WWAN: CPU1.E38 WWAN1.55
CLK_TP_SIO: EC6503.1 KBC24.78 RN6503.1(A) RN6504.4(B)
CLKA0: GPU1.H26 R7805.1 VRAM1.J7 VRAM2.J7
CLKA0#: GPU1.H25 R7806.1 VRAM1.K7 VRAM2.K7
CLKA0_CLKA0#: C8146.1 R7805.2 R7806.2
CLKA1: GPU1.G9 R8201.1 VRAM3.J7 VRAM4.J7
CLKA1#: GPU1.H9 R8202.1 VRAM3.K7 VRAM4.K7
CLKA1_CLKA1#: C8221.1 R8201.2 R8202.2
CLKREQ_PCIE#1: CPU1.AT7 R6112.2 RN1803.5(B)
CLKREQ_PCIE#2: CPU1.AT8 R3113.1 RN1803.7(B)
CLKREQ_PCIE#3: CPU1.AT10 RN1804.2(A)
CLKREQ_PCIE#4: CPU1.AU8 RN1804.1(A)
CLKREQ_PCIE#5: AFTP6257.1 CPU1.AU7 R6208.1 RN1803.6(B) WWAN1.52
CLKREQ_PEG#0: CPU1.AR10 Q7903.D R7943.2 RN1803.8(B)
CLKRUN#: KBC24.63 R1819.2 R2401.1
CLKRUN#_R: CPU1.AW11 R1818.1 R1819.1
CLKTESTA: C7822.1 GPU1.K8
CLKTESTA_C: C7822.2 R7821.1
CLKTESTB: C7821.1 GPU1.L7
CLKTESTB_C: C7821.2 R7820.1
CMP_VOUT0: KBC24.85 R2602.2 R2607.2 R2612.2
CMP_VOUT1: KBC24.83 Q2408.G R2417.1 R2418.1
CPM_RST_R: Q9103.S R9124.1 R9125.2 U9102.18
CPU_A16_TP: CPU1.BB9 TP1902.1
CPU_D1_TP: CPU1.M2 TP1801.1
CPU_D3_TP: CPU1.J4 TP1807.1
CPU_D4_TP: CPU1.V1 TP1804.1
CPU_D5_TP: CPU1.V2 TP1805.1
CPU_D6_TP: CPU1.M1 TP1806.1
CPU_DP1_CTRL_CLK: CPU1.L13 Q5702.4 RN801.4(B)
CPU_DP1_CTRL_DATA: CPU1.L12 Q5702.1 RN801.3(B)
CPU_DP1_HPD: CPU1.L9 R5719.1
CPU_DP2_CTRL_CLK: CPU1.N7 R803.2
CPU_DP2_CTRL_DATA: CPU1.N8 R804.2
CPU_DP2_HPD: IOBD4.16 R805.2 R806.1
CPU_DP2_HPD1: CPU1.L7 R805.1
CPU_POPIRCOMP: CPU1.AT16 RN401.4(B)
CPVDD: C2701.1 C2714.1 HDA27.36 R2726.2
CPVEE: C2704.2 HDA27.34
CSA0#_0: GPU1.H22 VRAM1.L2 VRAM2.L2
CSA1#_0: GPU1.G13 VRAM3.L2 VRAM4.L2
CSI2_COMP: CPU1.E13 R1501.1
DAT_ITE8010: R2471.2 R9603.2 U9601.20
DAT_TP_SIO: EC6501.1 KBC24.79 RN6503.2(A) RN6504.3(B)
DBC_EN_R: LCD1.8 R5518.1
DBC_PANEL_EN: CPU1.AM5 R5518.2 RN2001.2(A)
DC_IN_D: PQ4402.3 PR4405.2
DCBATOUT: EC9701.1 EC9702.1 EC9703.1 EC9704.1 EC9705.1 EC9707.1 EC9710.1 EC9712.1 EC9714.1 EC9715.1 EC9716.1 EC9717.1 EC9724.1 EC9726.1 EC9727.1 EC9728.1 F5503.1 FC9701.1 FC9702.1 FC9703.1 FC9704.1 FC9710.1 FC9717.1 FC9718.1 FC9719.1 FC9720.1 FC9721.1 FC9722.1 FC9723.1 FC9724.1 FC9725.1 FC9726.1 FC9727.1 FC9728.1 FC9729.1 FC9730.1 FC9731.1 FC9732.1 FC9733.1 FC9734.1 FC9735.1 FC9736.1 FC9737.1 PC4507.1 PC4518.1 PG4403.1 PG4404.1 PG4405.1 PG4406.1 PG4407.1 PG4504.1 PG4505.1 PG4510.1 PG4511.1 PG4512.1 PG4701.2 PG4702.2 PG4703.2 PG4704.2 PG4705.2 PG4801.1 PG4802.1 PG4803.1 PG4804.1 PG4805.1 PG5001.1 PG5002.1 PG5105.1 PG5110.1 PG5307.1 PG5308.1 PG5309.1 PG8501.1 PG8502.1 PG8503.1 PG8504.1 PG8505.1 PG8506.1 PG8511.1 PG8512.1 PG8513.1 PG8514.1 PG8515.1 PG8516.1 PG8651.1 PG8652.1 PR4402.2 PR4458.1 PR4601.1 PT4703.1 PT4704.1 PU4403.1 PU4403.2 PU4403.3 PU4501.12 R5501.2 R6103.1 R6220.1
DCBATOUT_+VCCSA: FC5001.1 PC5002.1 PC5027.1 PC5029.1 PG5001.2 PG5002.2 PU5002.5 PU5002.6 PU5002.7 PU5002.8
DCBATOUT_CAMERA: C5516.1 C5542.2 EC5505.1 IRCCD1.1 IRCCD1.2 R5501.1
DCBATOUT_LCD: C5515.1 C5535.2 F5503.2 FC5502.1 LCD1.1 LCD1.2
DCBATOUT_VCCGT: FC4801.1 PC4802.1 PC4803.1 PC4804.1 PC4805.1 PC4806.1 PC4811.1 PG4801.2 PG4802.2 PG4803.2 PG4804.2 PG4805.2 PU4801.25 PU4801.26 PU4801.27 PU4801.28 PU4801.29 PU4801.30
DCBATOUT_VCORE: FC4701.1 PC4702.1 PC4703.1 PC4704.1 PC4705.1 PC4710.1 PG4701.1 PG4702.1 PG4703.1 PG4704.1 PG4705.1 PU4701.25 PU4701.26 PU4701.27 PU4701.28 PU4701.29 PU4701.30
DDC_CLK_HDMI: ED5703.4 ED5703.7 HDMI1.15 Q5702.3 RN5702.1(A)
DDC_CLK_PH1: D5701.2 RN5702.4(B)
DDC_DATA_HDMI: ED5703.1 ED5703.10 HDMI1.16 Q5702.6 RN5702.2(A)
DDC_DATA_PH2: D5701.1 RN5702.3(B)
DDPD_CTRLDATA: CPU1.N12 TP802.1
DDR4_DRAMRST#: DM1.108 DM2.108 ED1217.1 ED1302.1 R504.2
DDR_VREF_S3: PC5123.1 PU5102.6
DGPU_HOLD_RST#: CPU1.P3 D7601.2 EC2002.1 R7623.1 RN2009.4(B)
DGPU_PWR_EN: CPU1.U1 PD8501.K PR8661.1 RN2009.3(B)
DGPU_PWR_EN_R: PC8602.1 PQ8604.2 PR8661.2
DGPU_PWROK: CPU1.C8 EC1903.1 EC2401.1 PR8520.2 R1904.2 R2427.1 R7904.1
DGPU_PWROK_KBC: KBC24.24 R2427.2
DGPU_PWROK_R: Q7903.G R7904.2 R7942.2
DMIC_CLK: EC2723.2 FC2701.1 R2716.1 RN5504.4(B)
DMIC_CLK_EDP: EC5501.1 LCD1.27 RN5504.1(A)
DMIC_CLK_R: HDA27.3 R2716.2
DMIC_DATA: R2714.1 RN5504.3(B)
DMIC_DATA_EDP: EC5502.1 LCD1.28 RN5504.2(A)
DMIC_DATA_R: EC2701.1 HDA27.2 R2714.2
DPLL_PVDD: C7710.1 C7711.1 C7713.1 GPU1.AF14 R7704.2
DPLL_VDDC: C7714.1 C7715.1 GPU1.AD14 R7705.2
DQA0_0: GPU1.K27 VRAM1.C8
DQA0_1: GPU1.J29 VRAM1.B8
DQA0_2: GPU1.H30 VRAM1.D7
DQA0_3: GPU1.H32 VRAM1.A7
DQA0_4: GPU1.G29 VRAM1.C2
DQA0_5: GPU1.F28 VRAM1.A2
DQA0_6: GPU1.F32 VRAM1.A3
DQA0_7: GPU1.F30 VRAM1.C3
DQA0_8: GPU1.C30 VRAM1.F8
DQA0_9: GPU1.F27 VRAM1.H3
DQA0_10: GPU1.A28 VRAM1.H7
DQA0_11: GPU1.C28 VRAM1.H8
DQA0_12: GPU1.E27 VRAM1.F7
DQA0_13: GPU1.G26 VRAM1.G2
DQA0_14: GPU1.D26 VRAM1.E3
DQA0_15: GPU1.F25 VRAM1.F2
DQA0_16: GPU1.A25 VRAM2.C2
DQA0_17: GPU1.C25 VRAM2.A2
DQA0_18: GPU1.E25 VRAM2.A3
DQA0_19: GPU1.D24 VRAM2.C3
DQA0_20: GPU1.E23 VRAM2.A7
DQA0_21: GPU1.F23 VRAM2.D7
DQA0_22: GPU1.D22 VRAM2.B8
DQA0_23: GPU1.F21 VRAM2.C8
DQA0_24: GPU1.E21 VRAM2.G2
DQA0_25: GPU1.D20 VRAM2.F2
DQA0_26: GPU1.F19 VRAM2.H3
DQA0_27: GPU1.A19 VRAM2.E3
DQA0_28: GPU1.D18 VRAM2.F7
DQA0_29: GPU1.F17 VRAM2.F8
DQA0_30: GPU1.A17 VRAM2.H8
DQA0_31: GPU1.C17 VRAM2.H7
DQA1_0: GPU1.E17 VRAM4.F8
DQA1_1: GPU1.D16 VRAM4.H8
DQA1_2: GPU1.F15 VRAM4.F2
DQA1_3: GPU1.A15 VRAM4.G2
DQA1_4: GPU1.D14 VRAM4.F7
DQA1_5: GPU1.F13 VRAM4.H7
DQA1_6: GPU1.A13 VRAM4.E3
DQA1_7: GPU1.C13 VRAM4.H3
DQA1_8: GPU1.E11 VRAM3.C3
DQA1_9: GPU1.A11 VRAM3.A3
DQA1_10: GPU1.C11 VRAM3.A2
DQA1_11: GPU1.F11 VRAM3.C2
DQA1_12: GPU1.A9 VRAM3.A7
DQA1_13: GPU1.C9 VRAM3.B8
DQA1_14: GPU1.F9 VRAM3.D7
DQA1_15: GPU1.D8 VRAM3.C8
DQA1_16: GPU1.E7 VRAM3.F8
DQA1_17: GPU1.A7 VRAM3.F7
DQA1_18: GPU1.C7 VRAM3.H7
DQA1_19: GPU1.F7 VRAM3.G2
DQA1_20: GPU1.A5 VRAM3.H3
DQA1_21: GPU1.E5 VRAM3.H8
DQA1_22: GPU1.C3 VRAM3.E3
DQA1_23: GPU1.E1 VRAM3.F2
DQA1_24: GPU1.G7 VRAM4.C8
DQA1_25: GPU1.G6 VRAM4.B8
DQA1_26: GPU1.G1 VRAM4.A3
DQA1_27: GPU1.G3 VRAM4.C3
DQA1_28: GPU1.J6 VRAM4.A7
DQA1_29: GPU1.J1 VRAM4.C2
DQA1_30: GPU1.J3 VRAM4.A2
DQA1_31: GPU1.J5 VRAM4.D7
DQMA0: GPU1.E32 VRAM1.D3
DQMA1: GPU1.E30 VRAM1.E7
DQMA2: GPU1.A21 VRAM2.D3
DQMA3: GPU1.C21 VRAM2.E7
DQMA4: GPU1.E13 VRAM4.E7
DQMA5: GPU1.D12 VRAM3.D3
DQMA6: GPU1.E3 VRAM3.E7
DQMA7: GPU1.F4 VRAM4.D3
DRAM_RST: R7802.2 R7804.1 VRAM1.T2 VRAM2.T2 VRAM3.T2 VRAM4.T2
DRAM_RST_R: C7802.1 R7803.1 R7804.2
DRAM_RST_VGA1: GPU1.L10 R7803.2 R7819.1
DS3_PWRCTL: C4103.1 R4102.2 R4104.2 U4101.4
DSW1: R6302.1 SIM1.DSW1
E51_RX1: TP6102.1 WLAN1.46
E51_RX2: TP6103.1 WLAN1.58
E51_TX1: R6115.2 WLAN1.44
E51_TXD_R: DB3.5 R2466.1
E71_TP: CPU1.E71 TP2314.1
EC_AGND: C2407.1 C2408.1 C2415.2 C2416.2 C2421.2 C2422.2 C2427.2 C2435.2 C2441.2 KBC24.112 R2441.2 R2444.2 R2445.2
EC_MUTE#: KBC24.119 R2708.1 R2724.2
EC_SLP_S0IX#: CPU1.AT11 KBC24.30 R4019.1 R9142.2
EC_SPI_CLK: KBC24.32 R2459.2 RN2401.8(B)
EC_SPI_CS0#: KBC24.27 R2426.1 R2490.1
EC_SPI_CS0#_R: R2426.2 R2518.1 SPI241.1
EC_SPI_MISO: KBC24.29 R2457.1 RN2401.6(B)
EC_SPI_MOSI: KBC24.28 R2460.2 RN2401.7(B)
EC_VTT: C2406.1 KBC24.95 R2402.2 R2440.2 R2492.2
EC_WAKE#: KBC24.35 R1736.1
ECVBAT: C2428.1 KBC24.122 R2451.2 R2452.2 R2472.1 R2473.1
EDP_AUX_CON_N: C5503.1 C5533.2 LCD1.12 R5529.1
EDP_AUX_CON_P: C5502.1 C5531.2 LCD1.11 R5528.1
EDP_AUX_CPU_N: C5533.1 CPU1.E45
EDP_AUX_CPU_P: C5531.1 CPU1.F45
EDP_BKLT_CTRL: D5503.1 R5524.2 R5530.2
EDP_COMP: CPU1.E52 R801.2
EDP_DISP_UTIL: CPU1.B52 TP801.1
EDP_HPD: CPU1.L10 RN5502.7(B) RN5503.5(B)
EDP_HPD_CONN: LCD1.9 RN5503.4(A)
EDP_TX_CON_N0: C5504.1 C5508.2 LCD1.14
EDP_TX_CON_N1: C5507.1 C5534.2 LCD1.17
EDP_TX_CON_P0: C5506.1 C5532.2 LCD1.15
EDP_TX_CON_P1: C5509.1 C5537.2 LCD1.18
EDP_TX_CPU_N0: C5508.1 CPU1.C47
EDP_TX_CPU_N1: C5534.1 CPU1.D46
EDP_TX_CPU_P0: C5532.1 CPU1.C46
EDP_TX_CPU_P1: C5537.1 CPU1.C45
EDP_VDD_EN: CPU1.U13 D5502.1
EDRAM_OPIO_RCOMP: CPU1.H66 RN402.4(B)
EMMC_RCOMP: CPU1.AT1 R1502.1
EN/DEM_VGA: D8602.2 PC8502.1 PD8501.A PQ8501.2 PR8503.2 PR8514.1
EOPIO_RCOMP: CPU1.H65 RN402.3(B)
EXT_PWR_GATE#: CPU1.AM10 R1731.2
FALL_INT2: Q6701.2 Q6701.3 R6703.2
FAN1_DAC: KBC24.47 R2453.1
FAN1_DAC_1: C2401.1 FAN261.4 R2453.2
FAN1_TACH: D2403.A KBC24.40 R2430.1
FAN_TACH1: D2403.K EC2602.1 R2606.1
FAN_TACH1_C: AFTP2802.1 FAN1.2 R2606.2
FAN_VCC1: AFTP2801.1 C2604.1 D2601.K EC2601.1 EC2603.1 FAN1.4 FAN261.3
FBA_VREF_0: C8147.1 R7801.1 R7807.2 VRAM1.H1 VRAM1.M8 VRAM2.H1 VRAM2.M8
FBA_VREF_1: C8230.1 R8204.2 R8206.1 VRAM3.H1 VRAM3.M8 VRAM4.H1 VRAM4.M8
FBA_ZQ0: R7808.2 VRAM1.L8
FBA_ZQ1: R7811.2 VRAM2.L8
FBA_ZQ2: R8205.2 VRAM3.L8
FBA_ZQ3: R8203.2 VRAM4.L8
FFS_INT2: CPU1.AC2 Q6701.5 R6704.2 R6706.1 R6707.1 U6701.11
FFS_INT2_Q: HDD1.11 Q6701.6 R6705.2 R6706.2
FIVR_EN_R: R9611.2 R9906.2 XDP1.45
FON#: FAN261.1 R2605.2
FP_PWR: AFTP8902.1 C9201.1 C9202.1 FPR1.6 R9201.2 R9202.1
GPD2/LAN_WAKE#: CPU1.AM15 R1707.2 R1736.2
GPD11/LANPHYPC: CPU1.AW17 R1709.2 RN1701.1(A)
GPIO16_VGA: GPU1.M4 TP7903.1
GPIO_5_AC_BATT: GPU1.T9 Q7902.D R7921.2
GPIO_8_ROMSO: GPU1.P10 TP7905.1
GPIO_9_ROMSI: GPU1.P4 TP7906.1
GPIO_10_ROMSCK: GPU1.P2 TP7901.1
GPIO_17_THERMAL_INT: GPU1.R6 TP7923.1
GPIO_19_CTF: GPU1.M2 R7922.1
GPIO_22_ROMCS#: GPU1.N8 TP7910.1
GPP_B2/VRALERT#: CPU1.AM11 TP1708.1
GPP_B4/CPU_GP3: CPU1.AY5 TP404.1
GPP_B18/GSPI0_MOSI: CPU1.AR7 R2007.2 R2019.1
GPP_B23/SML1ALERT#: CPU1.AM7 R1820.2
GPP_C2/SMBALERT#: CPU1.R10 R1821.1
GPP_C5/SML0ALERT#: CPU1.W1 R1822.2 R1823.1
GPP_D4/FLASHTRIG: CPU1.B7 R1503.1
GPP_E0/SATAXPCIE0/SATAGP0: CPU1.H2 TP1601.1
GPP_E2/SATAXPCIE2/SATAGP2: CPU1.G4 TP1603.1
GPP_E3/CPU_GP0: CPU1.A6 TP403.1
GPU_ALERT#: R2616.2 THM263.6
GPU_DMINUS: C2623.2 GPU1.T2 THM263.3
GPU_DPLUS: C2623.1 GPU1.T4 THM263.2
GPU_DPRSLP: R7911.1 TP7918.1
GPU_DPRSLP_R: GPU1.U6 R7911.2
GPU_PWR_LEVEL: KBC24.21 R7937.1
GPU_PWR_LEVEL_R: Q7902.G R7937.2
GPU_T_CRIT#: R2617.2 R2618.1 THM263.4
GPU_T_CRIT_R#: Q2606.S R2618.2
H_CATERR#: CPU1.D63 TP401.1
H_CPU_SVIDALRT#: CPU1.B63 R728.2
H_CPU_SVIDCLK: CPU1.A63 R732.1
H_CPU_SVIDDAT: CPU1.D64 R709.1 R726.2
H_CPUPWRGD: CPU1.A68 EC1701.1 EC1710.2 R405.1 TP1709.1
H_PECI: CPU1.A54 R2437.2
H_PROCHOT#: C2403.1 PR4418.1 PR4455.2 PR4624.2 PR4668.2 PR4669.2 R404.1 R2416.2
H_PROCHOT#_EC: Q2408.D R2416.1 R2418.2
H_PROCHOT#_R: CPU1.C65 R403.2
H_PROCHOT#_R_R: R401.2 R403.1 R404.2
H_VCCST_PWRGD: CPU1.B65 R1734.2
H_VCCST_PWRGD_R: EC1708.1 EC1715.1 R1716.2 R1719.1 R1722.2 R1734.1
H_VID3: GPU1.AK10 TP7919.1
H_VID4: GPU1.AM10 TP7920.1
HDA_BITCLK: CPU1.AY22 FC1901.1 RN1901.3(B)
HDA_BITCLK_CODEC_R: HDA27.6 R2720.2
HDA_CODEC_BITCLK: EC1901.2 EC2709.1 R2720.1 RN1901.2(A)
HDA_CODEC_SDIN0: HDA27.8 R2718.2
HDA_CODEC_SDOUT: EC2708.1 R2719.1 RN1901.1(A)
HDA_CODEC_SYNC: HDA27.10 R1908.1
HDA_RST#: CPU1.AW22 TP1903.1
HDA_SDIN0: CPU1.BA21 R2718.1
HDA_SDOUT: CPU1.BB22 R1909.2 RN1901.4(B)
HDA_SDOUT_CODEC_R: HDA27.5 R2719.2
HDA_SPKR_R: D2701.2 RN2701.3(B)
HDA_SYNC: CPU1.BA22 R1908.2
HDD_DET#: CPU1.U8 EC6001.1 HDD1.10 RN2002.4(B)
HDD_DEVSLP: CPU1.J1 R6007.1
HDD_DEVSLP_R: HDD1.20 R6007.2
HDD_DEW1: R5618.1 R5619.2 U5601.16
HDD_DEW2: R5616.1 R5617.2 U5601.6
HDD_FALL_INT: CPU1.M3 R6702.2 U6701.12
HDMI_CLK: C5704.1 CPU1.G56
HDMI_CLK#: C5701.1 CPU1.F56
HDMI_CLK#_R: C5701.2 R5712.1 RN5701.7(B)
HDMI_CLK#_R_C: ED5702.2 ED5702.9 ER5701.1 HDMI1.12 R5712.2
HDMI_CLK_R: C5704.2 R5714.1 RN5701.8(B)
HDMI_CLK_R_C: ED5702.1 ED5702.10 ER5701.2 HDMI1.10 R5714.2
HDMI_DATA0: C5703.1 CPU1.G53
HDMI_DATA0#: C5709.1 CPU1.F53
HDMI_DATA0#_R: C5709.2 R5715.1 RN5701.5(B)
HDMI_DATA0#_R_C: ED5702.5 ED5702.6 ER5703.1 HDMI1.9 R5715.2
HDMI_DATA0_R: C5703.2 R5716.1 RN5701.6(B)
HDMI_DATA0_R_C: ED5702.4 ED5702.7 ER5703.2 HDMI1.7 R5716.2
HDMI_DATA1: C5705.1 CPU1.F58
HDMI_DATA1#: C5706.1 CPU1.E58
HDMI_DATA1#_R: C5706.2 R5713.1 RN5703.5(B)
HDMI_DATA1#_R_C: ED5701.5 ED5701.6 ER5704.1 HDMI1.6 R5713.2
HDMI_DATA1_R: C5705.2 R5711.1 RN5703.6(B)
HDMI_DATA1_R_C: ED5701.4 ED5701.7 ER5704.2 HDMI1.4 R5711.2
HDMI_DATA2: C5708.1 CPU1.F55
HDMI_DATA2#: C5707.1 CPU1.E55
HDMI_DATA2#_R: C5707.2 R5717.1 RN5703.7(B)
HDMI_DATA2#_R_C: ED5701.2 ED5701.9 ER5702.1 HDMI1.3 R5717.2
HDMI_DATA2_R: C5708.2 R5718.1 RN5703.8(B)
HDMI_DATA2_R_C: ED5701.1 ED5701.10 ER5702.2 HDMI1.1 R5718.2
HDMI_HPD_B: Q5703.B R5707.2
HDMI_HPD_E: Q5703.E R5705.1 R5719.2
HDMI_PLL_GND: Q5701.D R5709.2 RN5701.1(A) RN5701.2(A) RN5701.3(A) RN5701.4(A) RN5703.1(A) RN5703.2(A) RN5703.3(A) RN5703.4(A)
HOST_DEBUG_TX: KBC24.81 R2466.2 R2478.1 R6115.1
HPD_HDMI_CON: ED5703.2 ED5703.9 HDMI1.19 R5706.2 R5707.1
HW_GPS_DISABLE2#: D6201.K R2413.1 R2498.1
HW_GPS_DISABLE2#_D: AFTP6266.1 D6201.A WWAN1.26
I2C0_SCL: CPU1.N3 RN2008.1(A)
I2C0_SCL_TCH_PAD: CPU1.U6 EC6504.1 Q6503.1 R6518.1 RN6505.4(B)
I2C0_SDA: CPU1.M4 RN2007.2(A)
I2C0_SDA_TCH_PAD: CPU1.U7 EC6502.1 Q6503.4 R6519.1 RN6505.3(B)
I2C1_SCL: CPU1.N2 RN2008.2(A)
I2C1_SCL_R: AFTP6237.1 Q6503.6 R6515.2 R6518.2 RN6502.4(B) TPAD1.3
I2C1_SDA: CPU1.N1 RN2007.1(A)
I2C1_SDA_R: AFTP6240.1 Q6503.3 R6511.2 R6519.2 RN6502.3(B) TPAD1.2
I_ADP: C2435.1 KBC24.110 R2421.2
I_BATT: C2441.1 KBC24.114 R2423.2 R2498.2
I_SYS: C2427.1 KBC24.113 R2425.2 R2497.2
ICSP_CLK_R: DB3.2 R2463.1
ICSP_CLOCK: KBC24.101 R2463.2
ICSP_CLR: KBC24.87 R2414.1 R2465.2
ICSP_CLR_R: DB3.6 R2465.1
ICSP_DATA: KBC24.102 R2464.2
ICSP_DATA_R: DB3.3 R2464.1
ILIM_HI: R3404.1 U3401.16
ILIM_SEL: R3405.2 U3401.4
INT#_ITE8010: R2422.2 U9601.7
INT_TP#: AFTP6241.1 D401.K R410.1 R2431.2 RN6501.2(A) TPAD1.5
IR_CAMERA_DET#: CPU1.AY7 D5501.A EC5504.1 R2051.2 R5540.2
IR_CAMERA_DET#_R: D5501.K IRCCD1.4 R5540.1
IT8010_WRST#: C9603.1 R9610.1 U9601.4
ITP_PMODE: CPU1.E8 R9932.2 R9933.1
JACK_PLUG: ED2902.1 HPMIC1.5 R2923.1
JACK_PLUG_DET: ED2902.2 HPMIC1.6 R2901.1
JDREF: HDA27.15 R2707.1
JET_SVC: GPU1.P8 R7919.2
JET_SVD: GPU1.N1 R7920.2
JGND: AFTP4301.1 AFTP4302.1 DCIN1.5 DCIN1.6 EC4301.2 EC4302.2 EC4303.2 EC4304.2 EL4303.1 EL4304.1
JTAG_TCK_VGA: GPU1.L3 TP7911.1
JTAG_TDI_VGA: GPU1.L5 TP7908.1
JTAG_TDO_VGA: GPU1.K4 TP7913.1
JTAG_TMS_VGA: GPU1.L1 TP7912.1
JTAG_TRST#_VGA: GPU1.L6 TP7907.1
KB_BL_CTRL#: AFTP6247.1 KBLIT1.4 Q6501.D
KB_DET#: AFTP6202.1 CPU1.BB7 KB1.30 RN2001.1(A)
KB_LED_BL_DET: CPU1.W8 R6503.1 R6507.1
KB_LED_DET_C: AFTP6246.1 C6502.1 KBLIT1.2 R6503.2
KBC_BEEP_R: D2701.1 RN2701.4(B)
KBC_PWRBTN#: R2432.1 R6403.1
KBC_PWRBTN#_C: AFTP6101.1 EC6401.1 ED6401.1 G6401.2 G6402.2 PWR1.2 PWSW2.3 PWSW2.4 R6403.2
KSI0: AFTP6228.1 KB1.22 KBC24.98 RN2412.8(B)
KSI1: AFTP6227.1 KB1.24 KBC24.99 RN2412.6(B)
KSI2: AFTP6218.1 KB1.26 KBC24.6 RN2411.8(B)
KSI3: AFTP6234.1 KB1.23 KBC24.7 RN2412.7(B)
KSI4: AFTP6230.1 KB1.27 KBC24.104 RN2411.7(B)
KSI5: AFTP6214.1 KB1.25 KBC24.105 RN2412.5(B)
KSI6: AFTP6222.1 KB1.28 KBC24.107 RN2411.6(B)
KSI7: AFTP6221.1 KB1.29 KBC24.108 RN2411.5(B)
KSO0: AFTP6207.1 KB1.13 KBC24.2 RN2404.5(B)
KSO1: AFTP6206.1 KB1.15 KBC24.14 RN2409.7(B)
KSO2: AFTP6226.1 KB1.14 KBC24.15 RN2409.8(B)
KSO3: AFTP6208.1 KB1.16 KBC24.16 RN2409.6(B)
KSO4: AFTP6224.1 KB1.20 KBC24.37 RN2410.6(B)
KSO5: AFTP6215.1 KB1.21 KBC24.38 RN2410.5(B)
KSO6: AFTP6223.1 KB1.18 KBC24.39 RN2410.8(B)
KSO7: AFTP6213.1 KB1.19 KBC24.50 RN2410.7(B)
KSO8: AFTP6231.1 KB1.17 KBC24.46 RN2409.5(B)
KSO9: AFTP6219.1 KB1.7 KBC24.68 R2449.2 R2450.1
KSO10: AFTP6232.1 KB1.5 KBC24.72 RN2403.8(B)
KSO11: AFTP6220.1 KB1.6 KBC24.74 RN2403.7(B)
KSO12: AFTP6233.1 KB1.12 KBC24.75 RN2404.6(B)
KSO13: AFTP6203.1 KB1.9 KBC24.76 RN2403.5(B)
KSO14: AFTP6216.1 KB1.8 KBC24.77 RN2403.6(B)
KSO15: AFTP6229.1 KB1.10 KBC24.86 RN2404.8(B)
KSO16: AFTP6225.1 KB1.11 KBC24.92 RN2404.7(B)
L_BKLT_CTRL: CPU1.R11 R5530.1
L_BKLT_EN: CPU1.R12 R2435.2 R2480.1
L_BKLT_EN_EC: KBC24.91 R2422.1 R2435.1 R2436.1
L_CPM_CLK: R9126.2 U9102.22
L_CPM_CLK_R: R9126.1 U9103.3
LAN_DISABLE#: LOM31.20 R3105.1 R3107.2
LAN_EN: KBC24.3 R2491.1
LAN_ENABLE_R_C: Q3101.D R3109.2 R3110.1
LAN_MDI0N: EC3102.2 ED3201.2 ED3201.9 LOM31.2 XF3103.11
LAN_MDI0P: EC3101.2 ED3201.1 ED3201.10 LOM31.1 XF3103.12
LAN_MDI1N: EC3104.2 ED3201.5 ED3201.6 LOM31.5 XF3103.8
LAN_MDI1P: EC3103.2 ED3201.4 ED3201.7 LOM31.4 XF3103.9
LAN_MDI2N: EC3106.2 ED3202.2 ED3202.9 LOM31.7 XF3103.5
LAN_MDI2P: EC3105.2 ED3202.1 ED3202.10 LOM31.6 XF3103.6
LAN_MDI3N: EC3108.2 ED3202.5 ED3202.6 LOM31.10 XF3103.2
LAN_MDI3P: EC3107.2 ED3202.4 ED3202.7 LOM31.9 XF3103.3
LAN_REGOUT: L3101.1 LOM31.24
LAN_RSET: LOM31.31 R3108.1
LANXIN: C3112.1 LOM31.28 X3101.1
LANXOUT: C3110.1 LOM31.29 X3101.3
LCD_BRIGHTNESS: LCD1.20 RN5503.2(A)
LCD_MIC_CBL_DET#: CPU1.W4 R5539.2 RN2002.3(B)
LCD_MIC_CBL_DET#_R: LCD1.23 R5539.1
LCD_TST: D5503.2 KBC24.26 R2419.1 RN5503.8(B)
LCD_TST_C: LCD1.10 RN5503.1(A)
LCD_VCC_TEST_EN: D5502.2 R2419.2 RN9601.2(A) U9601.13
LCDVDD: R5523.2 U5501.3
LCDVDD_EN: D5502.3 R5506.2 U5501.1
LCDVDD_LCD: C5536.2 C5538.1 FC5501.1 LCD1.4 LCD1.5 LCD1.6 LCD1.7 R5523.1
LDO1_CAP: C2702.2 HDA27.27 R2711.2
LDO2_CAP: C2712.2 HDA27.39
LDO3_CAP: C2718.1 HDA27.7
LED0: LOM31.27 TP3103.1
LED1: LOM31.26 R3104.1
LED2: LOM31.25 TP3101.1
LID_CL_SIO#: AFTP7001.1 C7001.1 D2402.K EC7001.1 KBC24.41 LIDSW1.3 R7001.1 RN2406.2(A)
LINE1-L_C: C2907.2 R2922.1
LINE1-L_R: C2908.2 R2921.1
LINE1_L: C2907.1 HDA27.22
LINE1_R: C2908.1 HDA27.21
LINE1_VREFO_L: HDA27.31 R2912.1
LINE1_VREFO_R: HDA27.30 R2913.1
LOM_CABLE_DETECT#: CPU1.AN7 R2052.2 R3104.2
LOM_TCT: C3119.1 XF3103.1 XF3103.4 XF3103.7 XF3103.10
LPC_FRAME#_DEBUG: DB1.6 R6801.2
LPC_LAD0: KBC24.59 R9154.2 RN1806.8(B) RN6801.4(A)
LPC_LAD0_C: DB1.2 RN6801.5(B)
LPC_LAD0_CPM: R9154.1 U9102.27
LPC_LAD0_R: CPU1.AY13 RN1806.1(A)
LPC_LAD1: KBC24.60 R9155.2 RN1806.6(B) RN6801.3(A)
LPC_LAD1_C: DB1.3 RN6801.6(B)
LPC_LAD1_CPM: R9155.1 U9102.24
LPC_LAD1_R: CPU1.BA13 RN1806.3(A)
LPC_LAD2: KBC24.61 R9156.2 RN1806.7(B) RN6801.2(A)
LPC_LAD2_C: DB1.4 RN6801.7(B)
LPC_LAD2_CPM: R9156.1 U9102.21
LPC_LAD2_R: CPU1.BB13 RN1806.2(A)
LPC_LAD3: KBC24.62 R9157.2 RN1806.5(B) RN6801.1(A)
LPC_LAD3_C: DB1.5 RN6801.8(B)
LPC_LAD3_CPM: R9157.1 U9102.19
LPC_LAD3_R: CPU1.AY12 RN1806.4(A)
LPC_LFRAME#: KBC24.58 R1801.2 R6801.1 R9158.2
LPC_LFRAME#_CPM: R9158.1 U9102.23
LPC_LFRAME#_R: CPU1.BA12 R1801.1
LPSS_UART2_CTS#: CPU1.AD4 R2046.1 TP2009.1
LPSS_UART2_RXD: CPU1.AD1 DB2.3 R2048.1
LPSS_UART2_TXD: CPU1.AD2 DB2.2 R2049.1
M_A_A0: CPU1.AY50 DM1.144
M_A_A1: CPU1.BB50 DM1.133
M_A_A2: CPU1.AY51 DM1.132
M_A_A3: CPU1.BA50 DM1.131
M_A_A4: CPU1.BB52 DM1.128
M_A_A5: CPU1.BA51 DM1.126
M_A_A6: CPU1.BA52 DM1.127
M_A_A7: CPU1.AW52 DM1.122
M_A_A8: CPU1.AY52 DM1.125
M_A_A9: CPU1.BB54 DM1.121
M_A_A10: CPU1.AT50 DM1.146
M_A_A11: CPU1.BA54 DM1.120
M_A_A12: CPU1.AW54 DM1.119
M_A_A13: CPU1.AU46 DM1.158
M_A_A14: CPU1.AT46 DM1.151
M_A_A15: CPU1.AU48 DM1.156
M_A_A16: CPU1.AU50 DM1.152
M_A_ACT_N: CPU1.BA55 DM1.114
M_A_ALERT_N: CPU1.AW50 DM1.116
M_A_BA0: CPU1.AU52 DM1.150
M_A_BA1: CPU1.AT48 DM1.145
M_A_BG0: CPU1.AY55 DM1.115
M_A_BG1: CPU1.AY54 DM1.113
M_A_CKE0: CPU1.BA56 DM1.109
M_A_CKE1: CPU1.BB56 DM1.110
M_A_CLK0: CPU1.AT53 DM1.137
M_A_CLK1: CPU1.AT55 DM1.138
M_A_CLK#0: CPU1.AU53 DM1.139
M_A_CLK#1: CPU1.AU55 DM1.140
M_A_CS#0: CPU1.AU45 DM1.149
M_A_CS#1: CPU1.AU43 DM1.157
M_A_DIMA_ODT0: CPU1.AT45 DM1.155
M_A_DIMA_ODT1: CPU1.AT43 DM1.161
M_A_DQ0: CPU1.AL71 DM1.8
M_A_DQ1: CPU1.AL68 DM1.7
M_A_DQ2: CPU1.AN68 DM1.20
M_A_DQ3: CPU1.AN69 DM1.21
M_A_DQ4: CPU1.AL70 DM1.4
M_A_DQ5: CPU1.AL69 DM1.3
M_A_DQ6: CPU1.AN70 DM1.16
M_A_DQ7: CPU1.AN71 DM1.17
M_A_DQ8: CPU1.AR70 DM1.28
M_A_DQ9: CPU1.AR68 DM1.29
M_A_DQ10: CPU1.AU71 DM1.41
M_A_DQ11: CPU1.AU68 DM1.42
M_A_DQ12: CPU1.AR71 DM1.24
M_A_DQ13: CPU1.AR69 DM1.25
M_A_DQ14: CPU1.AU70 DM1.38
M_A_DQ15: CPU1.AU69 DM1.37
M_A_DQ16: CPU1.BB65 DM1.50
M_A_DQ17: CPU1.AW65 DM1.49
M_A_DQ18: CPU1.AW63 DM1.62
M_A_DQ19: CPU1.AY63 DM1.63
M_A_DQ20: CPU1.BA65 DM1.46
M_A_DQ21: CPU1.AY65 DM1.45
M_A_DQ22: CPU1.BA63 DM1.58
M_A_DQ23: CPU1.BB63 DM1.59
M_A_DQ24: CPU1.BA61 DM1.70
M_A_DQ25: CPU1.AW61 DM1.71
M_A_DQ26: CPU1.BB59 DM1.83
M_A_DQ27: CPU1.AW59 DM1.84
M_A_DQ28: CPU1.BB61 DM1.66
M_A_DQ29: CPU1.AY61 DM1.67
M_A_DQ30: CPU1.BA59 DM1.79
M_A_DQ31: CPU1.AY59 DM1.80
M_A_DQ32: CPU1.AF65 DM1.191
M_A_DQ33: CPU1.AF64 DM1.194
M_A_DQ34: CPU1.AK65 DM1.203
M_A_DQ35: CPU1.AK64 DM1.207
M_A_DQ36: CPU1.AF66 DM1.190
M_A_DQ37: CPU1.AF67 DM1.195
M_A_DQ38: CPU1.AK67 DM1.204
M_A_DQ39: CPU1.AK66 DM1.208
M_A_DQ40: CPU1.AF70 DM1.173
M_A_DQ41: CPU1.AF68 DM1.170
M_A_DQ42: CPU1.AH71 DM1.182
M_A_DQ43: CPU1.AH68 DM1.183
M_A_DQ44: CPU1.AF71 DM1.169
M_A_DQ45: CPU1.AF69 DM1.174
M_A_DQ46: CPU1.AH70 DM1.186
M_A_DQ47: CPU1.AH69 DM1.187
M_A_DQ48: CPU1.AT66 DM1.224
M_A_DQ49: CPU1.AU66 DM1.225
M_A_DQ50: CPU1.AP65 DM1.215
M_A_DQ51: CPU1.AN65 DM1.216
M_A_DQ52: CPU1.AN66 DM1.211
M_A_DQ53: CPU1.AP66 DM1.212
M_A_DQ54: CPU1.AT65 DM1.229
M_A_DQ55: CPU1.AU65 DM1.228
M_A_DQ56: CPU1.AT61 DM1.236
M_A_DQ57: CPU1.AU61 DM1.237
M_A_DQ58: CPU1.AP60 DM1.249
M_A_DQ59: CPU1.AN60 DM1.232
M_A_DQ60: CPU1.AN61 DM1.246
M_A_DQ61: CPU1.AP61 DM1.250
M_A_DQ62: CPU1.AT60 DM1.245
M_A_DQ63: CPU1.AU60 DM1.233
M_A_DQS_DN0: CPU1.AM70 DM1.11
M_A_DQS_DN1: CPU1.AT69 DM1.32
M_A_DQS_DN2: CPU1.BA64 DM1.53
M_A_DQS_DN3: CPU1.AY60 DM1.74
M_A_DQS_DN4: CPU1.AH66 DM1.198
M_A_DQS_DN5: CPU1.AG69 DM1.177
M_A_DQS_DN6: CPU1.AR66 DM1.219
M_A_DQS_DN7: CPU1.AR61 DM1.240
M_A_DQS_DP0: CPU1.AM69 DM1.13
M_A_DQS_DP1: CPU1.AT70 DM1.34
M_A_DQS_DP2: CPU1.AY64 DM1.55
M_A_DQS_DP3: CPU1.BA60 DM1.76
M_A_DQS_DP4: CPU1.AH65 DM1.200
M_A_DQS_DP5: CPU1.AG70 DM1.179
M_A_DQS_DP6: CPU1.AR65 DM1.221
M_A_DQS_DP7: CPU1.AR60 DM1.242
M_A_PARITY: CPU1.AT52 DM1.143
M_B_A0: CPU1.BA46 DM2.144
M_B_A1: CPU1.AY46 DM2.133
M_B_A2: CPU1.AY47 DM2.132
M_B_A3: CPU1.BB46 DM2.131
M_B_A4: CPU1.BA47 DM2.128
M_B_A5: CPU1.AY48 DM2.126
M_B_A6: CPU1.BA48 DM2.127
M_B_A7: CPU1.AP48 DM2.122
M_B_A8: CPU1.BB48 DM2.125
M_B_A9: CPU1.AP50 DM2.121
M_B_A10: CPU1.AW46 DM2.146
M_B_A11: CPU1.AN48 DM2.120
M_B_A12: CPU1.AN50 DM2.119
M_B_A13: CPU1.BA43 DM2.158
M_B_A14: CPU1.AY44 DM2.151
M_B_A15: CPU1.AY43 DM2.156
M_B_A16: CPU1.AW44 DM2.152
M_B_ACT_N: CPU1.AN53 DM2.114
M_B_ALERT_N: CPU1.AN43 DM2.116
M_B_BA0: CPU1.BB44 DM2.150
M_B_BA1: CPU1.BA44 DM2.145
M_B_BG0: CPU1.AP52 DM2.115
M_B_BG1: CPU1.AN52 DM2.113
M_B_CKE0: CPU1.AN56 DM2.109
M_B_CKE1: CPU1.AP55 DM2.110
M_B_CLK0: CPU1.AP45 DM2.137
M_B_CLK1: CPU1.AP46 DM2.138
M_B_CLK#0: CPU1.AN45 DM2.139
M_B_CLK#1: CPU1.AN46 DM2.140
M_B_CS#0: CPU1.BB42 DM2.149
M_B_CS#1: CPU1.AY42 DM2.157
M_B_DIMB_ODT0: CPU1.BA42 DM2.155
M_B_DIMB_ODT1: CPU1.AW42 DM2.161
M_B_DQ0: CPU1.AY39 DM2.4
M_B_DQ1: CPU1.AW39 DM2.8
M_B_DQ2: CPU1.AY37 DM2.17
M_B_DQ3: CPU1.AW37 DM2.21
M_B_DQ4: CPU1.BB39 DM2.3
M_B_DQ5: CPU1.BA39 DM2.7
M_B_DQ6: CPU1.BA37 DM2.16
M_B_DQ7: CPU1.BB37 DM2.20
M_B_DQ8: CPU1.AY35 DM2.24
M_B_DQ9: CPU1.AW35 DM2.28
M_B_DQ10: CPU1.AY33 DM2.38
M_B_DQ11: CPU1.AW33 DM2.42
M_B_DQ12: CPU1.BB35 DM2.25
M_B_DQ13: CPU1.BA35 DM2.41
M_B_DQ14: CPU1.BA33 DM2.29
M_B_DQ15: CPU1.BB33 DM2.37
M_B_DQ16: CPU1.AY31 DM2.50
M_B_DQ17: CPU1.AW31 DM2.49
M_B_DQ18: CPU1.AY29 DM2.62
M_B_DQ19: CPU1.AW29 DM2.63
M_B_DQ20: CPU1.BB31 DM2.46
M_B_DQ21: CPU1.BA31 DM2.45
M_B_DQ22: CPU1.BA29 DM2.58
M_B_DQ23: CPU1.BB29 DM2.59
M_B_DQ24: CPU1.AY27 DM2.70
M_B_DQ25: CPU1.AW27 DM2.71
M_B_DQ26: CPU1.AY25 DM2.83
M_B_DQ27: CPU1.AW25 DM2.84
M_B_DQ28: CPU1.BB27 DM2.66
M_B_DQ29: CPU1.BA27 DM2.67
M_B_DQ30: CPU1.BA25 DM2.79
M_B_DQ31: CPU1.BB25 DM2.80
M_B_DQ32: CPU1.AU40 DM2.174
M_B_DQ33: CPU1.AT40 DM2.173
M_B_DQ34: CPU1.AT37 DM2.187
M_B_DQ35: CPU1.AU37 DM2.186
M_B_DQ36: CPU1.AR40 DM2.170
M_B_DQ37: CPU1.AP40 DM2.169
M_B_DQ38: CPU1.AP37 DM2.183
M_B_DQ39: CPU1.AR37 DM2.182
M_B_DQ40: CPU1.AT33 DM2.195
M_B_DQ41: CPU1.AU33 DM2.194
M_B_DQ42: CPU1.AU30 DM2.207
M_B_DQ43: CPU1.AT30 DM2.208
M_B_DQ44: CPU1.AR33 DM2.191
M_B_DQ45: CPU1.AP33 DM2.190
M_B_DQ46: CPU1.AR30 DM2.203
M_B_DQ47: CPU1.AP30 DM2.204
M_B_DQ48: CPU1.AU27 DM2.216
M_B_DQ49: CPU1.AT27 DM2.215
M_B_DQ50: CPU1.AT25 DM2.229
M_B_DQ51: CPU1.AU25 DM2.224
M_B_DQ52: CPU1.AP27 DM2.211
M_B_DQ53: CPU1.AN27 DM2.212
M_B_DQ54: CPU1.AN25 DM2.228
M_B_DQ55: CPU1.AP25 DM2.225
M_B_DQ56: CPU1.AT22 DM2.236
M_B_DQ57: CPU1.AU22 DM2.232
M_B_DQ58: CPU1.AU21 DM2.233
M_B_DQ59: CPU1.AT21 DM2.249
M_B_DQ60: CPU1.AN22 DM2.245
M_B_DQ61: CPU1.AP22 DM2.237
M_B_DQ62: CPU1.AP21 DM2.246
M_B_DQ63: CPU1.AN21 DM2.250
M_B_DQS_DN0: CPU1.BA38 DM2.11
M_B_DQS_DN1: CPU1.AY34 DM2.32
M_B_DQS_DN2: CPU1.BA30 DM2.53
M_B_DQS_DN3: CPU1.AY26 DM2.74
M_B_DQS_DN4: CPU1.AT38 DM2.177
M_B_DQS_DN5: CPU1.AT32 DM2.198
M_B_DQS_DN6: CPU1.AR25 DM2.219
M_B_DQS_DN7: CPU1.AR22 DM2.240
M_B_DQS_DP0: CPU1.AY38 DM2.13
M_B_DQS_DP1: CPU1.BA34 DM2.34
M_B_DQS_DP2: CPU1.AY30 DM2.55
M_B_DQS_DP3: CPU1.BA26 DM2.76
M_B_DQS_DP4: CPU1.AR38 DM2.179
M_B_DQS_DP5: CPU1.AR32 DM2.200
M_B_DQS_DP6: CPU1.AR27 DM2.221
M_B_DQS_DP7: CPU1.AR21 DM2.242
M_B_PARITY: CPU1.AP43 DM2.143
M_VREF_CA_DIMMA: C1229.1 DM1.164 R1206.1 RN1201.3(B) RN1201.4(B)
M_VREF_CA_DIMMB: C1301.1 DM2.164 R1305.1 RN1301.3(B) RN1301.4(B)
MAA0: GPU1.K17 VRAM1.N3 VRAM2.N3 VRAM3.N3 VRAM4.N3
MAA1: GPU1.J20 VRAM1.P7 VRAM2.P7 VRAM3.P7 VRAM4.P7
MAA2: GPU1.H23 VRAM1.P3 VRAM2.P3 VRAM3.P3 VRAM4.P3
MAA3: GPU1.G23 VRAM1.N2 VRAM2.N2 VRAM3.N2 VRAM4.N2
MAA4: GPU1.G24 VRAM1.P8 VRAM2.P8 VRAM3.P8 VRAM4.P8
MAA5: GPU1.H24 VRAM1.P2 VRAM2.P2 VRAM3.P2 VRAM4.P2
MAA6: GPU1.J19 VRAM1.R8 VRAM2.R8 VRAM3.R8 VRAM4.R8
MAA7: GPU1.K19 VRAM1.R2 VRAM2.R2 VRAM3.R2 VRAM4.R2
MAA8: GPU1.J14 VRAM1.T8 VRAM2.T8 VRAM3.T8 VRAM4.T8
MAA9: GPU1.K14 VRAM1.R3 VRAM2.R3 VRAM3.R3 VRAM4.R3
MAA10: GPU1.J11 VRAM1.L7 VRAM2.L7 VRAM3.L7 VRAM4.L7
MAA11: GPU1.J13 VRAM1.R7 VRAM2.R7 VRAM3.R7 VRAM4.R7
MAA12: GPU1.H11 VRAM1.N7 VRAM2.N7 VRAM3.N7 VRAM4.N7
MAA13: GPU1.G20 VRAM1.T3 VRAM2.T3 VRAM3.T3 VRAM4.T3
MAA14: GPU1.G14 VRAM1.T7 VRAM2.T7 VRAM3.T7 VRAM4.T7
MAA15: GPU1.L17 VRAM1.M7 VRAM2.M7 VRAM3.M7 VRAM4.M7
MAA_BA0: GPU1.J16 VRAM1.M2 VRAM2.M2 VRAM3.M2 VRAM4.M2
MAA_BA1: GPU1.L15 VRAM1.N8 VRAM2.N8 VRAM3.N8 VRAM4.N8
MAA_BA2: GPU1.G11 VRAM1.M3 VRAM2.M3 VRAM3.M3 VRAM4.M3
MASK_BASE_LEDS#: KBC24.23 Q6406.2 Q6406.5 Q6407.G R2438.1 R2499.1
MCARD_WWAN_PWREN: R6212.1 U9601.12
MCT: C3201.1 RN3201.5(B) RN3201.6(B) RN3201.7(B) RN3201.8(B)
MCT0: RN3201.1(A) XF3103.24
MCT1: RN3201.2(A) XF3103.21
MCT2: RN3201.3(A) XF3103.18
MCT3: RN3201.4(A) XF3103.15
MDO0+: RJ45.1 XF3103.13
MDO0-: RJ45.2 XF3103.14
MDO1+: RJ45.3 XF3103.16
MDO1-: RJ45.6 XF3103.17
MDO2+: RJ45.4 XF3103.19
MDO2-: RJ45.5 XF3103.20
MDO3+: RJ45.7 XF3103.22
MDO3-: RJ45.8 XF3103.23
ME_FWP_CPU: MESW1.C MESW1.C1 R1909.1 R9801.2
ME_FWP_EC: KBC24.80 MESW1.A R9801.1
ME_SUS_PWR_ACK: KBC24.42 R1712.1
ME_SUS_PWR_ACK_R: CPU1.AR13 R1708.1 R1712.2 R2039.2
MEM_CALRP0: GPU1.K25 R7809.2
MEM_SMBCLK: CPU1.R7 Q1801.3 RN1811.3(B)
MEM_SMBDATA: CPU1.R8 Q1801.6 RN1811.4(B)
MESO_SVC: GPU1.AJ11 R7946.2
MESO_SVD: GPU1.AK12 R7944.2
MESO_SVT: GPU1.AL11 R7945.2
MESO_U1: GPU1.U1 RN7905.2(A)
MESO_U3: GPU1.U3 RN7905.1(A)
MESW1_B: MESW1.B R9804.1 R9805.2
MIC2_VREFO: HDA27.29 RN2901.1(A) RN2901.2(A)
MIC_CAP: C2713.1 HDA27.19
MIC_GND: LCD1.26 R5531.1
MLPS_EN#: GPU1.R5 R7935.2 R7936.1
MODEL_ID: C2407.2 KBC24.109 R2441.1 R2442.2
MPV18: C8043.1 C8044.1 C8045.1 GPU1.L8 L8001.2
MSM#: CPU1.AP56 TP617.1
MVREFDA: C7805.2 GPU1.K26 R7817.2 R7818.1
MVREFSA: C7801.2 GPU1.J26 R7810.2 R7814.1
NC#AA3: GPU1.AA3 R7938.2
NC_R: GPU1.AM26 TP7922.1
NC_VSYNC: GPU1.AJ27 R7941.2
NCT7718_ALERT#: R2603.2 THM26.6
NCT7718_DXN: C2606.2 C2607.2 Q2603.E THM26.3
NCT7718_DXP: C2606.1 C2607.1 Q2603.B Q2603.C THM26.2
NGFF_CONFIG_0: AFTP6258.1 R6201.1 U9601.14 WWAN1.21
NGFF_CONFIG_1: AFTP6253.1 R6202.1 U9601.15 WWAN1.69
NGFF_CONFIG_2: AFTP6260.1 KBC24.20 R6203.1 WWAN1.75
NGFF_CONFIG_3: AFTP6254.1 KBC24.25 R6204.1 WWAN1.1
NGFF_DEVSLP1: CPU1.J2 R6209.2 R6216.2
NGFF_MSATA_DEVSLP: AFTP6209.1 R6216.1 WWAN1.38
NGFF_PCIE#_SATA: CPU1.H3 R1610.2
NGFF_WAKE#: AFTP6249.1 R6218.1 WWAN1.54
ODTA0: GPU1.L18 VRAM1.K1 VRAM2.K1
ODTA1: GPU1.K16 VRAM3.K1 VRAM4.K1
P_SYS: PG4415.2 PR4425.1 PR4671.1 R2425.1
PANEL_BKEN_EC: KBC24.117 R2439.2
PANEL_SIZE_ID: CPU1.AP13 R5521.2 R5525.2 R5526.1
PANEL_SIZE_ID_CONN: LCD1.22 R5525.1
PBAT_PRES1#: AFTP4310.1 BATT1.6 RN4302.8(B)
PBAT_PRES#: ED4304.3 KBC24.97 PG4416.1 R2415.1 RN4302.1(A)
PBAT_SMBCLK1: AFTP4312.1 BATT1.4 RN4302.6(B)
PBAT_SMBDAT1: AFTP4311.1 BATT1.5 RN4302.7(B)
PCH_ALW_ON: KBC24.71 R2496.1 R4102.1
PCH_BATLOW#: CPU1.AU13 R1710.2 RN1701.2(A)
PCH_DPC_AUXN: CPU1.E48 IOBD4.11
PCH_DPC_AUXP: CPU1.F48 IOBD4.12
PCH_DPC_N0: CPU1.C50 IOBD4.5
PCH_DPC_N1: CPU1.C52 IOBD4.8
PCH_DPC_P0: CPU1.D50 IOBD4.6
PCH_DPC_P1: CPU1.D52 IOBD4.9
PCH_DPWROK: CPU1.BB20 EC1714.1 R1704.2 R1718.1 R2497.1 RN1703.2(A)
PCH_JTAG_TCK: CPU1.B56 R407.1 R9914.2
PCH_JTAG_TDI: CPU1.D59 R408.1 R9916.2
PCH_JTAG_TDO: CPU1.A56 R409.1 R9919.2 XDP1.52
PCH_JTAG_TMS: CPU1.C59 R416.1 R9917.2
PCH_PLTRST#: CPU1.AN10 R1713.2
PCH_PLTRST#_EC: C2402.2 KBC24.56 R2410.1
PCH_POPIRCOMP: CPU1.AU16 RN401.3(B)
PCH_RSMRST#: EC1712.1 KBC24.88 R1702.2
PCH_SMBCLK: DM1.253 DM2.253 EC6505.1 IOBD4.15 Q1801.4 R6515.1 R9912.1 RN1810.3(B) U6701.1
PCH_SMBDATA: DM1.254 DM2.254 EC6506.1 IOBD4.14 Q1801.1 R6511.1 R9911.1 RN1810.4(B) U6701.4
PCH_SPI_CS2#: CPU1.AU1 R1816.2
PCH_THERMTRIP: CPU1.C63 ED401.1 R419.2
PCH_WAKE#: CPU1.BB15 R1705.2 RN1701.3(A)
PCI_CLK_LPC0: CPU1.AW9 R1804.1
PCI_CLK_LPC1: CPU1.AY9 R1805.1
PCI_CLK_LPC1_B: EC1802.1 R1804.2 R9121.1 R9153.1
PCI_CLK_LPC1_B_R: R9153.2 U9103.1
PCIE_CALR_RX: GPU1.AA22 R7618.2
PCIE_CALR_TX: GPU1.Y22 R7622.2
PCIE_CLK_XDP_N: CPU1.F43 R9923.1
PCIE_CLK_XDP_P: CPU1.E43 R9913.1
PCIE_LAN_WAKE#: D1702.2 LOM31.21 R3106.1
PCIE_RCOMPN: CPU1.F5 R1604.1
PCIE_RCOMPP: CPU1.E5 R1604.2
PCIE_RX_CON_N5: C3104.1 LOM31.18
PCIE_RX_CON_P5: C3108.1 LOM31.17
PCIE_RX_CPU_N5: C3104.2 CPU1.F16
PCIE_RX_CPU_N6: CPU1.G18 WLAN1.43
PCIE_RX_CPU_P5: C3108.2 CPU1.E16
PCIE_RX_CPU_P6: CPU1.F18 WLAN1.41
PCIE_TX_CON_N5: C1603.1 LOM31.14
PCIE_TX_CON_N6: C1601.1 WLAN1.37
PCIE_TX_CON_P5: C1604.1 LOM31.13
PCIE_TX_CON_P6: C1602.1 WLAN1.35
PCIE_TX_CPU_N5: C1603.2 CPU1.C19
PCIE_TX_CPU_N6: C1601.2 CPU1.D20
PCIE_TX_CPU_P5: C1604.2 CPU1.D19
PCIE_TX_CPU_P6: C1602.2 CPU1.C20
PCIE_WAKE#: D1702.3 R1705.1
PCIE_WLAN_WAKE#: D1702.1 R1714.2 R6121.1 R6218.2 WLAN1.55
PCIE_WLAN_WAKE#_R: R6121.2 WLAN1.70
PD4403_A: PD4404.A PQ4408.B
PD4403_K: PD4404.K PR4458.2
PD#: HDA27.47 R2708.2
PECI_EC: C2405.1 KBC24.94 R2437.1
PEG_CLK1_CPU: CPU1.A42 EC6103.1 WLAN1.47
PEG_CLK1_CPU#: CPU1.B42 EC6102.1 WLAN1.49
PEG_CLK2_CPU: CPU1.C41 LOM31.15
PEG_CLK2_CPU#: CPU1.D41 LOM31.16
PEG_CLK_CPU: CPU1.C42 GPU1.AK30
PEG_CLK_CPU#: CPU1.D42 GPU1.AK32
PEG_CLK_XDP: R9913.2 XDP1.40
PEG_CLK_XDP#: R9923.2 XDP1.42
PEG_RX_CPU_N0: C7302.2 CPU1.H13
PEG_RX_CPU_N1: C7304.2 CPU1.G11
PEG_RX_CPU_N2: C7306.2 CPU1.H16
PEG_RX_CPU_N3: C7308.2 CPU1.G15
PEG_RX_CPU_P0: C7301.2 CPU1.G13
PEG_RX_CPU_P1: C7303.2 CPU1.F11
PEG_RX_CPU_P2: C7305.2 CPU1.G16
PEG_RX_CPU_P3: C7307.2 CPU1.F15
PEG_RX_GPU_N0: C7302.1 GPU1.AG31
PEG_RX_GPU_N1: C7304.1 GPU1.AF28
PEG_RX_GPU_N2: C7306.1 GPU1.AF26
PEG_RX_GPU_N3: C7308.1 GPU1.AD26
PEG_RX_GPU_P0: C7301.1 GPU1.AH30
PEG_RX_GPU_P1: C7303.1 GPU1.AG29
PEG_RX_GPU_P2: C7305.1 GPU1.AF27
PEG_RX_GPU_P3: C7307.1 GPU1.AD27
PEG_TX_CPU_N0: C1606.2 CPU1.B17
PEG_TX_CPU_N1: C1608.2 CPU1.D16
PEG_TX_CPU_N2: C1610.2 CPU1.D17
PEG_TX_CPU_N3: C1612.2 CPU1.B19
PEG_TX_CPU_P0: C1605.2 CPU1.A17
PEG_TX_CPU_P1: C1607.2 CPU1.C16
PEG_TX_CPU_P2: C1609.2 CPU1.C17
PEG_TX_CPU_P3: C1611.2 CPU1.A19
PEG_TX_GPU_N0: C1606.1 GPU1.AE31
PEG_TX_GPU_N1: C1608.1 GPU1.AD28
PEG_TX_GPU_N2: C1610.1 GPU1.AC31
PEG_TX_GPU_N3: C1612.1 GPU1.AB28
PEG_TX_GPU_P0: C1605.1 GPU1.AF30
PEG_TX_GPU_P1: C1607.1 GPU1.AE29
PEG_TX_GPU_P2: C1609.1 GPU1.AD30
PEG_TX_GPU_P3: C1611.1 GPU1.AC29
PERN0/SATA_B-: ED6201.4 ED6201.7 R6207.2 WWAN1.43
PERP0/SATA_B+: ED6201.5 ED6201.6 R6205.2 WWAN1.41
PETN0/SATA_A-: C6205.2 ED6201.2 ED6201.9 WWAN1.47
PETP0/SATA_A+: C6204.2 ED6201.1 ED6201.10 WWAN1.49
PIRQA#: CPU1.BB11 RN2001.3(A)
PLL_ANALOG_IN: GPU1.AA1 TP7902.1
PLT_RST#: C1701.1 D7601.1 EC1703.1 Q9101.S Q9103.D R1713.1 R1715.1 R2410.2 R3112.1 R6116.1 R6215.2 R6802.1 R9110.1 R9125.1 RN5501.3(B)
PLT_RST#_DEBUG: DB1.7 R6802.2
PLT_RST#_LAN: LOM31.19 R3112.2
PLT_RST#_Q: Q9101.D R9110.2 R9113.1 R9114.2 R9136.1
PLT_RST#_Q_TPM1: R9113.2 U9101.3
PLT_RST#_Q_TPM2: R9136.2 U9104.17
PLT_RST_NGFF#: AFTP5805.1 R6116.2 WLAN1.52
PM_LAN_ENABLE: Q3101.G R2491.2 R3111.1
PM_LAN_ENABLE_C: C3122.2 Q3104.G R3110.2
PM_PCH_PWROK: CPU1.BA20 EC1713.2 R1706.2 R1732.2
PM_RSMRST#: CPU1.AY17 Q1701.3 R1702.1 R1704.1 R1720.2 R9904.1 RN1703.1(A)
PM_RSMRST#_M: Q1702.5 Q1702.6 R1737.2
PM_RSMRST#_R: Q1702.2 R1720.1
PM_RSMRST_PWRGD_XDP: R9904.2 XDP1.39
PM_SLP_S0_STG#: R4019.2 R9937.2 U4003.1
PM_SLP_S3_STG#: R4018.1 R4020.2 U4003.2
POWER_SW_IN#: C2426.1 KBC24.127 R2432.2 R2451.1
PQ3802_1: PQ4302.B PR4302.1 PR4309.2
PQ3809_D: PQ4306.3 PR4314.2
PQ4405_2: PQ4405.2 PR4462.1 PR4463.1
PQ4405_3: PQ4405.3 PR4455.1
PQ4405_5: PC4426.1 PQ4405.5 PR4413.2
PQ4405_6: PC4426.2 PQ4405.6 PR4450.1
PQ4408_C: PQ4408.C PR4451.1 PR4462.2
PQ4408_E: PQ4408.E PR4431.2 PR4433.1
PQ8206_3: PQ8501.3 PR8545.1
PROC_SELECT#: CPU1.C64 R603.1
PROJECT_ID2: CPU1.BA8 R2017.2 R2018.1
PS_0: C7918.1 GPU1.AC19 R7926.2 R7927.1
PS_1: C7919.1 GPU1.AD19 R7928.2 R7929.1
PS_2: C7920.1 GPU1.AE17 R7930.2 R7931.1
PS_3: C7921.1 GPU1.AE20 R7932.2 R7933.1
PS_ID: KBC24.36 PD4302.3 PR4304.2 PR4305.2
PS_ID_R: AFTP4304.1 DCIN1.4 PR4317.1
PS_ID_R1: PQ4301.S PR4305.1 PR4306.2
PS_ID_R2: PD4303.1 PD4303.2 PQ4301.D PR4306.1 PR4309.1 PR4317.2
PS_S3CNTRL: Q4001.5 Q4001.6 R4004.2
PSID_DISABLE#_R_C: PQ4301.G PQ4302.C PR4303.2
PSYS: PR4671.2 PU4601.46
PTP_DIS#: D2405.K KBC24.90
PTP_INT#_EC: KBC24.33 R2431.1
PU8201_36: PU8501.36 PU8501.37 PU8501.38
PU8201_39: PU8501.39 PU8501.40
PURE_HW_SHUTDOWN#: C2610.1 D4001.K Q2602.D Q2606.D R2612.1
PWR_0D6V_S3EN: PC5120.1 PR5125.2 PR5126.2 PU5102.7
PWR_0D6V_S5EN: PC5119.1 PR5114.2 PU5102.9
PWR_0D6V_VCNTL: PC5121.1 PR5118.1 PU5102.10
PWR_0D95V: PC8624.1 PC8625.1 PC8626.1 PG8603.1 PG8604.1 PL8601.2 PR8622.1
PWR_0D95V_FB: PC8624.2 PR8622.2 PR8623.1 PU8601.1
PWR_0D95V_PHASE: PL8601.1 PU8601.6
PWR_0D95V_PVDD: PC8621.1 PC8622.1 PC8623.1 PG8601.2 PG8602.2 PU8601.3
PWR_1D0V_BT: PC5304.2 PU5301.20
PWR_1D0V_EN: EC5312.1 PR5306.2 PR5308.2 PU5301.2
PWR_1D0V_PFM: PR5303.1 PU5301.3
PWR_1D0V_PG: PR5305.2 PR5307.2 PU5301.1
PWR_1D0V_PH: PC5304.1 PL5301.1 PU5301.10 PU5301.11 PU5301.16 PU5301.17 PU5301.18
PWR_1D0V_SS: PC5311.1 PU5301.22
PWR_1D0V_TON: PR5301.1 PU5301.6
PWR_1D0V_VFB: PC5310.2 PR5302.2 PR5304.1 PU5301.5
PWR_1D0V_VFB_A: PC5310.1 PG5310.1 PR5302.1
PWR_1D5V: PC8657.1 PC8658.1 PC8659.1 PC8660.1 PC8661.1 PG8653.2 PG8656.1 PG8657.1 PG8658.1 PG8660.1 PL8651.2
PWR_1D8V_EN: PC5411.1 PR5408.1 PR5412.2 PR5413.2 PU5401.2
PWR_1D8V_POK: PR5409.2 PR5414.2 PU5401.1
PWR_1D35V_BOOT: PR8674.1 PU8651.1
PWR_1D35V_BOOT_A: PC8656.1 PR8674.2
PWR_1D35V_EN: D8602.1 PG8655.2 PR8672.1 PU8651.11
PWR_1D35V_FB: PC8662.2 PR8675.2 PR8676.1 PU8651.14
