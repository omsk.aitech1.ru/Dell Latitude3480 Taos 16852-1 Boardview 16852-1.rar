# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
QSAP_7: length 46
  TOP w0.152: 187.85,89.9 187.85,88.88 188.12,88.62 189.15,88.62 189.5,88.27 189.5,87.76 189.63,87.64 v1(189.71,87.64) ; 187.85,89.9 187.85,90.87 187.17,91.55 187.17,91.98 187.42,92.23 187.66,92.23 188.04,92.6 188.04,92.99 188.29,93.24 190.29,93.24 190.85,93.81 191.23,93.81 191.95,93.09 192.83,93.09 193.09,92.82 193.09,91.86 193.38,91.58 194.19,91.58 194.51,91.9 197.1,91.9 197.38,92.19 197.38,97.36 197.38,98.32 197.1,98.61 196.24,98.61 195.96,98.32 195.96,98 195.84,97.88 192.48,97.88 191.75,98.6 188.41,98.6 188.29,98.73 188.29,99.03 187.4,99.92 187.4,102.01 186.51,102.9 VRAM4.C7 ; 187.85,89.9 v2(188.06,89.9)
  BOTTOM w0.102: GPU1.G5 186.45,88.07 186.99,88.07 187.17,88.14 187.43,88.14 187.58,88.07 187.87,88.07 188.11,88.31 189.24,88.31 189.47,88.07 189.47,87.88 v1(189.71,87.64)
  BOTTOM w0.152: v1(189.71,87.64) 190.09,88.02 v2(190.09,88.2)
RASA0#: length 52.3
  TOP w0.127: v1(164.39,105.8) 164.82,106.23 165.05,106.23 VRAM1.J3
  TOP w0.279: v1(173.38,87.93) 173.38,87.94 v2(173.38,88.53)
  L4 w0.127: v1(164.39,105.8) 163.89,106.3 163.89,107.72 163.34,108.27 163.09,108.52 161.94,108.52 160.94,107.52 160.74,107.52
  L4 w0.254: v1(173.38,87.93) 173.54,87.76 173.55,87.76 173.83,87.48 173.83,86.99 174.06,86.76 174.56,86.76 175.17,87.37 175.17,90.12 173.57,91.71 167.86,91.71 166.96,92.61 163.16,92.61 162.95,92.82 160.49,92.82 157.63,95.68 157.63,106.18 157.64,106.19 157.64,106.22 158.06,106.64 158.09,106.64 158.76,107.31 159.22,107.31 159.42,107.52 160.74,107.52
  BOTTOM w0.127: VRAM2.J3 164.05,106.97 164.05,106.17 164.39,105.83 v1(164.39,105.8)
  BOTTOM w0.14: GPU1.G22 172.91,88.4 v1(173.38,87.93)
RASA1#: length 49.8
  TOP w0.127: VRAM4.J3 187.55,106.23 187.32,106.23 v1(186.89,105.8)
  TOP w0.279: v2(177.01,89.16) 176.98,89.13 v1(176.98,88.6)
  L4 w0.127: 192.21,106.67 191.81,106.27 191.58,106.27 191.46,106.4 191.46,106.98 191.33,107.11 190.95,107.11 190.79,106.95 190.79,106.27 190.66,106.14 190.08,106.14 189.95,106.27 189.95,106.65 189.46,107.15 188.15,107.15 188.02,107.02 188.02,106.38 187.89,106.26 187.17,106.26 186.89,105.98 v1(186.89,105.8)
  L4 w0.254: v1(176.98,88.6) 176.78,88.79 176.78,89.89 177.43,90.54 181.87,90.54 182,90.66 182,90.68 182.13,90.81 182.92,90.81 183.54,91.43 185.29,91.43 187.95,94.08 187.95,94.08 187.97,94.09 189.33,94.09 189.97,94.73 193.17,94.73 195.18,96.74 195.18,104.27 192.79,106.67 192.21,106.67
  BOTTOM w0.127: v1(186.89,105.8) 186.94,105.85 186.94,106.27 186.81,106.4 186.49,106.4 186.25,106.64 186.25,106.99 186.39,107.14 186.39,107.4 186.09,107.7 VRAM3.J3
  BOTTOM w0.14: GPU1.G17 176.78,88.4 v1(176.98,88.6)
RESET_OUT#: length 228.9
  TOP w0.102: Q4001.3 49.64,55.9 v1(48.78,56.75) ; v1(63.27,43.6) 63.83,43.04 109.86,43.04 115.95,49.13 121.13,49.13 v1(121.25,49.25) ; KBC24.73 202,31.94 202.29,31.66 v1(202.31,31.66)
  L3 w0.102: v1(59.41,63.56) 59.41,66.46 58.34,67.52 58.34,68.29 58.37,68.32 58.37,69.87 59.84,71.33 59.84,73.52 59.39,73.97 59.39,74.33 59.87,74.81 59.87,78.23 61.06,79.42 62.69,81.05 63.79,81.05 63.99,81.25 64.21,81.4 67.58,84.77 68.01,84.77 69.88,86.64 v1(71.94,86.64) ; v1(63.01,45.72) 63.37,46.09 63.37,46.77 59.82,50.33 59.82,53.96 58.17,55.61 58.17,57.67 v1(57.66,58.18)
  L4 w0.102: v1(57.66,58.18) 57.43,57.95 49.98,57.95 v1(48.78,56.75) ; v1(63.27,43.6) 63.27,43.61 63.01,43.87 v1(63.01,45.72)
  BOTTOM w0.102: v1(59.41,63.56) 59.03,63.18 59.03,62.75 59.08,62.7 59.08,61.15 58.17,60.23 58.17,58.68 v1(57.66,58.18) ; 201.4,31.46 201.4,31.46 202.11,31.46 v1(202.31,31.66) ; 201.4,31.46 v2(201.4,31.46) ; 201.4,31.46 201.39,31.46 199.14,31.46 196.99,33.6 187.57,33.6 186.06,32.09 181.62,32.09 174.73,25.19 145.3,25.19 v1(121.25,49.25) 121.24,49.26 120.73,49.26 119.76,50.23 R1706.1 ; EC1704.1 71.35,87.23 v1(71.94,86.64) 72.17,86.87 Q2602.G
RING2: length 12.6
  TOP w0.203: HDA27.17 19.64,12.42 19.43,12.63 RN2901.4
  TOP w1.016: v3(16.92,5.37) 16.97,5.32 R2911.1
  L3 w1.016: v3(16.92,5.37) 16.94,5.4 16.94,12 v3(18.16,13.22)
  BOTTOM w0.508: v3(18.16,13.22) 18.22,13.28 EC2906.1
  vias: v2(18.77,13.6)
RING2_HPMIC1: length 31.8
  TOP w1.016: R2911.2 14.88,4.25 v3(14.4,3.77)
  L3 w1.016: v3(13.67,2.47) 12.66,3.48 12.66,3.56 10.32,5.9 5.2,5.9 HPMIC1.4
  L6 w1.016: v3(20.15,8.18) 20.15,6.73 17.42,4 14.63,4 v3(14.4,3.77)
  BOTTOM w1.016: v3(13.67,2.47) 15.42,2.47 18.16,5.21 v2(18.16,6.11) 19.2,7.14 ED2903.2 v3(20.15,8.18)
RSMRST_PWRGD#: length 203.2
  TOP w0.127: R4029.2 50.61,26.46 50.99,26.85 R4033.2 51.12,27.42 51.82,27.42 53.47,29.07 53.47,33.64 53.34,33.77 53.34,34.57 53.97,35.2 54.31,35.2 54.38,35.27 55.58,35.27 55.92,34.92 v1(55.94,34.92) ; v1(63.35,40.14) v2(64.26,40.14) 119.21,40.14 122.98,43.91 143.48,43.91 147.78,43.91 147.78,43.91 151.15,43.91 151.36,43.71 152.14,42.93 156.93,38.16 157.04,38.05 157.45,37.63 158.06,37.02 162.26,37.02 162.64,37.4 170.47,37.4 v1(170.65,37.58) ; R4030.2 161.35,40.12 165.83,40.12 165.97,40.26 v1(166,40.26)
  L4 w0.127: v1(189.99,40.12) 188.94,41.17 185.86,41.17 185.1,40.41 184.23,40.41 183.46,41.17 182.28,41.17 178.8,37.69 176.56,37.69 175.82,36.95 171.18,36.95 170.92,37.21 170.92,37.31 v1(170.65,37.58) 168.26,37.58 166,39.83 v1(166,40.26) ; v1(55.94,34.92) 55.94,34.92 56.18,35.16 58.01,35.16 60.19,37.34 60.47,37.34 60.93,37.8 60.93,39.05 61.62,39.74 62.94,39.74 v1(63.35,40.14)
  L6 w0.127: v1(189.99,40.12) 189.99,34.12 190.47,33.65 v1(190.47,32.97)
  BOTTOM w0.127: v1(190.47,32.97) 190.47,31.82 191.52,30.77 191.52,17.48 192.2,16.8 192.2,16.01 192.15,15.96 192.15,12.13 192.16,12.11 192.16,12.04 192.42,11.78 192.49,11.78 192.7,11.58 R4031.2 R4032.2 195.8,11.58 195.9,11.68 196.52,11.68 D4002.3
RSVD_TP_AK12: length 2.2
  TOP w0.102: v1(125.63,71.87) 126.42,70.89 TP606.1
  BOTTOM w0.102: CPU1.AK12 125.3,71.54 v1(125.63,71.87)
RSVD_TP_AK13: length 1.3
  TOP w0.102: TP605.1 125.09,71.99 v1(124.99,71.89)
  BOTTOM w0.102: v1(124.99,71.89) 124.65,71.55 CPU1.AK13
RSVD_TP_AW70: length 7.5
  BOTTOM w0.102: TP615.1 85.85,64.37 86.14,64.08 88.41,64.08 89.43,65.1 90.34,65.1 90.73,65.5 91.8,65.5 CPU1.AW70
RSVD_TP_AW71: length 7.8
  BOTTOM w0.102: CPU1.AW71 91.15,65.69 90.66,65.69 90.26,65.29 89.29,65.29 88.28,64.29 86.45,64.29 85.22,65.52 TP614.1
RSVD_TP_BA68: length 9.5
  BOTTOM w0.102: CPU1.BA68 92.37,64.71 92.06,64.41 91.62,64.41 91.33,64.12 89.74,64.12 88.71,63.09 88.71,63.08 86.66,61.02 85.12,61.02 TP602.1
RSVD_TP_BA70: length 5.4
  BOTTOM w0.102: CPU1.BA70 91.68,64.71 91.53,64.87 90.89,64.87 90.53,64.5 89.58,64.5 88.56,63.49 88.07,63.49 87.57,62.98 TP601.1
RSVD_TP_BB68: length 7.4
  BOTTOM w0.102: TP603.1 88.09,61.24 90.15,63.31 92.38,63.31 93.07,64 CPU1.BB68
RSVD_TP_BB69: length 8
  BOTTOM w0.102: CPU1.BB69 92.29,64.09 91.92,63.71 89.92,63.71 86.8,60.59 86.49,60.59 TP604.1
RTC_AUX_S5: length 364.8
  TOP w0.102: v1(127.76,49.67) 127.76,47.48 126.49,46.21 119.15,46.21 116.99,48.37 115.95,48.37 109.86,42.28 63.12,42.28 v1(62.71,41.87) ; v1(22.73,38.97) 22.73,32.12 21.97,31.35 21.97,27.93 20.19,26.15 20.19,22.59 19.43,21.83 18.03,21.83 16.55,20.35 16.55,19.63 17.48,18.7 R2712.2
  TOP w0.305: R1730.1 125.68,52.55 125.68,51.88 v1(126.09,51.47) ; RN1801.2 136.11,46.16 135.86,45.91 135.61,45.91 135.41,46.11 RN1801.1
  TOP w0.508: v1(223.22,38.57) 223.91,39.27 C2503.1 v2(226.09,39.27) 226.45,39.27 v1(227.1,38.62) ; 135.86,45.91 135.58,45.63 131.8,45.63 v1(127.76,49.67) 127.5,49.67 126.36,50.8 126.36,51.19 v1(126.09,51.47)
  L3 w0.508: v1(227.1,38.62) 225.93,39.79 224.21,39.79 223.22,40.78 221.44,40.78 219.56,42.66 213.73,42.66 213.18,42.11 211.85,42.11 210.57,40.83 210.57,38.47 210.21,38.11 208.39,38.11 207.4,39.1 206.49,39.1 206.12,38.73 206.12,38.2 205.75,37.83 205.22,37.83 204.22,38.84 204.22,39.62 203.08,40.75 202.51,40.75 199.47,37.7 193.8,37.7 193.14,38.36 189.53,38.36 189.41,38.24 189.38,38.24 188.24,37.09 183.18,37.09 v1(181.25,35.16) ; v1(223.22,38.57) 222.48,39.3 219.13,39.3 216.51,36.69 216.51,32.6 215.82,31.92 215.82,25.07 218.11,22.78 218.11,18.35 220.45,16.01 226.6,16.01 226.87,15.73 v1(226.87,15.48)
  L4 w0.102: v1(22.73,38.97) 22.99,38.97 25.53,41.51 25.53,45.58 27.3,47.36 35.43,47.36 35.69,47.61 36.96,47.61 37.78,48.44 37.78,50.85 38.73,51.8 45.59,51.8 46.23,51.17 48.64,51.17 50.42,49.39 53.06,49.39 54,48.45 54,45.81 v1(54.46,45.35)
  BOTTOM w0.102: v1(62.71,41.87) 62.29,41.87 57.15,36.73 57.15,35.66 57.5,35.31 57.5,34.31 54.96,31.77 53.75,31.77 52.58,32.95 52.58,35.29 53.72,36.43 53.72,38.09 55.75,40.12 55.75,44.05 v1(54.46,45.35)
  BOTTOM w0.305: v1(126.09,51.47) 126.09,52.33 R2106.1
  BOTTOM w0.508: R2473.2 227.56,6.67 229.64,8.75 229.64,10.23 228.68,11.19 226.94,12.93 226.93,13.12 226.93,13.18 226.91,13.77 226.87,13.81 v1(226.87,15.48) ; v1(181.25,35.16) 180.96,34.87 180.07,34.87 179.79,34.59 167.74,34.59 166.59,35.75 143.05,35.75 129.13,49.67 v1(127.76,49.67) ; v1(227.1,38.62) 227.62,38.1 D2501.3
RTC_DET#: length 135
  TOP w0.102: v1(225.07,42.81) 224.92,42.96 224.92,43.34 v2(224.99,43.42) 226.25,43.42 Q2505.D ; RN2013.4 144.15,81.27 143.13,80.25 v1(142.88,80.25)
  L3 w0.102: v1(225.07,42.81) 224.79,43.09 213.55,43.09 213.01,42.54 211.54,42.54 209.07,40.07 208.61,40.07 207.85,40.83 207.85,42.11 205.29,44.66 203.23,44.66 201.74,46.14 200.3,46.14 195.79,41.64 186.09,41.64 184.74,40.29 184.18,40.29 183.6,39.71 183.07,39.71 182.92,39.86 182.49,39.86 181.75,40.6 179.64,40.6 179.51,40.46 172.03,40.46 169.26,43.23 168.48,43.23 166.77,44.93 165.87,44.93 157.1,53.71 157.1,61.05 156.37,61.78 154.32,61.78 149.69,66.41 147.53,66.41 145.01,68.92 144.09,68.92 142.88,70.14 v1(142.88,80.25)
  BOTTOM w0.089: 135.17,79.78 134.91,79.52 134.91,79.48 134.4,78.97 133.51,78.97 133.32,79.16 132.04,79.16 132.02,79.14 CPU1.P1
  BOTTOM w0.102: 135.17,79.78 135.25,79.87 135.74,79.87 136.07,79.54 137.23,79.54 137.39,79.69 137.72,79.69 137.75,79.72 138.43,79.72 138.75,80.05 140.39,80.05 140.59,80.25 141.77,80.25 141.82,80.3 142.28,80.3 142.33,80.25 v1(142.88,80.25)
RTC_PWR: length 8.5
  TOP w0.508: v1(229.3,45.13) 228.54,44.37 Q2505.G
  BOTTOM w0.508: D2501.2 230.95,40.34 229.9,41.39 v2(229.9,41.46) 230.78,42.35 230.78,43.93 230.35,44.37 R2502.1 229.36,44.37 R2504.1 v1(229.3,45.13)
RTC_RST#: length 40.9
  TOP w0.127: Q1802.D 136.19,47.93 RN1801.3 136.11,48.67 136.4,48.96 v1(136.4,48.98) ; v1(123.32,70.22) 123.32,70.21 123.81,69.72 123.81,68.6 123.92,68.49 123.92,67.83 123.74,67.65 123.74,66.68 123.97,66.44 124.08,66.44 124.51,66.01 124.51,65.26 123.79,64.54 123.79,62.96 122.89,62.06 122.89,61.38 123.77,60.5 123.77,59.96 124.12,59.61 124.12,57.19 v1(126.04,55.26)
  L3 w0.127: v1(136.4,48.98) 136.32,49.06 134.71,49.06 132.65,51.12 132.65,52.86 132.53,52.98 129.35,52.98 127.07,55.26 v1(126.04,55.26)
  BOTTOM w0.127: EC1807.1 C1805.1 137.38,48.66 G1801.2 137.52,49.77 137.31,49.97 v2(137.23,49.97) 136.9,49.97 136.4,49.48 v1(136.4,48.98) ; CPU1.AM16 123.08,70.45 123.31,70.22 v1(123.32,70.22)
RTC_X1: length 24.4
  L4 w0.114: v1(122.42,70.13) 122.76,69.78 122.76,69.7 122.82,69.64 122.82,68.02 123.16,67.68 123.49,67.68 123.93,68.12 124.58,68.12 124.71,67.99 124.71,66.88 126.59,65.01 128.52,65.01 132.46,61.07 v1(132.51,61.07)
  BOTTOM w0.114: v1(132.51,61.07) 132.51,61.02 134.16,59.37 v2(134.16,58.56) 134.29,58.43 R1815.1 134.48,57.45 134.68,57.45 134.94,57.2 C1804.1 137.25,57.2 X1802.1 ; CPU1.AM18 122.09,70.45 v1(122.42,70.13)
RTC_X2: length 25.4
  L4 w0.114: v1(131.8,59.27) 131.8,59.28 129.98,61.1 129.54,61.1 126.01,64.63 124.15,64.63 121.97,66.8 121.97,69.66 v1(121.5,70.13)
  BOTTOM w0.114: v1(131.8,59.27) 131.9,59.27 v2(132.33,58.84) 133.5,57.67 133.5,57.14 133.95,56.69 R1815.2 134.65,56.33 C1803.1 135.52,56.33 X1802.2 ; v1(121.5,70.13) 121.18,70.45 CPU1.AM20
RTCRST_ON: length 94.1
  TOP w0.127: Q1802.G 138.35,45.25 140.47,45.25 EC1808.1 R1837.1 151.5,45.51 158.15,38.86 163.44,38.86 164.47,37.83 169.95,37.83 172.53,40.41 v2(175.64,40.41) 180.16,40.41 181.76,38.81 186.75,38.81 v1(187.17,39.23) ; v1(217.17,35.72) 217.27,35.72 217.61,35.38 217.61,34.96 217.4,34.74 KBC24.31
  L4 w0.127: v1(187.17,39.23) 188.09,38.31 196.08,38.31 197.45,39.67 204.55,39.67 204.8,39.93 206.05,39.93 206.15,39.82 208.92,39.82 209.88,40.79 211.55,40.79 212.51,39.82 213.3,39.82 v1(214.86,41.39)
  L6 w0.127: v1(214.86,41.39) 216.12,40.13 216.12,39.37 216.41,39.08 216.41,38.21 217.27,37.35 217.27,35.82 v1(217.17,35.72)
RUNPWROK: length 3.8
  TOP w0.127: KBC24.48 209.11,37.7 208.1,38.71 v2(208.1,38.75) 207.18,39.67 R2481.1
SA0_CHA_DIM0: length 6.7
  TOP w0.102: R1205.2 112.66,8.96 112.32,9.31 v2(112.06,9.31) ; R1205.2 R1204.1 ; R1205.2 112.98,9.59 v1(113.03,9.64)
  BOTTOM w0.102: v1(113.03,9.64) 112.85,9.81 110.74,9.81 110.48,10.08 DM1.256
SA0_CHB_DIM0: length 8.8
  TOP w0.102: R1302.1 R1303.2 188.15,10.72 v2(187.83,11.03) 187.66,11.21 187.66,14.44 v1(187.64,14.45)
  BOTTOM w0.102: DM2.256 187.48,12.78 187.66,12.96 187.66,14.44 v1(187.64,14.45)
SA1_CHA_DIM0: length 6.4
  TOP w0.102: v2(115.39,9.89) 114.94,9.89 v1(114.78,9.74) 114.78,9.46 114.76,9.43 R1208.1 R1210.2
  BOTTOM w0.102: v1(114.78,9.74) 114.78,9.76 114.27,10.27 112.45,10.27 111.48,11.24 DM1.260
SA1_CHB_DIM0: length 4.7
  BOTTOM w0.102: v2(188.85,8.75) 189.29,8.75 R1307.1 189.74,9.07 R1306.1 188.48,10.46 DM2.260
SA2_CHA_DIM0: length 4.5
  TOP w0.102: v1(87.97,10.02) 88.11,10.16 88.11,10.99 R1212.2 88.32,11.2 R1211.1 89.08,10.45 v2(88.85,10.22)
  BOTTOM w0.102: v1(87.97,10.02) DM1.166
SA2_CHB_DIM0: length 7.4
  TOP w0.102: v1(163.52,14.34) 164.19,13.67 v2(164.19,13.42) 164.19,12.61 163.86,12.28 R1310.1 163.09,11.86 R1311.2
  BOTTOM w0.102: DM2.166 164.98,12.37 164.79,12.56 164.79,13.19 163.65,14.34 v1(163.52,14.34)
SATA#/BATT_LED_MUXCTL: length 258.6
  TOP w0.127: v1(79.96,72.07) 78.78,73.25 75.07,73.25 74.46,73.86 U9601.11
  L6 w0.127: v1(73.85,50.15) 74.42,49.58 74.42,36.53 58.6,20.72 45.55,20.72 41.09,16.27 41.09,13.96 46.94,8.11 47.89,7.16 53.26,7.16 53.59,7.49 54.46,7.49 55.22,6.73 60.17,6.73 62.73,4.17 67.86,4.17 68.51,3.52 84,3.52 84.67,2.84 133.54,2.84 136.15,5.45 137.92,5.45 140.07,7.6 145.93,7.6 187.02,7.61 189.88,10.46 193.79,10.46 195.51,12.19 196.52,12.19 v1(196.79,12.46)
  BOTTOM w0.127: v1(73.85,50.15) 74.36,50.15 76.62,52.41 76.62,64.21 80.02,67.62 v2(80.02,70.27) 80.02,71.78 79.96,71.84 v1(79.96,72.07) ; v1(196.79,12.46) 197.87,12.46 198.79,13.38 Q6401.G 199.49,11.83 R6401.2
SATA_DE1_HDD: length 4.2
  TOP w0.102: v2(259.13,30.41) 259.66,30.41 v1(259.71,30.47) 259.85,30.6 U5601.9
  BOTTOM w0.102: v1(259.71,30.47) 260.22,30.97 R5613.2 R5612.1
SATA_DE2_HDD: length 4.6
  TOP w0.102: U5601.8 v1(259.71,31.1) 259.09,31.73 v2(259.09,31.81)
  BOTTOM w0.102: R5614.1 259.37,31.44 v1(259.71,31.1) 260.48,31.86 R5615.2
SATA_EQ1_HDD: length 4.3
  TOP w0.102: U5601.17 266.18,30.6 v1(266.32,30.47)
  BOTTOM w0.102: v2(267.21,28.69) 267.21,29.51 R5610.1 266.32,30.4 v1(266.32,30.47) 265.94,30.85 R5611.2
SATA_EQ2_HDD: length 3.7
  TOP w0.102: U5601.19 266.18,31.6 v1(266.32,31.74)
  BOTTOM w0.102: v2(267.08,30.72) 267.08,31.67 R5608.1 v1(266.32,31.74) R5609.2
SATA_LED#_R: length 137.4
  TOP w0.127: R1609.2 195.64,10.63 195.64,11.77 195.9,12.02 195.9,13.38 196.22,13.7 v2(197.74,13.7) 197.99,13.96 v1(197.99,14.34)
  L4 w0.127: v1(135.71,84.72) 135.71,84.54 134.85,83.68 134.85,74.03 138.87,70.01 138.87,68.21 139.06,68.02 139.06,65.37 141.74,62.7 141.74,56.55 146,52.28 149,52.28 152.41,48.87 153.12,48.87 154.25,47.74 157.86,47.74 158.93,48.8 171.02,48.8 173.44,46.39 181.09,46.39 181.25,46.54 184.26,46.54 184.42,46.39 191.13,46.39 192.1,47.36 v1(194.94,47.36)
  L6 w0.127: v1(194.94,47.36) 194.94,39.76 196.7,38 196.7,34.4 197.55,33.56 197.55,30.95 197.1,30.5 197.1,27.42 197.82,26.71 197.82,14.78 197.99,14.61 v1(197.99,14.34)
  BOTTOM w0.127: CPU1.H1 134.09,82.54 134.62,83.07 134.62,83.73 134.87,83.98 134.87,84 135.06,84.19 135.06,84.29 135.47,84.69 135.69,84.69 v1(135.71,84.72) ; v1(197.99,14.34) 197.45,13.79 197.45,13.42 197.48,13.38 Q6401.S
SATA_RN1/PERN6_L0: length 58
  TOP w0.127: v1(97.66,97.65) 97.66,99.3 ; 97.66,99.3 97.66,111.85 96.66,112.85 96.66,115.01 97.6,115.95 R6207.1 ; 97.66,99.3 v2(97.51,99.3)
  L6 w0.102: v1(119.67,83.02) 120.11,83.45 120.11,85.28 118.05,87.34 118.05,88.56 120.62,91.14 120.62,92.41 120.1,92.94 120.09,92.94 120.07,92.95 118.7,92.95 117.3,91.55 110.15,91.55 106.47,95.24 105.49,95.24 102.8,97.93 98.25,97.93 97.97,97.65 v1(97.66,97.65)
  BOTTOM w0.127: v1(119.67,83.02) 120,82.69 CPU1.G21
SATA_RP1/PERP6_L0: length 57.1
  TOP w0.127: R6205.1 97.5,115.28 97.27,115.28 96.9,114.91 96.9,112.95 97.9,111.95 97.9,101.2 ; 97.9,101.2 v2(98.07,101.2) ; 97.9,101.2 97.9,98.07 98.12,97.85 98.35,97.85 98.48,97.72 98.48,97.24 v1(98.37,97.14)
  L6 w0.102: v1(119.67,83.67) 119.91,83.9 119.91,85.2 117.85,87.26 117.85,88.65 120.42,91.22 120.42,92.32 120.01,92.73 120,92.73 119.99,92.75 118.79,92.75 117.39,91.35 110.07,91.35 106.38,95.03 105.41,95.03 102.72,97.72 98.33,97.72 98.23,97.62 98.23,97.28 v1(98.37,97.14)
  BOTTOM w0.127: CPU1.F21 120,83.34 v1(119.67,83.67)
SATA_RX_CON_N0: length 12.9
  TOP w0.127: v1(268.1,18.19) 267.91,18.38 267.91,18.9 267.5,19.3 265.48,19.3 264.97,19.82 ; 264.97,19.82 264.27,20.51 264.27,20.72 264.4,20.85 ED6001.7 ED6001.4 264.4,22.75 264.28,22.87 264.28,23.1 262.6,24.78 262.6,25.41 C6004.2 ; 264.97,19.82 v2(265.13,19.97)
  BOTTOM w0.127: v1(268.1,18.19) 267.97,18.32 267.97,18.81 268.15,18.99 HDD1.5
SATA_RX_CON_P0: length 12.9
  TOP w0.127: C6003.2 262.36,25.35 262.36,24.68 262.87,24.17 ; v2(262.71,24.01) 262.87,24.17 ; 262.87,24.17 264.04,23 264.04,22.87 263.92,22.75 ED6001.5 ED6001.6 263.92,20.87 264.03,20.76 264.03,20.41 265.38,19.06 267.4,19.06 267.67,18.8 267.67,18.55 v1(267.38,18.27)
  BOTTOM w0.127: v1(267.38,18.27) 267.46,18.27 267.73,18.54 267.73,18.91 267.65,18.99 HDD1.6
SATA_RX_CPU_N0: length 176
  TOP w0.127: v1(262.78,36.21) 262.78,35.62 C5620.2
  L6 w0.102: v1(120.59,83.66) 120.85,83.93 121.11,83.93 121.9,84.72 123.79,84.72 124.67,83.84 124.67,82.84 124.18,82.34 124.03,82.34 123.41,81.72 123.41,80.21 123.95,79.66 130.68,79.66 131.16,80.14 135.99,80.14 137.98,78.15 137.98,77.29 139.54,75.73 139.54,73.81 141.6,71.74 144.07,71.74 146.23,69.58 146.23,67.92 148,66.15 149.06,66.15 151.63,63.59 151.63,61.09 153.32,59.4 162.35,59.4 166.16,55.59 167.21,55.59 168.27,54.52 169.98,54.52 171.1,53.4 179.28,53.4 179.66,53.02 189.46,53.02 189.92,52.56 211.09,52.56 214.03,49.62 217.38,49.62 218.26,48.74 218.26,48.17 218.26,47.59 221.93,43.93 223.55,43.93 225.13,43.93 230.38,38.68 230.38,37.9 233.08,35.19 238.1,35.19 238.79,35.88 243.34,35.88 244.15,35.06 261.93,35.06 262.45,35.58 262.45,35.88 v1(262.78,36.21)
  BOTTOM w0.127: v2(262.76,35.65) 262.76,36.2 v1(262.78,36.21) ; CPU1.F20 120.91,83.34 v1(120.59,83.66)
SATA_RX_CPU_N0_R: length 1.7
  TOP w0.127: U5601.4 262.64,33.76 262.51,33.89 262.51,34.47 C5620.1
SATA_RX_CPU_P0: length 175.8
  TOP w0.127: v2(120.01,84.25) 120.4,84.25 v1(120.55,84.4) ; C5619.2 261.89,35.62 v1(261.89,36.21)
  L6 w0.102: v1(120.55,84.4) 120.82,84.13 121.03,84.13 121.82,84.92 123.87,84.92 124.87,83.93 124.87,82.75 124.26,82.14 124.11,82.14 123.61,81.64 123.61,80.3 124.04,79.87 130.6,79.87 131.07,80.34 136.08,80.34 138.19,78.23 138.19,77.37 139.74,75.81 139.74,73.89 141.69,71.94 144.15,71.94 146.43,69.67 146.43,68.01 148.08,66.36 149.15,66.36 151.83,63.67 151.83,61.18 153.41,59.6 162.43,59.6 166.24,55.79 167.29,55.79 168.36,54.72 170.06,54.72 171.18,53.6 179.36,53.6 179.74,53.23 189.54,53.23 190,52.77 211.17,52.77 214.12,49.82 217.47,49.82 218.47,48.82 218.47,48.09 218.47,47.68 222.01,44.13 223.47,44.13 224.77,44.13 224.78,44.13 225.21,44.13 230.58,38.76 230.58,37.98 233.17,35.39 238.02,35.39 238.7,36.08 243.42,36.08 244.23,35.27 261.85,35.27 262.24,35.66 262.24,35.85 v1(261.89,36.21)
  BOTTOM w0.127: CPU1.E20 120.96,83.99 v1(120.55,84.4)
SATA_RX_CPU_P0_R: length 1.8
  TOP w0.127: U5601.5 262.14,33.76 262.27,33.89 262.27,34.07 C5619.1
SATA_RX_R_N0: length 2.8
  TOP w0.127: U5601.12 262.64,28.44 262.54,28.34 262.54,26.94 C6004.1
SATA_RX_R_P0: length 3
  TOP w0.127: U5601.11 262.14,28.46 262.3,28.3 262.3,27.54 ; 262.3,27.54 262.3,26.89 C6003.1 ; 262.3,27.54 v2(262.08,27.54)
SATA_TN1/PETN6_L0: length 57.6
  TOP w0.127: C6205.1 97.26,117.22 96.79,117.22 96.6,117.03 96.6,115.84 96.02,115.27 96.02,112.59 96.9,111.71 96.9,111.2 96.63,110.93 96.2,110.93 96.07,110.8 96.07,110.42 96.2,110.29 96.63,110.29 96.9,110.03 96.9,108.16 ; v1(95.63,98.18) 95.83,98.38 96.35,98.38 96.9,98.94 96.9,108.16 ; 96.9,108.16 v2(97.08,108.16)
  L6 w0.102: v1(114.55,89.77) 114.55,90.09 114.11,90.54 109.73,90.54 107.81,92.45 107.67,92.45 107.16,91.95 106.85,91.95 106.44,92.36 106.44,92.67 106.95,93.17 106.95,93.32 106.06,94.21 105.03,94.21 102.34,96.89 101.97,96.89 101.87,96.79 101.87,96.61 101.65,96.39 101.07,96.39 100.85,96.61 100.85,96.79 100.75,96.89 100.35,96.89 100.24,96.79 100.24,96.61 100.02,96.39 97.6,96.39 97,96.99 96.66,96.99 96.34,97.31 96.34,98.05 96.09,98.3 95.75,98.3 v1(95.63,98.18)
  BOTTOM w0.089: CPU1.D21 119.46,85.15 119.46,85.79 119.41,85.93 119.41,86.19 119.47,86.34 119.47,86.44 119.41,86.58 119.41,87.49 118.79,88.11 118.72,88.11
  BOTTOM w0.127: 118.72,88.11 116.25,88.11 114.59,89.77 v1(114.55,89.77)
SATA_TP1/PETP6_L0: length 57.5
  TOP w0.127: C6204.1 97.29,117.46 96.69,117.46 96.35,117.13 96.35,115.94 95.78,115.37 95.78,112.49 96.66,111.61 96.66,111.3 96.53,111.17 96.1,111.17 95.83,110.9 95.83,110.32 96.1,110.05 96.53,110.05 96.66,109.93 96.66,105.7 ; 96.66,105.7 96.66,99.04 96.25,98.63 96.05,98.63 v1(95.63,99.05) ; 96.66,105.7 v2(96.49,105.7)
  L6 w0.102: v1(95.63,99.05) 96.54,98.14 96.54,97.39 96.74,97.19 97.09,97.19 97.68,96.59 99.94,96.59 100.04,96.7 100.04,96.88 100.26,97.1 100.84,97.1 101.06,96.88 101.06,96.7 101.16,96.59 101.56,96.59 101.67,96.7 101.67,96.88 101.89,97.1 102.42,97.1 105.11,94.41 106.14,94.41 107.15,93.4 107.15,93.09 106.65,92.59 106.65,92.44 106.94,92.15 107.08,92.15 107.58,92.66 107.89,92.66 109.81,90.74 114.2,90.74 114.86,90.08 v1(115.19,90.08)
  BOTTOM w0.089: CPU1.C21 119.64,85.62 119.64,85.83 119.59,85.96 119.59,86.16 119.65,86.31 119.65,86.47 119.59,86.61 119.59,87.61 118.85,88.35
  BOTTOM w0.127: v1(115.19,90.08) 115.19,89.52 116.35,88.35 118.85,88.35
SATA_TX_CON_N0: length 12.5
  TOP w0.127: 267.13,20.03 265.99,20.03 265.56,20.46 265.56,20.74 265.44,20.85 ED6001.9 ED6001.2 265.44,22.75 265.56,22.87 265.56,23.26 264.1,24.73 264.1,25.39 C6005.2 ; 267.13,20.03 267.99,20.03 269.26,18.75 269.26,18.3 v1(269.29,18.28) ; 267.13,20.03 v2(267.13,19.82)
  BOTTOM w0.127: HDD1.3 269.15,18.9 269.29,18.77 v1(269.29,18.28)
SATA_TX_CON_P0: length 12.8
  TOP w0.127: C6006.2 264.34,25.37 264.34,24.83 264.87,24.29 ; 264.87,24.29 265.8,23.36 265.8,22.87 265.92,22.75 ED6001.1 ED6001.10 265.92,20.87 265.8,20.75 265.8,20.56 266.09,20.27 268.09,20.27 269.74,18.62 269.76,18.62 v1(270.05,18.32) ; 264.87,24.29 v2(265.02,24.45)
  BOTTOM w0.127: v1(270.05,18.32) 269.65,18.73 HDD1.2
SATA_TX_CPU_N0: length 181.9
  TOP w0.127: v1(264.05,36.37) 264.05,35.88 C5618.1
  L6 w0.102: v1(119.91,88.28) 119.85,88.34 119.85,88.84 120.16,89.15 120.73,89.15 121.16,88.72 121.16,87.69 123.34,85.5 125.12,85.5 125.84,84.78 125.84,84.36 125.44,83.95 125.44,82.73 125.52,82.64 125.52,81.25 125.89,80.88 129.26,80.88 130.34,81.96 134.44,81.96 135.17,81.24 137.03,81.24 141.1,77.18 141.1,75.68 148.6,68.18 151.52,68.18 152.09,67.61 154.18,67.61 156.55,65.24 156.57,65.24 157.44,64.38 157.44,63.6 158.29,62.75 160.7,62.75 161,62.44 161.89,62.44 164.55,59.79 167.86,59.79 168.3,59.35 168.3,57.06 169.54,55.81 170.29,55.81 171.59,54.52 183.67,54.52 184.24,55.09 187.04,55.09 187.83,55.88 188.33,55.88 190.93,53.27 211.34,53.27 214.32,50.3 216.7,50.3 217.67,50.3 218.95,49.02 218.95,47.88 222.21,44.61 226.16,44.61 234.9,35.88 237.82,35.88 238.5,36.56 243.62,36.56 244.44,35.75 260.13,35.75 261.01,36.62 261.62,36.62 261.65,36.66 263.36,36.66 263.66,36.96 264.25,36.96 264.38,36.84 264.38,36.58 264.17,36.37 v1(264.05,36.37)
  BOTTOM w0.089: CPU1.B21 120.11,86.32 120.11,87.69 119.86,87.94 119.86,88.22 v1(119.91,88.28)
  BOTTOM w0.127: v1(264.05,36.37) 264.01,36.33 v2(264.01,35.72)
SATA_TX_CPU_N0_R: length 1.9
  TOP w0.127: U5601.2 263.64,33.53 264.03,33.92 264.03,34.21 C5618.2
SATA_TX_CPU_P0: length 181.8
  TOP w0.127: C5617.1 264.54,35.97 v1(264.94,36.37)
  L6 w0.102: v1(119.46,88.73) 120.08,89.35 120.82,89.35 121.36,88.81 121.36,87.77 123.42,85.7 125.21,85.7 126.04,84.87 126.04,84.27 125.64,83.87 125.64,82.81 125.73,82.72 125.73,81.33 125.97,81.09 129.18,81.09 130.26,82.16 134.53,82.16 135.25,81.44 137.12,81.44 141.3,77.26 141.3,75.77 148.68,68.39 151.61,68.39 152.18,67.82 154.26,67.82 156.64,65.44 156.66,65.44 157.64,64.46 157.64,63.68 158.37,62.95 160.78,62.95 161.09,62.65 161.98,62.65 164.63,59.99 167.95,59.99 168.5,59.43 168.5,57.14 169.63,56.02 170.38,56.02 171.67,54.72 183.59,54.72 184.16,55.29 186.95,55.29 187.74,56.08 188.41,56.08 191.02,53.48 211.43,53.48 214.4,50.51 216.62,50.51 217.75,50.51 219.15,49.11 219.15,47.96 222.3,44.82 226.24,44.82 234.98,36.08 237.73,36.08 238.42,36.76 243.71,36.76 244.52,35.95 260.05,35.95 260.86,36.76 260.93,36.83 261.53,36.83 261.57,36.87 263.28,36.87 263.58,37.17 264.34,37.17 264.58,36.92 264.58,36.73 v1(264.94,36.37)
  BOTTOM w0.089: v1(119.46,88.73) 119.46,88.07 119.92,87.61 119.92,86.78 CPU1.A21
  BOTTOM w0.127: v1(264.94,36.37) 264.94,36.29 v2(265.3,35.93)
SATA_TX_CPU_P0_R: length 1.7
  TOP w0.127: C5617.2 264.27,34.33 264.27,33.82 264.14,33.69 U5601.1
SATA_TX_R_N0: length 2.9
  TOP w0.127: U5601.14 263.64,28.44 263.77,28.31 263.77,27.84 264.1,27.52 264.1,26.91 C6005.1
SATA_TX_R_P0: length 3.1
  TOP w0.127: 264.34,27.49 264.34,26.92 C6006.1 ; 264.34,27.49 264.34,27.62 264.01,27.94 264.01,28.31 264.14,28.44 U5601.15 ; 264.34,27.49 v2(264.54,27.49)
SD_RCOMP: length 4
  TOP w0.381: R1901.1 125.23,74.46 v2(126.64,74.46) 127.9,74.46 128.37,74.93 v1(128.37,75)
  BOTTOM w0.305: v1(128.37,75) 128.37,75.34 CPU1.AB7
SD_READ_MODE#: length 196.4
  TOP w0.127: EC2001.1 129.41,70.98 129.44,70.95 v1(129.51,70.95) 129.56,70.9 130.06,70.9 130.93,70.03 R2050.2
  L4 w0.127: v1(129.51,70.95) 129.51,70.88 131.42,68.97 131.42,64.76 132.39,63.79 132.39,62.19 133.17,61.4 133.17,57.98 133.27,57.88 133.27,51.33 142.14,42.47 165.81,42.47 169.43,38.85 177.43,38.85 179.39,40.82 180.36,40.82 181.58,42.03 181.58,42.36 181.93,42.72 183.31,42.72 184.1,41.93 190.84,41.93 193.61,44.7 196.18,44.7 197.63,46.16 200.66,46.16 202.89,43.93 204.75,43.93 205.96,42.72 207.71,42.72 208.15,42.28 217.14,42.28 219.35,40.07 225.2,40.07 225.24,40.03 227.22,40.03 228.93,38.32 228.93,37.95 232.98,33.91 238.17,33.91 239.16,32.92 241.14,32.92 241.24,32.81 241.61,32.81 241.71,32.92 245.15,32.92 245.66,32.41 247.78,32.41 249.2,30.99 251.24,30.99 252.34,29.89 253.35,29.89 257.45,34 260.38,34 261.12,34.74 264.58,34.74 264.67,34.66 265.43,34.66 267.21,32.88 267.21,31.86 269.24,29.83 270.13,29.83 271.06,30.76 274.74,30.76 277.18,33.2 278.37,33.2 v1(279.48,34.3)
  BOTTOM w0.127: IOBD3.9 v1(279.48,34.3) 279.37,34.3 v2(279.02,34.66) ; v1(129.51,70.95) 129.46,70.9 129.29,70.9 128.97,70.59 128.97,70.11 CPU1.AN5
SERIRQ: length 106.4
  TOP w0.14: v1(135.28,51.72) 135.7,51.3 RN2001.4 ; v1(205.87,39.48) 205.87,39.28 206.32,38.83 KBC24.55
  BOTTOM w0.089: CPU1.AY11 126.07,65.07 126.07,63.93 125.92,63.78 125.92,63.37 126.15,63.14 126.94,63.14 127.43,62.65 127.49,62.65 127.7,62.43 127.7,62.37 127.85,62.22
  BOTTOM w0.14: 127.85,62.22 128.32,61.76 128.32,60.18 130.32,58.18 130.32,53.71 130.62,53.4 v2(130.63,53.4) 130.63,53.39 131.03,52.99 131.69,52.48 134.39,52.48 135.15,51.72 v1(135.28,51.72) 136.25,50.75 137.28,50.75 147.04,40.98 167.32,40.98 167.77,41.43 171.52,41.43 174.63,38.32 184.25,38.32 184.94,37.62 189.19,37.62 193.52,41.95 194.37,41.95 194.73,42.31 199.08,42.31 200.23,43.47 201.57,43.47 202.04,43.93 203.6,43.93 204.02,43.51 204.02,42.94 204.32,42.64 204.32,41.84 205.49,40.68 205.49,39.99 205.87,39.61 v1(205.87,39.48)
SERIRQ_TPM: length 2.6
  TOP w0.102: U9104.27 v1(248.93,25.27)
  BOTTOM w0.102: R9148.1 v1(248.93,25.27) 248.93,24.62 v2(249,24.56)
SIO_EXT_SCI#: length 9
  TOP w0.14: R2411.1 199.59,41.89 199.59,38.36 199.24,38.01 v2(199.24,37.5) 199.24,35.93 200.43,34.74 KBC24.66
SIO_EXT_SCI#_R: length 106.5
  TOP w0.102: R2411.2 199.26,43.29 v2(200.11,44.14) v1(201.04,45.07)
  L3 w0.102: v1(201.04,45.07) 200.79,45.07 197.16,41.44 186.17,41.44 184.83,40.09 184.27,40.09 183.68,39.51 183.33,39.51 182.99,39.51 182.84,39.66 182.41,39.66 181.67,40.39 179.73,40.39 179.36,40.03 172.64,40.03 172.62,40.04 172.05,40.04 172.04,40.03 170.49,40.03 168.99,41.53 168.99,42.43 166.69,44.73 165.79,44.73 156.9,53.62 156.9,60.97 156.29,61.57 154.23,61.57 149.61,66.2 147.44,66.2 144.93,68.72 144.01,68.72 141.68,71.04 141.68,79.33 137.26,83.75 v1(136.65,83.75) 136.65,83.26 135.79,82.41 131.52,82.41 130.49,81.38 v1(130.48,81.38)
  BOTTOM w0.102: R1608.2 136.46,84.15 136.65,83.96 v1(136.65,83.75) ; CPU1.J3 130.48,81.72 130.48,81.38 v1(130.48,81.38)
SIO_EXT_SMI#: length 3.8
  TOP w0.102: v1(217.81,26.36) 217.81,26.36 217.78,26.34 KBC24.10
  BOTTOM w0.102: v2(219.46,24.5) 219.46,24.74 R2412.1 218.76,25.32 217.81,26.27 v1(217.81,26.36)
SIO_EXT_SMI#_R: length 144.6
  L3 w0.102: v1(129.54,80.27) 133.05,80.27 133.43,80.65 134.42,80.65 135.16,81.39 136.23,81.39 136.44,81.18 137.71,81.18 v1(138.18,81.65)
  L4 w0.102: v1(203.2,48.71) 202.48,48.71 202.21,48.98 192.48,48.98 190.38,46.88 184.62,46.88 184.46,47.04 181.04,47.04 180.88,46.88 173.64,46.88 171.08,49.44 158.75,49.44 158.02,48.7 154.74,48.7 154.07,49.36 152.62,49.36 149.2,52.78 147.37,52.78 142.25,57.89 142.25,63.22 139.83,65.64 139.83,70.09 141.4,71.66 141.4,75.48 140.51,76.36 139.98,76.36 139.88,76.26 139.52,76.26 138.18,77.61 v1(138.18,81.65)
  L6 w0.102: v1(214.12,27.54) 213.56,26.99 213.08,26.99 211.33,28.74 211.33,34.1 211.66,34.43 213.11,34.43 213.46,34.78 213.46,39.31 212.17,40.61 212.17,44 206.88,49.29 206.22,49.29 205.72,48.79 203.28,48.79 v1(203.2,48.71)
  BOTTOM w0.102: v1(214.12,27.54) 214.36,27.79 215.5,27.79 215.52,27.77 217.01,27.77 218.58,26.21 R2412.2 v2(219.84,26.66) ; CPU1.L6 129.54,80.41 v1(129.54,80.27) ; R802.1 v1(138.18,81.65)
SIO_EXT_WAKE#: length 142.7
  TOP w0.102: v1(149.22,74.03) 149.22,74.79 149.35,74.92 149.35,75.93 149.02,76.26 148.29,76.26 147.47,77.07 147.47,80.89 147.5,80.91 147.5,81.96 147.47,81.98 147.18,82.28 146.3,82.28 145.94,81.92 RN2013.3 ; KBC24.116 210.31,22.46 210.21,22.57 v1(210.21,24.75)
  L3 w0.102: v1(183.16,57.83) 183.64,58.32 186.01,58.32 186.49,57.84 186.49,55.94 188.21,54.21 195.61,54.21 195.81,54.42 195.81,55.05 196.06,55.31 196.42,55.31 196.67,55.05 196.67,53.7 200.14,50.24 202.64,50.24 206.31,46.57 v1(208.19,46.57)
  L4 w0.102: v1(183.16,57.83) 182.87,57.83 182.19,58.52 181.43,58.52 181.29,58.38 180.69,58.38 180.44,58.63 180.44,60.89 180.34,60.99 180.34,61.89 179.29,62.94 179.29,63.59 177.53,65.34 177.53,65.44 176.33,66.65 172.84,66.65 170.38,69.1 169.56,69.1 168.42,70.24 167.29,70.24 166.97,70.56 166.87,70.56 166.24,71.18 166.24,72.25 164.5,73.99 164.5,74.76 161.5,77.76 154.92,77.76 152.1,74.94 150.14,74.94 v1(149.22,74.03)
  L6 w0.102: v1(210.21,24.75) 210.69,25.23 210.69,26.48 210.29,26.88 210.29,28.53 210.82,29.07 210.82,34.29 211.36,34.83 212.79,34.83 213.06,35.1 213.06,39.14 211.76,40.44 211.76,43.5 208.68,46.57 v1(208.19,46.57)
  BOTTOM w0.089: CPU1.AD3 131.27,73.54 131.67,73.54 131.68,73.54 131.81,73.47 133.88,73.47 133.88,73.47
  BOTTOM w0.102: v1(149.22,74.03) 148.86,74.03 148.06,74.83 148.06,75.07 147.8,75.32 145.87,75.32 v2(144.5,73.95) 142.06,73.95 141.2,73.09 138.04,73.09 137.74,73.39 134.92,73.39 134.53,73.78 134.2,73.78 133.88,73.47
SIO_PWRBTN#: length 236
  TOP w0.102: v1(204.44,34.2) 204.46,34.22 205.96,34.22 207.52,35.77 KBC24.52 ; v1(62.84,101.59) 62.97,101.46 R9926.1
  L3 w0.102: v1(62.84,101.59) 62.84,101.56 62.28,101 62.28,94.65 63.96,92.97 63.96,92.01 61.59,89.64 61.59,88.45 61.57,88.42 61.57,86.09 62.79,84.87 62.79,82.87 59,79.09 59,78.37 57.54,76.91 57.54,73.65 58.17,73.02 58.36,73.02 v1(58.78,72.6)
  L4 w0.102: v1(58.78,72.6) 58.8,72.62 59.44,72.62 61.52,70.55 71.04,70.55 72.67,68.92 75.7,68.92 80.13,73.36 87.97,73.36 88.39,72.93 88.39,72.22 89.01,71.6 89.24,71.37 89.81,70.81 117.27,70.81 117.93,71.47 119.74,71.47 120.06,71.15 120.7,71.15 120.99,70.86 120.99,68.66 120.89,68.57 120.89,66.6 121.43,66.06 121.69,66.06 121.93,65.83 121.93,65.56 124.4,63.09 v1(124.4,60.69) 125.25,60.69 125.87,60.07 125.87,59.63 125.46,59.22 125.46,58.86 125.71,58.61 127.62,58.61 131.24,54.99 131.24,50.45 149.88,31.81 168.17,31.81 168.32,31.97 171.18,31.97 176.66,37.45 178.94,37.45 182.42,40.93 183.36,40.93 184.13,40.17 185.2,40.17 185.96,40.93 188.31,40.93 189.55,39.69 190.17,39.69 193.24,42.76 193.24,42.96 193.5,43.22 195.86,43.22 197.43,44.79 v1(199.75,44.79)
  L6 w0.102: v1(204.44,34.2) 204.18,34.2 203.81,34.57 202.86,34.57 200.51,36.92 200.51,40 199.11,41.4 199.11,44.16 v1(199.75,44.79)
  BOTTOM w0.102: CPU1.BA15 123.39,64.51 123.12,64.24 123.12,61.72 v2(123.9,60.95) 124.14,60.95 v1(124.4,60.69)
SIO_RCIN#: length 121.8
  TOP w0.14: KBC24.53 207.12,35.98 205.97,34.83 204.47,34.83 v1(204.47,34.83)
  L4 w0.127: v1(125.89,59.04) 127.71,59.04 131.61,55.14 131.61,50.6 142.15,40.06 165.17,40.06 165.82,40.7 166.39,40.7 168.85,38.24 178.81,38.24 182.13,41.55 183.62,41.55 184.32,40.86 184.38,40.79 184.94,40.79 185.71,41.55 191,41.55 193.76,44.32 196.34,44.32 197.73,45.71 v1(200.47,45.71)
  L6 w0.114: v1(200.47,45.71) 200.47,43.61 199.47,42.61 199.47,41.55 200.87,40.15 200.87,37.14 203.08,34.93 204.32,34.93 204.41,34.83 v1(204.47,34.83)
  BOTTOM w0.089: 125.83,61.02 124.18,62.67 124.18,64.19 124.21,64.33 124.21,64.49 124.18,64.64 124.18,64.92 124.25,65.23 124.25,65.48 124.38,65.6 124.38,65.8 CPU1.AW13
  BOTTOM w0.14: 125.83,61.02 125.93,60.91 125.93,59.08 v1(125.89,59.04) 125.92,59.01 125.92,58.65 v2(126.97,57.59) 126.99,57.57 126.99,57.55 127.07,57.48 R1838.2
SIO_SLP_A#: length 1.2
  TOP w0.102: TP1706.1 122.42,69.06 v1(122.42,69.48)
  BOTTOM w0.102: CPU1.AN16 v1(122.42,69.48)
SIO_SLP_S3#: length 404.7
  TOP w0.127: v1(51.13,25.69) 52.42,25.69 57.71,30.98 120.37,30.98 120.79,30.98 126.83,37.02 148.05,37.02 156.22,28.85 165.61,28.85 167.16,27.3 v1(171.12,27.3) ; v1(215.44,23.94) 215.45,23.94 KBC24.4 ; Q4001.2 50.29,57.07 R4010.1 50.36,57.33 50.04,57.64 48.26,57.64 v1(47.88,57.26) ; PR5126.1 61.16,46.27 61.65,45.78 61.65,44.99 v1(61.37,44.71)
  L3 w0.127: v1(39.44,11.58) 41.53,13.67 41.53,16.8 47.73,22.99 47.73,23.89 49.17,25.33 49.17,25.36 49.5,25.69 v1(51.13,25.69) ; v1(215.44,23.94) 215.25,23.75 215.25,23.72 214.95,23.42 212.39,23.42 212.25,23.28 208.57,23.28 203.94,18.64 194.69,18.64 194.03,19.31 192.9,19.31 190.52,21.68 190.52,23.1 189.78,23.85 189.78,25.82 187.48,28.12 171.93,28.12 v1(171.12,27.3)
  L4 w0.127: v1(57,58.84) 56.99,58.85 48.83,58.85 47.88,57.9 v1(47.88,57.26)
  L6 w0.127: v1(124.23,68.77) 124.23,68.77 123.79,69.21 123.79,69.57 123.55,69.81 123.05,69.81 122.82,70.03 122.82,70.3 122.38,70.74 119.92,70.74 119.65,70.47 119.11,70.47 118.5,71.08 99.75,71.08 99.67,71.17 99.4,71.17 99.05,71.52 99.05,71.91 96.03,74.93 v1(85.57,74.93) ; v1(215.44,23.94) 215.58,24.08 215.58,31.97 216.73,33.12 216.73,37.31 216.09,37.95 216.09,39.04 215.86,39.27 215.86,39.28 v1(214.85,40.29) ; v1(39.44,11.58) 38.4,12.62 38.4,16.53 38.4,17.05 44.39,23.03 49.43,23.03 54.55,28.15 54.55,29.45 62.85,37.76 62.85,41.1 63.25,41.49 63.25,42.61 62.13,43.72 62.13,44.02 61.44,44.71 v1(61.37,44.71) 61.4,44.75 61.4,45.04 61.54,45.18 61.54,45.76 62.81,47.03 66.36,47.03 66.86,47.53 66.86,50.97 63.43,54.4 61.29,54.4 58.95,56.74 58.95,57.85 57.95,58.85 57.01,58.85 v1(57,58.84)
  BOTTOM w0.127: v1(61.37,44.71) 61.7,45.04 62.96,45.04 63.5,45.58 65.91,45.58 71.62,51.28 73.74,51.28 75.54,53.08 75.54,64.66 78.94,68.06 78.94,70.79 78.91,70.82 78.91,71.67 80.27,73.02 81.04,73.02 82.7,74.69 85.33,74.69 v1(85.57,74.93) ; v1(124.23,68.77) 124.17,68.77 124.11,68.83 124.11,68.83 CPU1.AP15 ; R2728.1 43.42,8.31 42.77,8.95 v2(41.5,8.95) 41.25,8.95 39.44,10.75 v1(39.44,11.58) ; v1(214.85,40.29) 214.19,40.96 R4020.1
SIO_SLP_S4#: length 364.6
  TOP w0.127: KBC24.67 200.09,34.34 198.69,35.74 198.69,40.05 199.12,40.49 199.12,41.4 198.75,41.77 198.75,45.53 199.24,46.01 v1(199.24,47.36)
  L3 w0.127: v1(51.82,9.89) 57.19,9.89 58.83,11.53 96.68,11.53 96.96,11.81 109.59,11.81 111.33,13.56 113.28,13.56 113.39,13.58 113.74,13.93 114.65,13.93 117.39,11.2 119.34,11.2 120.39,10.15 123.57,10.15 124.59,11.16 142.52,11.16 143.05,11.69 143.27,11.69 143.69,12.11 144.17,12.11 144.39,12.34 146.84,12.34 147.68,13.18 147.68,16 157.52,25.84 181.25,25.84 181.88,26.46 184.14,26.46 v1(184.23,26.38) ; v1(182.75,40.5) 182.75,40.93 182.31,41.37 182.31,43.35 182.57,43.61 182.82,43.61 183.46,44.24 191.09,44.24 191.35,43.98 191.35,43.87 191.84,43.38 192.21,43.38 192.83,44.01 195.89,44.01 v1(199.24,47.36) 199.24,47.96 194.89,52.31 183.07,52.31 180.92,54.46 171.4,54.46 170.38,55.47 166.01,55.47 164.8,56.68 164.8,60.07 165.71,60.98 165.71,61.62 166.75,62.66 166.75,65.41 168.07,66.72 168.64,66.72 168.9,66.98 168.9,70.22 166.28,72.84 166.03,72.84 164.76,74.11 162.47,74.11 161.4,75.18 161.4,76.01 162.5,77.11 162.5,81.88 157.51,86.87 v1(155.84,86.87)
  L4 w0.127: v1(182.75,40.5) 182.45,40.5 179.16,37.21 177.14,37.21 171.19,31.26 169.01,31.26 168.84,31.09 150.25,31.09 131,50.35 131,54.89 127.52,58.37 125.26,58.37 123.57,60.05 v1(123.31,60.05)
  L6 w0.127: v1(184.23,26.38) 184.12,26.48 184.12,37.27 182.75,38.64 v1(182.75,40.5)
  BOTTOM w0.089: 122.75,61.15 122.75,64.59 122.76,64.61 CPU1.BA16
  BOTTOM w0.127: PR5405.1 52.58,9.13 v1(51.82,9.89) ; v1(155.84,86.87) 155.63,86.66 R4023.1 154.62,86.73 U4005.2 ; v1(123.31,60.05) 123.1,60.05 122.82,60.32 v2(122.82,60.35) 122.75,60.43 122.75,61.15
SIO_SLP_S5#: length 7.4
  BOTTOM w0.102: TP1703.1 123.74,59.3 123.74,60.47 122.93,61.28 122.93,64.51 123.06,64.64 123.06,65.42 CPU1.AY16
SIO_SLP_SUS#: length 206.2
  TOP w0.102: KBC24.96 202,22.74 202.08,22.66 v1(202.82,22.66) ; R4104.1 158.24,50.79 158.5,50.53 158.5,47.25 v1(158.37,47.12) 157.86,46.61 157.86,45.93 157.1,45.17 157.1,41.85 159.59,39.36 163.57,39.36 164.46,38.47 166.43,38.47 PR5413.1 167.83,38.72 170.12,38.72 172.38,40.98 184.23,40.98 185.3,39.92 v1(185.98,39.92)
  L3 w0.102: v1(125.93,56.5) 126.06,56.63 126.06,57.31 124.97,58.41 124.97,62.06 123.09,63.94 123.09,66 123.75,66.66 123.75,68.97 123.33,69.39 v1(123.33,69.4) ; v1(186.16,29.96) 187.92,29.96 191.39,26.49 191.39,24.52 192.14,23.77 192.14,22.45 193.29,21.3 198.14,21.3 198.96,20.48 200.31,20.48 202.41,22.58 202.75,22.58 v1(202.82,22.66)
  L4 w0.102: v1(125.93,56.5) 129.53,52.9 129.53,49.93 153.37,26.1 174.04,26.1 182.4,34.45 183.51,34.45 186.22,37.16 186.22,39.68 v1(185.98,39.92)
  L6 w0.102: v1(186.16,29.96) 186.31,30.11 186.31,38.69 186.23,38.76 186.23,39.66 v1(185.98,39.92)
  BOTTOM w0.102: PR5306.1 202.37,24.05 202.57,23.86 202.91,23.51 202.91,22.75 v1(202.82,22.66) ; CPU1.AN15 123.71,69.8 123.33,69.42 v1(123.33,69.4) ; R1729.2 149.07,65.56 v2(149.07,64.62) 149.07,64.27 149.22,64.12 149.22,64.04 150.6,62.67 151.08,62.67 152.15,63.74 154.14,63.74 156.57,61.31 156.57,59.7 158.04,58.23 158.04,54.68 156.15,52.79 155.83,52.79 155.47,52.43 155.47,50.22 155.82,49.87 155.82,48.08 156.07,47.83 157.4,47.83 158.11,47.12 v1(158.37,47.12)
SKTOCC#: length 9.1
  BOTTOM w0.102: CPU1.A65 95.15,86.79 95.15,87.75 94.44,88.46 94.36,88.46 94.06,88.76 90.63,88.76 89.26,90.13 88.65,90.13 TP402.1
SLEEVE: length 13
  TOP w0.203: HDA27.18 18.83,12.02 RN2901.3
  TOP w0.305: v2(19.28,3.21) 18.97,2.91 v3(18.03,2.91)
  TOP w1.016: R2906.1 18.01,2.93 v3(18.03,2.91)
  L3 w1.016: v3(18.03,2.91) 18.21,3.08 18.21,11.11 v3(18.31,11.21)
SLEEVE_HPMIC1: length 28.7
  TOP w1.016: HPMIC1.3 6.4,6.92 7.49,5.83 8.99,5.83 v3(10.29,4.53) ; v3(11.4,3.39) 11.4,2.22 12.35,1.27 15.25,1.27 15.65,1.66 R2906.2
  BOTTOM w1.016: v3(10.29,4.53) 11.33,5.57 12.4,5.57 14.9,8.07 ED2901.1 16.9,6.83 v2(16.21,6.13) 15.29,5.22 14.07,5.22 12.24,3.39 v3(11.4,3.39)
SLP_LAN#: length 1.6
  TOP w0.127: v1(123.1,66.75) 123.09,66.73 123.09,66.39 TP1704.1
  BOTTOM w0.127: v1(123.1,66.75) 123.09,66.73 123.09,66.29 CPU1.AW15
SM_DRAMRST#: length 38
  TOP w0.127: ED502.2 147.21,57.19 R504.1 R505.2 146.05,56.95 v2(145.38,56.95) 144.11,56.95 141.47,59.6 141.47,61.98 139.49,63.96 136.57,63.96 134.18,61.57 126.37,61.57 126.11,61.31 123.53,61.31 123.29,61.55 123.29,61.89 125.01,63.6 125.01,65.83 124.93,65.9 124.93,66.82 v1(124.24,67.51)
  BOTTOM w0.127: v1(124.24,67.51) 124.24,67.64 124.45,67.85 CPU1.AT13
SM_INTRUDER#: length 17.5
  TOP w0.102: v1(123.33,68.74) 123.34,68.74 123.72,68.37 123.72,67.92 123.53,67.74 123.53,66.59 123.97,66.16 124.08,66.16 124.31,65.93 124.31,65.6 123.75,65.05 123.63,65.05 v2(123.32,64.73) 123.32,62.77 122.68,62.14 122.68,60.06 123.74,59 123.74,56.75 124.78,55.71 R1730.2
  BOTTOM w0.102: CPU1.AP16 123.28,68.74 v1(123.33,68.74)
SM_PGCNTL: length 26
  TOP w0.127: v1(78.98,57.02) 78.98,54.6 80.65,52.93 80.65,52.39 Q501.G
  BOTTOM w0.127: v1(78.98,57.02) v2(79.55,57.59) 79.98,58.02 83.28,58.02 83.37,58.11 84.67,58.11 90.07,63.51 92.29,63.51 92.76,63.98 92.76,64.25 93.39,64.88 93.39,65.5 93.6,65.71 CPU1.AW67
SM_PGCNTL_R: length 20.7
  TOP w0.127: v1(73.87,52.04) 74.33,52.5 R506.2 76.07,53.77 Q502.D ; PR5125.1 60.58,46.15 60.58,46.14 61.1,45.62 v1(61.1,45.6)
  BOTTOM w0.127: v1(73.87,52.04) 73.87,52.03 73.67,51.83 v2(72.59,51.83) 71.78,51.83 66.87,46.91 62.04,46.91 61.11,45.98 61.11,45.62 v1(61.1,45.6)
SM_RCOMP_0: length 3.6
  TOP w0.305: v1(121.5,68.18) 121.45,68.18 120.7,67.43 v2(120.7,66.81) 119.99,66.1 R501.1
  BOTTOM w0.305: CPU1.AR18 v1(121.5,68.18)
SM_RCOMP_1: length 2.9
  TOP w0.305: R502.1 120.88,65.85 121.89,66.86 v2(121.89,67.12) 121.89,67.13 v1(121.5,67.53)
  BOTTOM w0.305: CPU1.AT18 121.63,67.53 v1(121.5,67.53)
SM_RCOMP_2: length 2.4
  TOP w0.305: R503.1 122.38,66.84 v1(122.44,66.9) 122.52,66.9 123.06,67.45 v2(123.11,67.45)
  BOTTOM w0.305: v1(122.44,66.9) 122.26,66.9 CPU1.AU18
SMB_CLK_VGA: length 4.5
  TOP w0.14: v2(186.11,79.59) 185.72,79.2 v1(185.7,79.2) 185.7,78.55 185.58,78.43 185.58,77.99 185.67,77.9 R7912.2
  BOTTOM w0.14: v1(185.7,79.2) 185.22,79.2 184.52,79.91 GPU1.U7
SMB_CLK_VGA_GPUT8: length 58.1
  TOP w0.14: R7947.1 184.91,74.32 v1(184.91,73.59)
  L3 w0.127: v1(203.23,113.73) 202.29,114.67 199.26,114.67 198.63,114.03 198.63,105.4 197.24,104.01 197.24,95.49 190.44,88.68 190.44,86.92 188.49,84.97 188.49,80.74 189.43,79.79 189.43,77.67 189.43,77.41 188.84,76.82 188.84,76.8 188.59,76.55 188.58,76.55 188.29,76.26 187.68,76.26 185.61,74.19 185.61,74.19 185.01,73.59 v1(184.91,73.59)
  BOTTOM w0.14: THM263.8 204.77,111.7 204.66,111.81 204.43,112.03 203.9,112.03 203.81,112.13 203.64,112.13 203.26,112.51 C2619.1 v1(203.23,113.73) 203.22,113.73 v2(203.22,114.34)
SMB_CLK_VGA_R: length 15.4
  TOP w0.14: 184.02,72.81 184.28,73.07 184.28,74.66 184.35,74.82 184.78,75.25 R7947.2 R7912.1 ; 184.02,72.81 v2(183.87,72.96) ; 184.02,72.81 183.5,72.3 183.5,71.49 182.73,70.72 181.54,70.72 181.35,70.53 179.47,70.53 Q7901.1 179.2,69.95 179.57,69.58 179.57,68.15 179.42,68 178.91,68 178.47,67.55 RN7902.2
SMB_DATA_VGA: length 5.3
  TOP w0.14: v2(186.56,78.01) 186.41,78.17 v1(186.01,78.17) 185.95,78.11 185.95,77.67 R7914.2
  BOTTOM w0.14: GPU1.U8 183.81,80.2 184.88,79.14 184.88,78.75 185.28,78.35 185.83,78.35 v1(186.01,78.17)
SMB_DATA_VGA_GPUT8: length 57.3
  TOP w0.14: R7948.1 185.85,74.22 v1(185.85,73.48)
  L3 w0.127: v1(202.51,113.75) 202.51,114.1 202.19,114.42 199.36,114.42 198.87,113.93 198.87,105.29 197.49,103.91 197.49,95.39 190.68,88.58 190.68,86.82 188.73,84.87 188.73,80.84 189.68,79.89 189.68,77.57 189.67,77.57 189.67,77.31 189.08,76.72 189.08,76.7 188.69,76.31 188.68,76.31 188.39,76.02 187.78,76.02 185.85,74.09 v1(185.85,73.48)
  BOTTOM w0.14: v2(201.9,113.75) 202,113.75 v1(202.51,113.75) 202.51,112.77 C2620.1 202.56,112.44 202.56,112.13 202.82,111.87 203.08,111.87 203.09,111.86 203.64,111.86 204.12,111.39 THM263.7
SMB_DATA_VGA_R: length 17.8
  TOP w0.14: R7914.1 R7948.2 186.51,74.67 186.51,73.54 186.03,73.05 184.64,73.05 183.77,72.19 183.77,71.38 183.43,71.04 183.43,69.27 v2(182,67.83) 180.93,66.77 179.15,66.77 RN7902.1 180.77,68.46 Q7901.4
SMBCLK1: length 89.3
  TOP w0.14: v1(237.82,38.19) 237.82,38.61 237.45,38.97 236.7,38.97 236.56,38.83 234.6,38.83 234.1,39.33 233.75,39.58 232.26,39.58 231.9,39.23 231.9,35.71 ED4306.3 232.37,35.68 232.69,36 232.69,36.89 232.85,37.06 233.74,37.06 234.03,37.35 235.39,37.35 235.52,37.22 235.52,37 235.46,36.95 RN4302.3 ; 218.82,25.61 218.55,25.87 217.72,25.87 217.65,25.94 KBC24.9 ; 218.82,25.61 219.49,24.94 219.49,16.47 221.14,14.81 221.55,14.81 222.66,13.69 222.66,13.26 v1(222.95,12.98) ; 218.82,25.61 v2(218.97,25.77) ; v1(242.14,19.06) 242.08,19 PR4412.2 240.27,19 PG4410.2
  L3 w0.127: v1(237.82,38.19) 237.82,38.29 237.93,38.4 238.7,38.4 239.88,37.22 239.88,31.41 241.17,30.12 241.17,28.76 242.19,27.75 242.19,25.28 242.63,24.84 242.63,22.34 242.59,22.15 242.59,21.85 242.63,21.66 242.63,20.5 243.09,20.04 243.09,19.19 242.61,18.71 242.49,18.71 v1(242.14,19.06)
  L4 w0.127: v1(222.95,12.98) 222.95,12.65 223.18,12.42 225.17,12.42 226.66,13.9 226.86,13.9 233.4,13.9 234.58,12.72 234.94,12.72 235.33,13.12 235.33,13.74 240.32,18.72 241.65,18.72 241.78,18.72 v1(242.14,19.06)
  BOTTOM w0.14: v1(222.95,12.98) 222.63,13.29 222.63,13.7 222.25,14.08 221.56,14.08 221.21,13.73 221.21,12.58 222.5,11.29 222.5,10.43 222.31,10.23 RN2402.3
SMBCLK2: length 307.3
  TOP w0.14: R2483.1 v1(223.01,6.59) 222.98,6.62 RN2407.4 ; R2474.1 68.74,70.7 70.51,70.7 72.17,69.04 72.69,69.04 ; v1(215.11,26.51) 215.24,26.51 215.88,27.14 KBC24.12 ; 72.69,69.04 74.02,69.04 74.5,68.56 74.5,54.92 73.15,53.58 v1(73.15,52.56) ; 72.69,69.04 v2(72.69,68.84)
  L6 w0.114: v1(223.01,6.59) 222.14,5.71 221.22,5.71 220.56,6.37 203.47,6.37 200.62,9.22 190.24,9.22 188.94,7.91 188.27,7.91 187.37,7.01 146.17,7.01 140.93,7.01 138.72,4.81 136.35,4.81 133.74,2.2 84.48,2.2 83.75,2.93 68.76,2.93 68.76,2.92 68.27,2.92 67.62,3.58 62.49,3.58 59.93,6.14 48.08,6.14 46.8,7.42 40.5,13.71 40.5,16.69 45.12,21.31 58.36,21.31 73.83,36.78 73.83,47.83 72.43,49.22 72.43,51 73.15,51.73 v1(73.15,52.56)
  BOTTOM w0.14: v1(215.11,26.51) 215.13,26.51 216,25.64 216,25.61 216.28,25.33 216.28,18.08 220.26,14.11 220.26,12.41 221.19,11.48 221.19,8.91 221.5,8.6 221.5,7.84 221.87,7.48 222.5,7.48 222.77,7.21 222.77,6.83 v1(223.01,6.59) 222.77,6.34 222.75,6.34 222.48,6.07 222.48,4.87 222.7,4.64 Q2604.3
SMBDA1: length 84.1
  TOP w0.14: RN4302.2 235.96,37.05 235.91,37.1 235.91,37.34 235.63,37.62 233.92,37.62 233.63,37.32 232.97,37.32 232.84,37.45 232.84,38.58 232.85,38.59 ED4305.3 233.26,39.12 233.93,39.12 234.49,38.57 237.13,38.57 v1(237.21,38.49) ; PG4409.2 240.3,18.08 PR4411.2 242.05,18.08 242.09,18.12 v1(242.11,18.12) ; 221.18,14.54 221.44,14.54 222.4,13.58 222.4,13.26 v1(222.11,12.98) ; 221.18,14.54 v2(221.18,14.41) ; 221.18,14.54 221.03,14.54 219.22,16.36 219.22,24.83 218.44,25.61 217.72,25.61 217.65,25.54 KBC24.8
  L3 w0.127: v1(242.11,18.12) 242.37,18.12 243.33,19.09 243.33,20.14 242.87,20.6 242.87,21.68 242.83,21.87 242.83,22.13 242.87,22.32 242.87,24.94 242.43,25.38 242.43,27.85 241.41,28.86 241.41,30.22 240.12,31.51 240.12,37.32 238.8,38.64 237.34,38.64 237.21,38.52 v1(237.21,38.49)
  L4 w0.127: v1(242.11,18.12) 241.77,18.48 241.65,18.48 240.42,18.48 235.57,13.64 235.57,13.02 235.04,12.48 234.48,12.48 233.3,13.66 226.76,13.66 225.27,12.18 222.97,12.18 222.2,12.95 222.13,12.95 222.11,12.96 v1(222.11,12.98)
  BOTTOM w0.14: v1(222.11,12.98) 222.36,13.23 222.36,13.59 222.14,13.82 221.67,13.82 221.48,13.62 221.48,12.69 222.77,11.4 222.77,10.42 222.96,10.23 RN2402.4
SMBDA2: length 304.2
  TOP w0.14: 74.76,67.07 74.76,54.81 73.43,53.48 73.43,53.17 v1(73.66,52.94) ; 74.76,67.07 74.76,68.67 74.13,69.31 72.28,69.31 70.62,70.97 69.29,70.97 R2471.1 ; 74.76,67.07 v2(74.87,67.07) ; KBC24.11 215.91,26.74 215.66,26.49 215.66,26.18 v1(215.11,25.64) ; RN2407.3 222.33,6.67 v1(222.25,6.59) 222.12,6.46 R2482.1
  L6 w0.114: v1(222.25,6.59) 222.33,6.51 222.33,6.21 222.05,5.93 221.31,5.93 220.65,6.59 203.56,6.59 200.71,9.43 190.15,9.43 188.85,8.13 188.18,8.13 187.28,7.23 146.08,7.23 146.08,7.23 140.84,7.23 138.63,5.03 136.26,5.03 133.65,2.42 84.57,2.42 83.84,3.14 68.67,3.14 68.36,3.14 67.71,3.79 62.58,3.79 60.02,6.35 48.17,6.35 46.89,7.63 40.72,13.8 40.72,16.6 45.21,21.09 58.45,21.09 74.04,36.69 74.04,47.91 72.64,49.31 72.64,50.91 73.41,51.67 73.41,52.2 73.59,52.38 73.59,52.59 73.66,52.66 v1(73.66,52.94)
  BOTTOM w0.14: Q2604.6 221.92,5.94 222.24,6.26 222.24,6.58 v1(222.25,6.59) 222.5,6.84 222.5,7.1 222.39,7.21 221.75,7.21 221.23,7.73 221.23,8.49 220.92,8.8 220.92,11.37 219.99,12.3 219.99,14 216.01,17.97 216.01,25.22 215.74,25.5 215.74,25.53 215.62,25.64 v1(215.11,25.64)
SML0_SMBCLK: length 20.7
  TOP w0.14: v1(137.52,77.78) 137.99,77.78 138.44,78.23 142.52,78.23 v2(143.5,79.21) 144.38,80.08 RN1807.5
  L3 w0.127: v1(137.52,77.78) 137.08,78.22 133.39,78.22 133.18,78.01 132.85,78.01 132.64,78.22 131.7,78.22 131.19,78.73 127.89,78.73 127.71,78.55 127.42,78.55 v1(126.97,78.1)
  BOTTOM w0.14: v1(126.97,78.1) 126.97,78.12 126.99,78.13 126.99,78.24 CPU1.R9
SML0_SMBDATA: length 15.4
  TOP w0.14: v1(139.7,76.69) 139.77,76.76 142.97,76.76 144.49,78.28 RN1807.8
  BOTTOM w0.089: 134.68,75.87 133.91,76.64 132.39,76.64 132.2,76.83 131.83,76.83 131.74,76.8 131.51,76.8 CPU1.W2
  BOTTOM w0.14: 134.68,75.87 v2(136.22,75.87) 136.56,76.21 137.53,76.21 138.02,76.69 v1(139.7,76.69)
SML1_SMBCLK: length 309.6
  TOP w0.14: v1(181.77,69.6) 181.77,69.74 181.56,69.95 Q7901.6 ; v1(139.19,77.21) 142.78,77.21 144.5,78.93 RN1807.7 ; R2483.2 222.39,4.38 222.39,4.16 222.89,3.66 223.77,3.66 224.29,4.18 v1(224.29,4.56)
  L3 w0.127: v1(202.06,47.31) 201.51,47.85 201.51,47.96 200.65,48.83 199.55,48.83 195.45,52.93 183.32,52.93 181.18,55.08 171.65,55.08 170.64,56.09 166.27,56.09 165.42,56.94 165.42,59.81 166.33,60.72 166.33,61.29 167.37,62.33 167.37,65.15 168.33,66.1 168.9,66.1 170.13,67.33 172.17,67.33 172.81,66.69 176.18,66.69 177.48,67.99 178.8,67.99 179.88,69.07 181.25,69.07 v1(181.77,69.6) 178.65,69.6 178.21,69.15 177.39,69.15 175.2,71.35 172.85,71.35 171.32,72.87 171.32,76.19 170.77,76.74 168.45,76.74 167.49,75.77 164.94,75.77 163.91,74.74 163.01,74.74 v1(162.81,74.94)
  L4 w0.127: v1(75.54,94.27) 76.69,93.12 77.66,93.12 79.56,95.03 83.33,95.03 85.72,92.63 95.05,92.63 96.14,93.72 96.14,98.92 97.28,100.06 105.64,100.06 106.75,98.94 108.65,98.94 110.24,97.36 110.24,95.85 111.38,94.7 116.55,94.7 117.65,95.79 117.65,95.79 117.77,95.92 125.56,95.92 125.69,95.79 125.69,95.79 125.93,95.55 129.85,95.55 130.32,96.02 139.39,96.02 142.63,92.78 142.63,88.94 140.79,87.1 140.79,80.76 139.4,79.36 139.4,78.21 139.1,77.91 139.1,77.3 v1(139.19,77.21)
  L6 w0.114: v1(224.29,4.56) 224.72,4.98 224.72,5.67 223.24,7.14 222.74,7.14 221.97,7.91 214.24,7.91 211.99,10.16 211.99,11.1 211.23,11.86 211.23,13.9 210.32,14.81 207.38,14.81 204.7,17.48 204.7,17.79 204.51,17.98 204.51,19.75 204.53,19.77 204.53,20.65 203.26,21.92 203.26,22.86 204,23.6 204,24.41 203.58,24.83 203.58,25.89 205.23,27.54 205.23,29.2 205.38,29.36 205.38,30.02 205.48,30.12 205.48,30.57 204.45,31.59 204.45,32.37 203.61,33.21 201.9,33.21 199.93,35.18 199.93,39.66 198.25,41.35 198.25,44.6 199.76,46.11 199.76,48.11 200.06,48.41 201.23,48.41 201.76,47.88 201.76,47.6 v1(202.06,47.31)
  BOTTOM w0.089: 134.62,76.29 134.09,76.82 132.46,76.82 132.27,77.01 131.8,77.01 131.71,76.98 131.04,76.98 CPU1.W3
  BOTTOM w0.14: 134.62,76.29 135.49,76.29 135.83,76.63 137.36,76.63 137.84,77.11 139.1,77.11 v1(139.19,77.21) 139.49,77.5 144.62,77.5 146.01,76.12 148.77,76.12 150.13,74.76 150.65,74.76 150.81,74.6 150.81,74.6 151.94,73.47 155.75,73.47 155.91,73.31 157.27,73.31 157.86,73.9 159.33,73.9 ; v1(75.54,94.27) 76.16,93.64 Q2601.3 ; 159.33,73.9 161.29,73.9 162.33,74.94 v1(162.81,74.94) ; 159.33,73.9 v2(159.33,73.7) ; Q2604.4 221.88,4.22 223.96,4.22 v1(224.29,4.56)
