# Allegro board 16852-1.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
GND on TOP: 39.4,30.26 38.99,30.67 38.99,32.75 39.12,32.88 40.21,32.88 40.64,33.31 40.64,34.91 40.77,35.04 45.72,35.04 45.72,33.39 45.34,33.01 44.45,33.01 43.81,32.37 43.26,32.37 42.7,31.81 42.09,31.81 41.25,30.97 40.28,30.97 40.13,30.82 40.13,30.44 39.95,30.26 ; 1 cut-out
GND on TOP: 114.12,98.79 114.05,98.87 114.05,106.03 114.3,106.28 114.81,106.28 115.06,106.54 115.06,111.62 115.19,111.75 118.49,111.75 118.62,111.62 118.62,102.47 114.94,98.79 ; 15 cut-outs
GND on TOP: 116.59,116.7 115.87,117.41 115.06,117.41 113.92,118.55 113.92,123.81 114.68,124.57 117.09,124.57 117.35,124.32 117.35,122.16 117.22,122.03 116.33,122.03 116.2,121.91 116.2,120.38 116.59,120 125.86,120 125.98,119.87 125.98,117.46 125.22,116.7 ; 2 cut-outs
GND on TOP: 167.51,51.17 167.39,51.29 167.39,55.74 167.51,55.87 169.93,55.87 170.31,55.48 170.31,51.42 170.05,51.17 ; 2 cut-outs
GND on TOP: 47.42,89.52 46.66,90.28 41.27,90.28 41.15,90.41 41.15,91.55 41.4,91.81 41.91,91.81 42.16,92.06 42.8,92.06 43.18,91.68 43.18,91.43 43.43,91.17 45.59,91.17 45.72,91.3 46.61,91.3 47.75,90.16 47.75,89.65 47.62,89.52 ; 1 cut-out
GND on TOP: 62.46,112.81 62.33,112.94 62.33,114.11 62.74,114.51 69.7,114.51 69.93,114.29 69.93,113.24 69.49,112.81 ; 6 cut-outs
GND on TOP: 258.8,19.54 256.74,21.6 256.74,24.72 257.61,25.59 259.03,25.59 259.26,25.36 259.26,24.04 259.56,23.73 259.56,19.67 259.44,19.54 ; 7 cut-outs
GND on TOP: 44.68,56.55 44.42,56.8 44.42,57.95 44.68,58.2 46.96,58.2 47.22,57.95 47.22,56.68 47.09,56.55 ; 2 cut-outs
GND on TOP: 43.48,20.94 43.03,21.4 43.03,22.69 43.28,22.95 43.28,23.38 43.64,23.73 44.63,23.73 44.75,23.61 44.75,21.24 44.45,20.94 ; 2 cut-outs
GND on BOTTOM: 206.76,124.95 205.61,126.1 204.34,126.1 203.58,126.86 203.07,126.86 202.95,126.73 202.95,126.22 202.44,125.72 199.64,125.72 199.39,125.97 199.39,127.75 199.47,127.82 210.74,127.82 210.95,127.62 210.95,125.46 210.44,124.95 ; 2 cut-outs
GND on BOTTOM: 119.04,64.96 118.91,65.09 118.91,65.24 119.16,65.5 119.16,65.93 118.88,66.21 116.52,66.21 116.4,66.34 116.4,66.46 116.5,66.56 117.06,66.56 117.61,67.12 117.61,67.43 117.95,67.76 117.95,68.45 118.07,68.57 118.07,69.06 117.87,69.06 117.48,69.45 117.48,70.07 117.23,70.07 117.06,69.89 116.8,69.89 116.14,70.55 115.91,70.55 115.89,70.58 115.89,71.26 115.89,71.27 115.71,71.46 115.71,71.86 115.87,72.02 116.12,72.02 117.08,71.06 118.05,71.06 118.4,70.7 118.4,70.68 118.48,70.6 118.48,67.68 118.2,67.4 118.17,67.4 118.1,67.33 118.1,67.05 118.58,66.56 119.22,66.56 119.52,66.26 119.52,65.34 119.14,64.96
GND on BOTTOM: 25.53,54.72 25.4,54.85 25.4,57.39 25.53,57.52 26.29,57.52 26.54,57.77 26.54,58.66 26.67,58.79 27.43,58.79 27.56,58.66 27.56,57.77 27.81,57.52 27.81,56.88 27.69,56.75 27.05,56.75 26.92,56.63 26.92,55.61 27.18,55.36 27.18,54.85 27.05,54.72 ; 2 cut-outs
GND on BOTTOM: 92.53,74.04 92.51,74.06 92.51,74.6 92.74,74.83 96.95,74.83 97.08,74.7 97.08,74.57 96.98,74.47 96.37,74.47 95.94,74.04
GND on BOTTOM: 181.03,81.03 179.15,82.91 179.15,83.29 179.22,83.37 179.6,83.37 180.19,82.78 180.57,82.78 181.18,83.39 181.43,83.39 181.52,83.3 181.52,83.11 181.23,82.81 181.23,82.51 181.69,82.05 181.69,81.26 181.46,81.03
GND on BOTTOM: 208.53,44.82 208.41,44.94 208.41,46.47 208.53,46.59 210.67,46.59 211.53,47.46 212.88,47.46 213.23,47.1 213.23,44.94 213.11,44.82
GND on BOTTOM: 81.15,41.62 80.64,42.12 80.64,44.92 88.42,52.69 102.84,52.69 103.3,52.23 103.3,42.91 102.01,41.62
GND on BOTTOM: 209.42,99.05 209.17,99.3 209.17,100.7 210.57,102.09 210.57,104.13 210.31,104.38 209.17,104.38 208.91,104.63 208.91,105.01 209.3,105.4 209.3,107.68 207.9,109.08 207.9,113.22 208.03,113.35 209.14,113.35 209.58,113.78 209.58,114.56 209.73,114.72 210.34,114.72 210.52,114.89 210.52,116.39 209.88,117.03 209.8,117.03 209.8,118.1 209.68,118.22 209.68,118.73 209.8,118.86 211.38,118.86 211.38,118.86 211.81,118.86 212.04,118.63 212.04,107.24 212.05,106.94 212.08,106.65 213.29,99.05 ; 3 cut-outs
GND on BOTTOM: 195.78,104.23 195.71,104.3 195.71,106.03 196.09,106.41 197.87,106.41 198.25,106.79 198.25,108.7 197.87,109.08 197.23,109.08 197.1,108.95 195.88,108.95 195.71,109.13 195.71,117.21 195.83,117.33 197.36,117.33 198.06,116.63 198.06,115.75 199.9,113.9 199.9,104.38 199.75,104.23 ; 13 cut-outs
GND on BOTTOM: 138.71,101.94 138.57,102.08 138.57,102.84 138.56,102.86 138.56,106.41 138.81,106.67 140.08,106.67 140.84,105.9 140.84,103.08 139.7,101.94 ; 3 cut-outs
GND on BOTTOM: 115.06,116.44 114.94,116.57 114.94,120.64 114.68,120.89 114.05,120.89 113.92,121.02 113.92,123.68 114.05,123.81 114.68,123.81 115.82,122.67 119.18,122.67 119.43,122.92 120.52,122.92 120.65,122.79 120.65,120.25 121.03,119.87 125.86,119.87 125.86,117.59 125.73,117.46 124.97,117.46 124.84,117.59 124.84,117.97 124.71,118.1 124.08,118.1 123.95,117.97 123.95,117.33 123.83,117.21 120.27,117.21 119.89,116.83 117.73,116.83 117.35,116.44 ; 2 cut-outs
GND on BOTTOM: 68.83,92.06 68.58,92.31 68.58,93.33 69.6,94.35 70.87,94.35 70.99,94.22 70.99,92.95 70.87,92.82 69.85,92.82 69.47,92.44 69.47,92.19 69.34,92.06
GND on BOTTOM: outline of 202 points within 32.51,0.76 292.04,65.64 ; 4 cut-outs
GND on BOTTOM: 178.15,78.13 176.92,79.36 176.92,79.53 174.87,81.58 174.41,81.58 174.25,81.41 174.25,81.05 174.47,80.82 174.59,80.82 176.74,78.67 176.74,78.28 176.66,78.2 176.24,78.2 173.36,81.08 173.36,81.36 173.92,81.92 173.92,82.5 173.35,83.07 173.35,83.66 173.49,83.8 173.77,83.8 173.86,83.9 174.11,83.9 174.26,83.75 174.26,82.94 175.17,82.03 175.17,82.01 178.55,78.63 178.55,78.25 178.42,78.13
GND on BOTTOM: 41.91,86.85 41.78,86.98 41.78,88.25 41.91,88.38 43.94,88.38 44.07,88.25 44.07,86.98 43.94,86.85
GND on BOTTOM: 170.05,74.53 169.16,75.42 168.15,75.42 167.89,75.68 167.89,76.57 167.51,76.95 166.24,76.95 165.48,77.71 165.48,79.74 164.97,80.25 164.97,84.19 165.35,84.57 167.51,84.57 168.15,83.93 170.18,83.93 170.31,83.81 170.31,78.98 171.32,77.96 171.32,74.79 171.07,74.53
GND on BOTTOM: 72.9,55.36 72.39,55.87 72.39,62.09 72.64,62.34 73.53,62.34 73.79,62.09 73.79,55.48 73.66,55.36
GND on BOTTOM: 179.64,80.54 177.16,83.02 177.16,83.27 177.27,83.38 177.5,83.38 179.95,80.93 179.95,80.69 179.8,80.54
GND on BOTTOM: 175.77,57.77 175.64,57.9 175.64,59.55 175.51,59.68 174.88,59.68 174.75,59.8 174.75,59.93 174.88,60.06 176.53,60.06 176.66,59.93 176.66,58.66 176.73,58.58 177.55,58.58 177.67,58.46 177.67,57.9 177.55,57.77
GND on BOTTOM: 115.32,102.37 115.19,102.5 115.19,111.49 115.44,111.75 117.35,111.75 117.47,111.62 117.47,110.6 117.86,110.22 119.63,110.22 119.89,109.97 119.89,107.68 119.63,107.43 117.35,107.43 117.09,107.17 117.09,104 117.58,103.52 117.78,103.52 117.91,103.39 117.91,102.58 117.7,102.37 ; 1 cut-out
GND on BOTTOM: 223.01,21.83 222.76,22.08 222.76,23.23 222.88,23.35 222.88,25.26 223.27,25.64 225.68,25.64 226.82,24.5 226.82,22.97 225.68,21.83 ; 4 cut-outs
GND on BOTTOM: 21.72,5.7 21.46,5.95 21.46,8.37 20.7,9.13 19.68,9.13 19.18,8.62 18.29,8.62 18.21,8.7 18.21,9.38 18.72,9.89 20.57,9.89 21.21,10.53 21.21,13.7 22.07,14.56 24.82,14.56 24.97,14.72 26.06,14.72 26.42,14.36 26.42,12.05 25.91,11.54 25.91,10.4 25.53,10.02 25.15,10.02 24.89,9.76 24.89,8.11 25.15,7.86 25.15,7.48 25.02,7.35 23.75,7.35 23.5,7.61 22.99,7.61 22.72,7.34 22.72,5.83 22.61,5.71 22.61,5.7 ; 11 cut-outs
GND on BOTTOM: 204.93,60.74 203.58,62.09 202.06,62.09 201.93,62.22 201.93,63.49 203.71,65.26 203.71,65.9 203.84,66.03 206.83,66.03 208.51,64.35 208.51,60.87 208.38,60.74 ; 3 cut-outs
GND on BOTTOM: outline of 95 points within 2.36,22.93 15.88,80.86
GND on BOTTOM: 66.55,56.75 66.42,56.88 66.42,60.95 66.55,61.07 67.56,61.07 67.82,60.82 67.82,57.01 67.56,56.75
GND on BOTTOM: 177.16,122.16 177.04,122.29 177.04,124.06 177.29,124.32 180.34,124.32 180.59,124.06 180.59,122.29 180.47,122.16 ; 3 cut-outs
GND on BOTTOM: 208.15,91.17 208.03,91.3 208.03,95.49 208.28,95.74 209.8,95.74 209.93,95.62 209.93,95.24 210.31,94.85 210.82,94.85 210.95,94.73 210.95,91.43 210.69,91.17 ; 2 cut-outs
GND on BOTTOM: 23.11,35.16 22.86,35.42 22.86,38.47 25.27,40.88 30.48,40.88 31.37,39.99 31.37,36.82 31.24,36.69 28.07,36.69 26.54,35.16
GND on BOTTOM: 41.35,25.21 40.89,25.66 40.89,27.11 38.4,29.6 38.4,30.01 38.66,30.26 38.96,30.26 39.34,29.88 40.08,29.88 40.41,30.21 40.41,30.62 40.61,30.82 45.72,30.82 46.23,30.31 46.23,25.41 46.02,25.21
GND on BOTTOM: 63.14,22.64 61.93,23.86 61.93,31 67.67,36.74 110.77,36.74 115.93,41.9 126.06,41.9 132.61,35.34 132.61,26.07 131.47,24.93 123.24,24.93 123.19,24.88 110.24,24.88 108,22.64
GND on BOTTOM: 136.65,118.1 136.14,118.6 135.38,118.6 135.25,118.73 135.25,119.11 135.51,119.37 135.51,121.07 135.15,121.42 135.15,125.11 135.36,125.31 137.01,125.31 137.16,125.16 137.16,121.27 137.67,120.76 139.06,120.76 139.32,120.51 139.32,118.22 139.19,118.1 ; 5 cut-outs
GND on BOTTOM: 102.11,98.92 101.85,99.17 101.85,101.59 102.11,101.84 105.41,101.84 105.66,101.59 105.66,99.17 105.41,98.92
GND on BOTTOM: 48.26,2.65 48.13,2.78 48.13,8.11 48.39,8.37 51.44,8.37 51.56,8.24 51.56,5.57 51.44,5.45 50.04,5.45 49.78,5.19 49.78,2.91 49.53,2.65 ; 6 cut-outs
GND on BOTTOM: 194.56,81.27 194.18,81.65 194.18,85.08 195.33,86.22 197.36,86.22 197.74,85.84 197.74,83.3 195.71,81.27
GND on BOTTOM: 204.34,120.51 204.23,120.62 204.23,120.75 204.14,120.84 202.51,120.84 202.44,120.76 202.18,120.76 202.06,120.89 202.06,121.14 202.18,121.27 202.49,121.27 202.59,121.17 204.17,121.17 204.24,121.24 204.24,121.42 204.47,121.65 207.14,121.65 207.35,121.44 207.37,121.45 207.85,121.45 208.28,121.88 208.86,121.88 208.94,121.8 208.94,121.42 208.84,121.32 208.51,121.32 208.1,120.91 208.1,120.74 208.03,120.66 207.59,120.66 207.49,120.76 207.14,120.76 207.01,120.89 205.61,120.89 205.49,120.76 205.49,120.64 205.36,120.51
GND on BOTTOM: 149.99,123.68 149.86,123.81 149.86,125.21 149.99,125.33 151.38,125.33 151.51,125.21 151.51,123.81 151.38,123.68 ; 2 cut-outs
GND on BOTTOM: 261.85,22.85 260.5,24.19 260.5,28.1 260.55,28.15 261.39,28.15 262.2,27.34 262.89,27.34 263.86,26.38 263.86,23 263.7,22.85
GND on BOTTOM: 27.94,97.01 27.3,97.65 27.3,98.5 26.8,99 13.08,99 13.08,99.54 39.51,99.54 39.51,99.54 41.86,99.54 43.11,100.05 43.62,101.3 43.62,106.17 43.63,106.24 43.67,106.31 44.77,107.78 45.03,108.28 45.12,108.83 45.12,114.17 45.03,114.72 44.77,115.22 43.67,116.69 43.63,116.76 43.62,116.83 43.62,122.72 43.63,122.74 44.57,124.79 46.61,125.73 46.63,125.74 51.86,125.74 53.11,126.25 53.62,127.5 53.62,128.5 53.69,128.67 53.86,128.74 57.24,128.74 57.33,128.74 57.4,128.67 57.82,128.25 58.39,127.87 59.06,127.74 60.07,127.74 62.77,127.74 63.77,128.74 209.68,128.74 209.68,128.2 196.85,128.2 196.01,127.37 192.28,127.37 191.52,128.13 191.39,128.13 191.31,128.2 98.76,128.2 95.38,124.83 90.68,124.83 90.67,124.81 77.86,124.81 76.99,123.94 76.99,111.14 76.2,110.35 58.14,110.35 56.39,112.1 56.39,115.3 57.28,116.19 57.28,118.6 55.88,120 49.53,120 48.51,118.98 48.51,103.36 47.88,102.73 46.74,102.73 42.8,98.79 34.29,98.79 33.15,97.65 29.84,97.65 29.21,97.01 ; 4 cut-outs
GND on BOTTOM: 195.24,55.14 194.97,55.41 194.97,61.12 195.17,61.33 197.87,61.33 198.25,60.95 198.25,55.46 197.93,55.14
GND on BOTTOM: 193.68,67.93 193.17,68.44 193.17,70.85 193.55,71.23 197.74,71.23 198.12,70.85 198.12,68.31 197.74,67.93
GND on BOTTOM: 130.02,102.73 129.54,103.21 129.54,111.24 129.67,111.36 132.21,111.36 132.59,110.98 132.59,103.24 132.08,102.73 ; 10 cut-outs
GND on BOTTOM: 232.28,29.32 232.03,29.58 232.03,34.99 233.93,34.99 233.93,29.65 233.6,29.32 ; 2 cut-outs
GND on BOTTOM: 167.49,59.01 167,59.5 167,61.28 167.77,62.04 167.77,65.14 166.62,66.28 164.34,66.28 164.21,66.41 164.21,67.55 164.34,67.68 166.88,67.68 168.39,66.16 169.25,66.16 169.44,65.97 169.44,64.79 169.35,64.69 169.35,64.68 169.21,64.68 168.91,64.37 168.91,59.01 ; 6 cut-outs
GND on BOTTOM: 42.42,42.91 41.78,43.55 38.86,43.55 38.73,43.67 38.73,49.26 39.5,50.02 43.43,50.02 44.07,49.39 44.07,43.42 43.56,42.91
GND on BOTTOM: 17.45,26.15 17.2,26.4 17.2,27.9 17.53,28.23 17.98,28.23 18.29,27.93 19.68,27.93 20.07,27.54 20.07,26.27 19.94,26.15
GND on BOTTOM: 105.54,104.63 105.28,104.89 105.28,113.24 105.59,113.55 105.59,116.22 105.69,116.32 105.71,116.32 105.79,116.39 105.79,122.34 105.87,122.41 106.86,122.41 106.96,122.31 106.96,118.78 106.73,118.55 106.73,117.03 107.44,116.32 113.41,116.32 113.54,116.19 113.54,113.9 113.41,113.78 112.65,113.78 112.52,113.9 112.52,114.41 112.39,114.54 111.76,114.54 111.63,114.41 111.63,113.78 111.51,113.65 108.71,113.65 108.46,113.4 108.46,113.02 108.2,112.76 106.68,112.76 106.43,112.51 106.43,111.75 106.68,111.49 106.68,108.57 107.19,108.06 108.2,108.06 108.33,107.94 108.33,105.65 107.31,104.63 ; 2 cut-outs
GND on BOTTOM: 156.16,100.62 155.83,100.95 155.83,101.84 154.43,103.24 154.18,103.24 153.67,103.74 153.67,107.94 155.7,109.97 155.7,115.56 155.07,116.19 155.07,119.11 154.31,119.87 154.31,120.64 154.69,121.02 157.48,121.02 157.73,120.76 157.73,117.21 156.84,116.32 156.84,100.75 156.72,100.62 ; 20 cut-outs
GND on BOTTOM: 184.28,73.82 181.1,76.99 181.1,77.88 180.3,78.67 179.75,78.67 178.93,79.49 178.74,79.49 177.14,81.09 177.14,81.2 176.35,81.99 176.35,82.26 176.46,82.37 176.65,82.37 179.91,79.11 180.41,79.11 180.87,79.58 181.45,79.58 181.76,79.26 181.76,78.84 181.91,78.7 182.48,78.7 182.59,78.58 182.59,76.51 182.75,76.35 183.21,76.35 183.22,76.37 184.94,76.37 185.16,76.59 185.39,76.59 185.83,76.15 185.83,74.87 184.78,73.82
GND on BOTTOM: 262.76,28.92 262.05,29.63 262.05,30.47 261.87,30.64 261.29,30.64 261.16,30.77 261.16,34.07 261.21,34.12 265.02,34.12 265.13,34.02 265.13,29.35 264.69,28.92 ; 11 cut-outs
GND on BOTTOM: 190.75,69.07 190.5,69.33 190.5,70.6 191.52,71.61 191.52,72.12 191.64,72.25 192.28,72.25 192.41,72.12 192.41,69.2 192.28,69.07 ; 2 cut-outs
GND on BOTTOM: 213.18,66.63 212.39,67.42 209.3,67.42 209.04,67.68 209.04,70.72 209.3,70.98 215.14,70.98 215.26,70.85 215.26,69.71 216.03,68.95 216.79,68.95 217.04,68.69 217.04,67.26 216.79,67 214.8,67 214.43,66.63 ; 1 cut-out
GND on BOTTOM: 178.08,76.13 177.14,77.07 177.14,77.45 177.28,77.58 177.5,77.58 178.1,76.98 178.53,76.98 179.18,77.62 179.41,77.62 179.58,77.45 179.58,77.01 178.69,76.13
GND on BOTTOM: 273.3,25.89 272.97,26.22 272.97,28.13 273.23,28.38 273.23,30.19 273.43,30.39 276.38,30.39 276.56,30.57 276.56,31.43 275.89,32.09 273.84,32.09 273.69,32.24 273.69,32.88 273.81,33.01 274.35,33.01 274.45,33.11 274.45,33.69 274.57,33.82 274.57,33.79 276.1,33.79 276.2,33.89 277.75,33.89 277.9,33.74 277.9,28.2 277.67,27.98 275.11,27.98 275.11,27.93 274.29,27.11 274.29,26.12 274.07,25.89 ; 9 cut-outs
GND on BOTTOM: 239.57,23.99 239.37,24.19 239.37,27.85 238.96,28.26 238.96,28.53 239.04,28.61 239.98,28.61 240.61,27.98 244.25,27.98 244.4,27.82 244.4,25.66 243.41,24.67 241.1,24.67 240.41,23.99
GND on BOTTOM: 155.45,80 155.07,80.38 155.07,84.06 155.19,84.19 156.97,84.19 157.23,83.93 157.23,80.38 156.84,80 ; 2 cut-outs
GND on BOTTOM: 208.03,79.11 207.9,79.23 207.9,82.28 208.03,82.41 209.68,82.41 209.8,82.54 209.8,83.68 209.93,83.81 213.87,83.81 214,83.93 214.12,84.31 214.12,84.44 214.25,84.57 214.8,84.57 215.34,83.58 215.43,83.17 215.77,79.87 215.77,79.74 215.52,79.49 214.76,79.49 214.5,79.74 214.5,80.12 214.38,80.25 212.47,80.25 212.34,80.12 212.34,79.23 212.22,79.11
GND on BOTTOM: 100.58,102.47 100.2,102.86 100.2,105.4 100.58,105.78 103,105.78 103.25,105.52 104.9,105.52 105.03,105.4 105.03,102.6 104.9,102.47
GND on BOTTOM: 247.19,16.42 245.82,17.79 245.82,21.22 245.92,21.32 247.93,21.32 248.16,21.09 248.16,17.56 248.13,17.54 248.13,17.49 248.41,17.21 248.41,16.6 248.23,16.42 ; 6 cut-outs
GND on BOTTOM: 74.17,70.85 74.04,70.98 74.04,77.84 74.17,77.96 74.42,77.96 74.55,77.84 76.02,77.84 76.23,77.63 76.23,77.18 75.56,76.52 75.56,70.98 75.44,70.85 ; 7 cut-outs
GND on BOTTOM: 185.29,61.58 185.04,61.83 185.04,64.25 185.29,64.5 192.53,64.5 192.79,64.25 192.79,61.83 192.53,61.58 ; 11 cut-outs
GND on BOTTOM: 247.8,33.54 247.75,33.59 247.75,34.5 247.9,34.66 252.25,34.66 252.37,34.53 252.37,33.89 252.2,33.72 248.46,33.72 248.28,33.54 ; 4 cut-outs
GND on L2VCC: 205.69,11.48 205.17,12 205.17,13.44 205.17,13.52 205.17,13.53 205.11,13.58 203.39,15.42 212.9,15.42 216.84,11.48
GND on L2VCC: outline of 230 points within 2.36,0.76 292.04,128.74 ; 3 cut-outs
GND on L3: 12.38,24.37 12.38,36.44 12.82,37.85 11.62,38.71 7.5,38.71 6.72,38.45 6.28,37.76 6.25,37.66 4.18,37.66 4.18,37.85 3.81,38.74 2.92,39.11 2.47,39.11 2.47,41.09 2.92,41.09 3.81,41.46 4.18,42.35 4.18,42.54 6.25,42.54 6.28,42.44 6.72,41.75 7.5,41.49 11.62,41.49 12.82,42.35 12.38,43.76 12.38,56.44 12.82,57.85 11.62,58.71 7.5,58.71 6.72,58.45 6.28,57.76 6.25,57.66 4.24,57.66 3.16,58.74 2.84,58.97 2.47,59.1 2.36,59.11 2.36,60.54 7.44,60.54 8.85,60.1 9.71,61.3 9.71,77 8.85,78.2 7.44,77.76 6.73,77.76 6.73,78.3 6.73,78.3 6.73,79 6.91,79.18 12.75,79.18 13.59,78.34 13.59,59.47 16.76,56.3 16.76,51.67 16.15,51.06 16.15,47.13 15.85,46.82 15.85,41.51 14.76,40.42 14.76,20.61 13.94,19.8 4.83,19.8 4.47,20.15 4.47,21.24 4.72,21.5 6.83,21.5 7.01,21.32 12.32,21.32 13.08,22.08 13.08,23.67 ; 6 cut-outs
GND on L3: 92.43,93.48 91.03,93.48 89.79,92.24 89.79,89.01 90.55,88.25 92.58,88.25 93.34,89.01 93.34,92.57
GND on L3: 231.72,42.76 229.44,45.04 219.02,45.04 217.37,46.7 217.37,48.47 216.87,48.98 216.87,49.97 217.68,50.79 221.21,50.79 221.18,50.63 221.18,49.36 221.31,48.73 221.69,47.84 222.58,46.7 223.6,46.06 224.87,45.68 225.63,45.68 226.52,45.81 227.53,46.19 228.55,46.95 229.06,46.95 230.07,45.93 231.85,44.79 232.11,44.54 232.11,42.89 231.98,42.76
GND on L3: 88.01,71.74 81.15,71.74 74.68,65.26 74.68,59.42 74.04,58.79 74.04,49.77 52.2,27.93 52.2,26.4 44.58,18.78 44.58,13.45 45.21,12.81 51.56,12.81 52.45,11.92 54.23,11.92 54.86,12.56 73.03,12.56 73.28,12.3 84.84,12.3 85.47,12.94 108.33,12.94 110.36,14.97 117.6,14.97 119.63,12.94 143.26,12.94 144.65,14.34 144.65,14.95 145.1,15.39 145.1,18.36 144.65,18.81 144.65,26.91 129.67,41.9 129.67,48.25 128.91,49.01 128.91,52.06 120.4,60.56 120.4,65.16 119.25,66.3 118.24,66.3 116.99,67.55 112.85,67.55 112.14,68.26 111.12,68.26 110.64,67.78 109.45,67.78 108.41,68.82 108.41,69.73 107.9,70.24 107.11,70.24 107.05,70.18 106.48,70.18 105.48,69.18 101.45,69.18 101.34,69.07 100.35,69.07 99.97,68.69 96.14,68.69 94.36,70.47 89.28,70.47
GND on L3: 238.63,4.68 237.62,4.68 235.97,3.03 223.52,3.03 223.27,2.78 207.9,2.78 204.85,5.83 199.52,5.83 199.14,5.45 199.14,5.07 200.03,4.18 200.03,2.4 200.91,1.51 237.24,1.51 238.63,2.91
GND on L3: outline of 96 points within 13.08,65.95 217.25,128.74
GND on L3: 291.85,55.99 287.4,55.99 287.15,55.61 285.62,53.2 283.97,51.04 282.07,48.75 278.64,45.58 275.97,43.55 271.65,41.01 269.37,39.99 266.32,38.85 262,37.7 256.92,37.07 253.11,37.07 250.32,37.32 245.24,38.21 243.08,38.97 240.03,40.12 239.65,40.12 239.4,40.37 239.01,40.37 238.76,40.12 238.76,39.48 239.01,39.1 240.41,38.09 245.24,37.2 246.76,36.56 247.27,36.05 265.94,36.05 267.08,37.2 274.07,37.2 276.1,35.16 280.16,35.16 284.61,30.72 284.61,27.67 280.16,23.23 280.16,22.08 279.91,21.83 279.02,21.83 277.62,23.23 273.69,23.23 271.65,25.26 267.72,25.26 267.08,25.89 266.45,25.89 266.19,25.64 266.19,18.27 265.94,18.02 264.67,18.02 264.03,18.65 258.32,18.65 258.29,18.63 253.92,18.63 249.05,13.75 249.05,11.54 249.56,11.03 252.48,11.03 253.37,11.92 253.37,15.86 255.02,17.51 273.94,17.51 275.21,16.24 288.67,16.24 291.97,19.54 291.97,55.87
GND on L4: outline of 258 points within 2.36,0.76 292.04,128.74
GND on L4: 12.87,22.93 12.71,23.39 12.38,23.76 12.38,36.44 12.82,37.85 11.62,38.71 7.5,38.71 6.72,38.45 6.28,37.76 6.25,37.66 4.18,37.66 4.18,37.85 3.81,38.74 2.92,39.11 2.36,39.11 2.36,41.09 2.92,41.09 3.81,41.46 4.18,42.35 4.18,42.54 6.25,42.54 6.28,42.44 6.72,41.75 7.5,41.49 11.62,41.49 12.82,42.35 12.38,43.76 12.38,56.44 12.82,57.85 11.62,58.71 7.5,58.71 6.72,58.45 6.28,57.76 6.25,57.66 4.24,57.66 3.16,58.74 2.84,58.97 2.47,59.1 2.36,59.11 2.36,60.54 7.44,60.54 8.85,60.1 9.71,61.3 9.71,63.61 9.97,63.87 13.08,63.87 13.59,63.36 13.59,59.42 16.76,56.25 16.76,47.74 15.88,46.85 15.88,41.51 14.73,40.37 14.73,20.56 13.97,19.8 4.83,19.8 4.45,20.18 4.45,21.96 4.95,22.46 5.84,22.46 6.99,21.32 12.32,21.32 13.08,22.08 13.08,22.72
GND on L5GND: outline of 224 points within 2.36,0.76 292.04,128.74
GND on L6: 75.69,125.33 94.11,125.33 94.49,125.72 96.14,125.72 96.77,125.08 96.77,115.56 89.79,108.57 88.52,108.57 86.74,110.35 77.85,110.35 75.69,108.19 74.3,108.19 74.04,108.44 74.04,123.68
GND on L6: outline of 171 points within 32.51,0.76 292.04,120.64
GND on L6: 209.65,128.2 196.67,128.2 195.88,127.42 192.3,127.42 192.3,127.44 191.54,128.2 68.07,128.2 65.53,125.66 65.53,121.47 64.31,120.25 52.51,120.25 52.47,120.29 52.17,120.23 51.86,120.2 50.96,120.2 50.61,120.23 50.27,120.31 47.15,120.31 46.43,119.59 46.43,110.88 48.21,109.1 48.21,104.96 44.11,100.87 43.32,99.53 41.86,99 10.86,99 10.46,98.61 2.36,98.61 2.36,99.54 41.86,99.54 43.11,100.05 43.62,101.3 43.62,106.17 43.64,106.24 43.67,106.31 43.7,106.34 44.77,107.78 45.03,108.28 45.12,108.83 45.12,114.17 45.03,114.72 44.77,115.22 43.67,116.69 43.64,116.76 43.62,116.83 43.62,121.08 43.62,122.5 44.57,124.79 46.86,125.74 51.86,125.74 53.11,126.25 53.62,127.5 53.62,128.5 53.69,128.67 53.86,128.74 57.24,128.74 57.33,128.72 57.4,128.67 57.82,128.25 57.86,128.21 57.91,128.17 58.45,127.85 59.06,127.74 62.04,127.74 62.71,127.87 63.28,128.25 63.7,128.67 63.77,128.72 63.86,128.74 209.65,128.74
GND on L6: outline of 94 points within 2.36,17.89 18.67,80.86
GND on L7GND: outline of 239 points within 2.36,0.76 292.04,128.74
VCC_CORE on TOP: 108.41,71.41 108.2,71.61 108.2,73.01 107.65,73.57 107.65,81.27 107.06,81.85 107.06,82.28 106.86,82.48 106.5,82.48 106.3,82.69 106.3,83.53 105.84,83.98 105.84,84.67 105.66,84.85 105.66,85.53 105.77,85.63 106.07,85.63 106.3,85.86 106.3,86.57 106.17,86.7 105.87,86.7 105.74,86.83 105.74,90.33 113.77,98.36 114.88,98.36 118.87,102.35 118.87,110.6 119.89,111.62 120.98,111.62 122.5,110.09 124.87,110.09 125.76,110.98 125.76,111.01 126.59,111.85 129.05,111.85 129.29,111.61 129.29,104 118.12,92.83 118.11,92.83 117.58,92.3 116.47,92.3 114.73,90.56 114.73,89.01 114.58,88.86 114.58,85.88 112.84,84.14 112.84,82.92 112.5,82.58 112.23,82.58 112.01,82.37 112.01,80.57 111.9,80.46 111.9,73 112.14,72.76 113.12,72.76 113.52,72.36 113.52,71.61 113.51,71.61 113.31,71.41 ; 55 cut-outs
VCC_CORE on BOTTOM: 109.35,85.84 109.09,86.09 109.09,86.73 109.18,86.73 109.58,87.12 109.58,87.35 109.81,87.58 109.81,89.09 109.98,89.27 111.89,89.27 112.12,89.04 112.12,87.88 111.89,87.65 111.89,86.35 111.38,85.84
VCC_CORE on BOTTOM: 109.88,70.29 109.88,70.34 108.58,71.64 108.58,72.78 109.47,73.67 111.73,73.67 113.97,71.44 113.97,70.44 113.82,70.29
VCC_CORE on BOTTOM: 107.19,80.38 107.13,80.43 107.13,81.96 107.21,82.03 107.99,82.03 108.08,82.12 108.08,82.77 108.54,83.23 108.88,83.23 109.35,82.76 109.35,81.8 109.24,81.69 109.24,81.37 109.45,81.16 109.76,81.16 110,81.4 110,81.68 109.9,81.78 109.9,82.75 110.37,83.22 110.76,83.22 111.18,82.79 111.18,81.82 111.09,81.72 111.09,81.38 111.29,81.18 111.61,81.18 111.83,81.4 111.83,81.67 111.73,81.77 111.73,82.71 112.23,83.21 112.53,83.21 112.97,82.77 113.47,82.77 113.71,83.01 113.82,83.01 114.08,83.27 114.36,83.27 114.85,82.78 114.85,82.5 114.33,81.97 114.33,80.46 114.25,80.38
VCC_CORE on BOTTOM: 118.19,102.42 118.08,102.52 118.08,103.44 117.84,103.68 117.64,103.68 117.22,104.1 117.22,107.07 117.4,107.25 120.09,107.25 120.27,107.43 120.27,108.95 121.03,109.71 125.73,109.71 127.38,111.36 128.91,111.36 129.29,110.98 129.29,103.62 128.52,102.86 120.98,102.86 120.55,102.42 ; 14 cut-outs
VCC_CORE on L2VCC: 108.39,71.55 108.39,73.34 105.85,75.88 105.85,81.6 104.71,82.74 104.71,89.31 117.67,102.27 117.67,106.21 117.93,106.47 127.68,106.47 129.73,104.43 129.73,102.81 116.01,89.09 116.01,85.54 114.49,84.01 114.49,80.68 115.11,80.06 117.54,80.06 117.54,77.01 116.63,77.01 116.01,76.39 116.01,73.45 114.22,73.45 113.47,72.71 113.47,71.55
VCC_CORE on L3: 113.54,71.49 108.84,71.49 108.71,71.61 108.71,73.31 108.23,73.8 107.93,73.8 105.87,75.86 105.87,81.61 105.45,82.03 105.42,82.03 105.42,82.03 104.71,82.74 104.71,89.28 117.09,101.67 117.09,101.69 117.68,102.27 117.68,105.85 118.24,106.41 127.51,106.41 130.05,103.87 130.05,101.06 119,90.01 117.84,90.01 114.68,86.85 114.68,82.28 113.92,81.52 113.92,71.87
VCC_CORE on L4: 108.46,71.49 108.33,71.61 108.33,73.14 106.68,74.79 106.68,79.21 106.65,79.23 106.65,81.54 105.41,82.79 105.41,86.85 106.43,87.87 108.33,87.87 109.73,89.27 112.14,89.27 113.54,87.87 114.81,87.87 114.94,87.74 114.94,85.71 114.25,85.03 114.25,79.16 113.82,78.73 113.79,78.73 113.39,78.32 113.39,76.62 113.79,76.21 113.79,71.74 113.54,71.49
VDD10 on TOP: 48.39,89.77 46.74,91.43 45.47,91.43 45.34,91.3 43.56,91.3 43.31,91.55 43.31,91.93 40.64,94.6 40.64,96.25 40.26,96.63 40.26,97.5 40.39,97.62 45.49,97.62 46.05,97.06 46.84,97.06 47.75,96.15 47.75,94.6 47.32,94.17 46.48,94.17 46.35,94.3 46.35,95.77 46.1,96.02 45.69,96.02 45.09,96.63 42.42,96.63 42.16,96.38 42.16,94.22 43.18,93.2 45.59,93.2 46.35,92.44 47.37,92.44 47.65,92.16 51.51,92.16 51.82,91.86 51.82,90.03 51.56,89.77 ; 12 cut-outs
VDDREG on BOTTOM: 48.77,89.77 48.13,90.41 48.13,92.44 47.62,92.95 47.24,92.95 46.99,93.2 46.99,93.66 46.94,93.71 45.92,93.71 45.77,93.86 45.77,94.19 45.85,94.27 46.94,94.27 47.24,93.97 48.77,93.97 49.91,92.82 49.91,90.03 49.66,89.77 ; 2 cut-outs
0D6V_PWR on TOP: 58.42,52.69 58.17,52.94 58.17,53.6 57.94,53.83 57.94,54.29 58.12,54.47 60.83,54.47 61.59,55.23 62.81,55.23 62.99,55.05 62.99,53.1 62.97,53.07 62.71,53.07 62.69,53.1 62.69,54.54 62.64,54.6 62.1,54.6 61.98,54.47 61.98,53.2 61.85,53.07 61.39,53.07 61.01,52.69
0D6V_S0 on TOP: 58.62,48.93 58.17,49.39 58.17,51.93 58.55,52.31 60.45,52.31 60.58,52.18 60.58,51.52 59.56,50.51 59.56,49.03 59.46,48.93 ; 2 cut-outs
0D6V_S0 on TOP: 114.68,11.29 113.16,12.81 113.16,15.86 113.54,16.24 114.94,16.24 115.44,15.73 115.44,11.42 115.32,11.29 ; 5 cut-outs
0D6V_S0 on TOP: 41.55,13.24 41.1,13.7 41.1,14.72 41.3,14.92 44.02,14.92 44.45,14.49 44.45,13.57 44.12,13.24 ; 2 cut-outs
0D6V_S0 on BOTTOM: 115.32,10.4 114.55,11.16 114.55,11.8 114.05,12.3 112.39,12.3 112.01,12.69 110.87,12.69 110.62,12.94 110.62,13.45 111.51,14.34 112.78,14.34 113.41,14.97 113.41,15.73 113.92,16.24 115.7,16.24 116.2,15.73 116.2,10.65 115.95,10.4
0D95V_VGA_S0 on TOP: 170.02,79.16 170.01,79.17 170.01,79.71 170.05,79.74 171.25,79.74 171.38,79.87 171.38,81.17 171.31,81.23 169.46,81.23 169.2,81.49 169.2,83.87 169.84,84.51 172.34,84.51 173.21,83.63 173.21,81.81 172.75,81.34 172.75,80.88 172.65,80.78 172.19,80.78 172.05,80.64 172.05,79.45 171.76,79.16 ; 11 cut-outs
0D95V_VGA_S0 on BOTTOM: 169.65,64.76 169.55,64.86 169.55,65.49 169.54,65.49 169.54,68.16 170.33,68.95 170.81,68.95 171.58,69.71 177.55,69.71 178.31,68.95 178.31,68.57 178.05,68.31 174.75,68.31 174.37,68.69 173.48,68.69 171.7,66.91 171.7,64.88 171.58,64.76
0D95V_VGA_S0 on BOTTOM: 170.62,79.1 170.43,79.29 170.43,83.89 170.23,84.09 169.2,84.09 169,84.29 169,85.14 169.52,85.65 170.33,85.65 170.78,85.2 172.12,85.2 172.42,84.9 172.96,84.9 173.26,84.6 173.26,83.09 173.78,82.58 173.78,82.05 173.2,81.47 173.2,80.99 173.73,80.46 173.73,80.12 172.71,79.1
0D95V_VGA_S0 on L4: 173.61,68.69 176.02,71.11 176.02,80.5 172.09,84.44 169.04,84.44 165.35,80.76 165.35,74.28 166.88,72.76 166.88,71.99 168.15,70.72 170.05,70.72 172.09,68.69
1D0V_PWR on TOP: 33.66,18.65 33.53,18.78 33.53,19.54 34.16,20.18 34.7,20.18 34.98,20.46 34.98,24.12 35.1,24.24 38.99,24.24 39,24.23 39.61,24.23 39.83,24.01 39.83,20.51 40.03,20.31 41.15,20.31 41.27,20.18 41.27,19.42 40.51,18.65
1D0V_PWR on BOTTOM: 32.77,20.74 32.64,20.86 32.64,23.86 32.89,24.12 33.22,24.12 33.48,24.37 33.48,25.26 33.68,25.46 38.94,25.46 39.09,25.31 39.09,20.99 38.84,20.74
1D0V_S5 on TOP: 33.78,16.37 33.53,16.62 33.53,18.15 33.78,18.4 40.64,18.4 40.89,18.15 40.89,17.21 40.06,16.37
1D0V_S5 on TOP: 145.16,86.73 145.03,86.85 145.03,87.74 145.16,87.87 145.92,87.87 146.18,88.12 146.18,89.65 146.43,89.9 148.34,89.9 149.1,89.14 149.1,87.11 148.72,86.73
1D0V_S5 on BOTTOM: 146.05,85.84 145.92,85.96 145.92,91.04 146.18,91.3 146.56,91.3 148.46,89.39 149.86,89.39 149.99,89.27 149.99,88.76 149.9,88.67 149.14,88.67 148.84,88.38 148.84,87.62 148.72,87.49 147.7,87.49 147.57,87.36 147.57,85.96 147.45,85.84 ; 1 cut-out
1D0V_S5 on BOTTOM: 151.51,77.71 150.75,78.47 150.11,78.47 149.99,78.6 149.99,79.87 150.11,80 157.48,80 158.09,79.39 158.09,77.91 157.89,77.71 ; 1 cut-out
1D0V_S5 on BOTTOM: 163.7,57.77 163.45,58.02 163.45,61.33 163.32,61.45 162.18,61.45 161.93,61.71 161.93,62.98 162.05,63.1 165.18,63.1 165.46,62.82 165.46,61.71 165.23,61.48 165.23,58.02 164.97,57.77 ; 2 cut-outs
1D0V_S5 on L2VCC: 34.24,17.07 33.85,17.46 33.85,24.29 34.5,24.94 39.42,24.94 40.05,24.31 41.32,24.31 41.7,23.92 42.5,23.92 42.86,24.29 42.86,24.54 43.26,24.94 48.47,24.94 57.36,33.83 165.43,33.83 175.08,43.48 181.93,43.48 181.93,26.4 183.94,24.29 187.45,20.75 171.15,20.75 168.99,22.91 55.29,22.91 51.1,18.72 45.01,18.72 43.36,17.07
1D0V_S5 on L3: 160.39,74.43 162.69,72.13 163.19,72.13 163.19,72.12 163.83,72.12 164.34,71.61 164.34,70.98 166.12,69.2 166.12,62.67 165.53,62.09 165.53,61.17 164.54,60.18 164.54,56.62 165.94,55.22 170.18,55.22 171.43,53.97 171.43,53.96 179.58,53.96 181.86,51.67 181.86,43.93 180.59,42.66 174.62,42.66 172.59,44.69 171.07,44.69 169.54,46.21 168.53,46.21 160.74,54 160.74,56.4 159.12,58.02 159.12,59.86 159.27,60.01 160.2,60.01 160.22,59.99 160.97,59.99 161.16,60.18 161.16,61.2 159.84,62.52 159.84,63.42 160.68,64.26 160.68,65.36 159.89,66.15 159.89,70.22 157.35,70.22 156.34,71.23 156.34,74.79 153.25,77.87 153.25,80.85 152.02,82.08 152.02,84.41 150.85,85.58 148.59,85.58 145.41,88.76 145.41,90.03 145.54,90.16 149.99,90.16 152.02,88.12 153.72,88.12 153.95,87.89 153.95,87.56 153.92,87.54 153.92,86.98 155.38,85.52 156.53,85.52 159.96,82.09 159.96,81.71 161.16,80.5 161.16,77.98 161.16,77.97 161.16,77.49 160.39,76.72
1D2V_S3 on TOP: 68.96,45.32 67.79,46.5 67.79,49.23 66.36,50.66 66.36,51.1 66.29,51.17 66.29,53.07 67.06,53.83 72.52,53.83 72.77,53.58 72.77,49.64 73.28,49.13 84.33,49.13 84.57,49.38 84.57,53.01 85.52,53.96 85.52,59.32 88.95,62.75 93.6,62.75 93.6,63.49 94.36,64.25 94.36,65.64 94.61,65.9 95.63,65.9 95.76,65.77 95.76,64.63 95.89,64.5 97.03,64.5 97.16,64.63 97.16,65.14 97.54,65.52 105.16,65.52 105.92,66.28 105.92,67.04 106.17,67.3 108.33,67.3 108.58,67.04 110.62,67.04 111.38,67.8 111.63,67.8 112.01,68.18 118.49,68.18 118.87,67.8 118.87,65.01 120.02,63.87 120.02,61.58 119.25,60.82 119.25,54.34 110.24,45.32 ; 25 cut-outs
1D2V_S3 on TOP: 144.78,11.29 144.27,11.8 135.76,11.8 135.38,11.42 119.63,11.42 119.13,11.92 119.13,20.81 116.97,22.97 111.38,22.97 110.36,21.96 110.36,12.3 109.47,11.42 91.06,11.42 89.03,13.45 87.12,13.45 87,13.57 87,13.85 87.1,13.96 87.86,13.96 88.06,14.16 88.06,14.72 87.93,14.84 86.11,14.84 85.85,14.59 85.85,12.69 85.47,12.3 84.58,12.3 83.69,11.42 75.69,11.42 75.44,11.67 49.15,11.67 47.75,13.07 47.75,17.64 55.12,25 58.17,25 61.09,27.93 120.65,27.93 128.91,36.18 144.02,36.18 152.27,27.93 163.58,27.93 169.54,21.96 171.83,21.96 172.21,21.58 174.12,21.58 174.37,21.32 174.37,19.42 176.4,17.38 178.31,17.38 179.71,15.99 179.71,13.96 178.18,12.43 175.39,12.43 174.62,13.19 170.69,13.19 169.67,12.18 169.67,11.67 169.54,11.54 169.04,11.54 168.78,11.29 149.17,11.29 148.49,11.97 146.18,11.97 145.49,11.29 ; 96 cut-outs
1D2V_S3 on L3: 119.75,71.17 118.09,71.17 117.18,70.25 117.18,67.68 118.44,66.41 118.44,66.41 120.24,66.41 120.37,66.54 120.37,70.56
1D2V_S3 on L4: 70.23,53.2 66.67,53.2 66.55,53.07 66.55,51.04 70.61,46.98 71.12,46.98 72.14,47.99 72.14,51.29
1D2V_S3 on L6: 66.55,53.58 66.29,53.33 66.29,53.07 67.63,51.74 67.63,47.23 65.66,45.26 65.66,38.97 55.88,29.2 55.88,23.35 56.13,23.1 58.55,23.1 72.77,37.32 72.77,47.99 71.88,48.88 71.88,53.33 71.63,53.58
1D5V_VGA_S0 on TOP: 170.56,84.57 170.31,84.82 170.31,98.41 168.02,100.7 168.02,104.63 169.04,105.65 169.04,116.19 167.51,117.71 162.43,117.71 160.78,116.06 160.78,106.67 160.02,106.67 159.38,106.03 159.38,105.52 159.64,105.27 160.27,105.27 160.78,104.76 160.78,103.11 160.27,102.6 160.27,100.82 159.64,100.19 158.62,100.19 158.24,100.57 157.35,100.57 157.1,100.82 157.1,111.87 156.97,112 156.97,124.32 161.39,128.74 189.89,128.74 191.01,127.62 191.01,119.37 191.77,118.6 192.66,118.6 195.45,115.81 195.45,110.86 195.07,110.48 195.07,108.19 195.2,108.06 195.2,101.33 194.44,100.57 191.01,100.57 190.37,101.2 190.37,102.86 191.52,104 191.52,115.81 189.99,117.33 185.55,117.33 183.13,114.92 183.13,100.06 181.23,98.16 181.23,94.35 183.13,92.44 183.13,85.84 182.25,84.95 174.12,84.95 173.86,85.2 173.1,85.2 172.97,85.08 172.97,84.69 172.85,84.57 ; 65 cut-outs
1D5V_VGA_S0 on BOTTOM: 172.46,84.98 172.12,85.32 170.85,85.32 170.55,85.62 170.55,86.83 171.17,87.46 171.52,87.46 171.98,87 171.98,86.24 172.18,86.04 174.58,86.04 174.71,85.91 174.71,85.08 174.61,84.98
1D5V_VGA_S0 on BOTTOM: 157.61,100.06 157.1,100.57 157.1,108.44 157.86,109.21 157.86,111.24 157.61,111.49 157.23,111.49 156.97,111.75 156.97,115.68 157.99,116.7 157.99,125.33 160.73,128.08 191.36,128.08 191.54,127.9 191.54,120.51 191.55,120.5 191.55,120.14 192.09,119.61 192.89,119.61 192.99,119.5 192.99,118.45 193.17,118.27 193.6,118.27 193.68,118.2 193.68,117.79 194.03,117.43 195.38,117.43 195.45,117.36 195.45,104.13 195.33,104 192.15,104 191.52,104.63 191.52,105.65 191.64,105.78 192.66,105.78 192.79,105.9 192.79,106.41 192.53,106.67 191.52,106.67 191.52,115.81 189.99,117.33 185.67,117.33 183.13,114.79 183.13,102.98 183.01,102.86 178.56,102.86 177.55,103.87 177.55,107.94 176.66,108.82 172.21,108.82 170.81,107.43 170.81,104.63 170.69,104.51 168.72,104.51 168.54,104.69 168.54,105.12 169.04,105.62 169.04,107.55 169.16,107.68 169.16,116.06 168.53,116.7 168.53,117.59 168.4,117.71 162.43,117.71 160.78,116.06 160.78,101.33 159.51,100.06 ; 68 cut-outs
1D8V_PWR on TOP: 162.05,48.75 161.93,48.88 161.93,53.33 162.05,53.45 164.21,53.45 164.34,53.58 166.88,53.58 167.13,53.33 167.13,51.29 167,51.17 163.19,51.17 162.81,50.79 162.81,48.88 162.69,48.75 ; 4 cut-outs
1D8V_S5 on TOP: 162.69,53.58 162.43,53.83 162.43,54.6 163.47,55.64 163.47,55.66 163.78,55.97 167.06,55.97 167.23,55.79 167.23,54.32 166.83,53.91 164.21,53.91 163.93,53.63 163.63,53.63 163.58,53.58
1D8V_S5 on L4: 164.59,56.37 165.1,55.87 165.1,54.47 163.96,53.33 159.89,53.33 158.24,54.98 158.24,56.25 158.37,56.37
1D8V_VGA_S0 on TOP: 175.01,68.95 174.88,69.07 174.88,70.6 174.75,70.72 174.75,74.03 174.37,74.41 174.04,74.41 173.92,74.53 173.92,77.16 174,77.24 175.35,77.24 175.65,76.94 175.65,76.2 176.14,75.72 176.14,74.41 176.78,73.76 176.78,71.23 176.15,70.6 176.15,69.2 175.9,68.95 ; 8 cut-outs
1D8V_VGA_S0 on BOTTOM: 173.48,76.15 173.35,76.29 173.35,77.45 173.45,77.55 174.64,77.55 174.76,77.43 174.76,76.29 174.63,76.15
2D5V_S3 on TOP: 110.87,18.65 110.72,18.81 110.72,21.93 111.3,22.51 113.08,22.51 113.41,22.18 113.41,19.09 112.98,18.65 ; 8 cut-outs
2D5V_S3 on TOP: 176.53,18.53 176.02,19.04 176.02,19.42 176.28,19.67 179.58,19.67 179.71,19.8 179.71,22.21 179.83,22.34 187.58,22.34 189.1,20.81 189.1,19.16 188.47,18.53 ; 6 cut-outs
2D5V_S3 on BOTTOM: 65.2,4.68 65.15,4.73 65.15,7.73 65.66,8.24 66.42,8.24 66.67,7.99 66.67,7.35 66.6,7.27 66.6,4.81 66.47,4.68 ; 2 cut-outs
2D5V_S3 on BOTTOM: 110.74,18.65 110.62,18.78 110.62,22.85 111.89,24.12 180.75,24.12 181.36,24.72 188.59,24.72 189.1,24.22 189.1,19.16 188.59,18.65 187.71,18.65 187.58,18.78 187.58,20.66 187.35,20.89 185.95,20.89 184.38,22.46 114.05,22.46 112.52,20.94 112.52,19.04 112.14,18.65
2D5V_S3 on L3: 64.82,6.36 81.23,6.36 82.07,5.52 100.36,5.52 102.79,7.96 114.38,7.96 114.83,8.42 114.83,10.7 113.89,11.64 110.95,11.64 110.27,10.97 98.97,10.97 97.82,9.81 79.17,9.81 77.8,8.44 75.79,8.44 74.9,9.33 64.77,9.33 64.21,8.77 64.21,6.97
2D5V_S3 on L4: 111.68,22.57 117.32,22.57 118.08,21.8 118.08,12.76 115.98,10.65 112.34,10.65 112.17,10.83 112.17,12.69 112.39,12.91 114.53,12.91 114.86,13.24 114.86,16.65 111.68,19.82
3D3V_LAN_S5 on TOP: 39.75,92.06 39.24,92.57 39.24,95.36 38.35,96.25 38.35,98.16 39.12,98.92 51.94,98.92 52.45,98.41 52.45,96.51 51.31,95.36 51.31,92.57 51.05,92.31 49.4,92.31 48.39,93.33 48.39,96.38 46.93,97.84 44.77,97.84 44.7,97.78 40.39,97.78 40.13,97.52 40.13,96.51 40.51,96.12 40.51,94.47 42.16,92.82 42.16,92.44 41.78,92.06 ; 7 cut-outs
3D3V_LAN_S5 on BOTTOM: 41.53,92.06 41.4,92.19 41.4,93.25 41.48,93.33 42.88,93.33 42.9,93.3 42.9,92.47 42.49,92.06
3D3V_LAN_S5 on L4: 44.58,99.05 43.69,99.05 40.77,96.12 40.77,93.2 42.29,91.68 49.15,91.68 50.04,92.57 50.04,94.35 48.39,96 47.37,96 45.34,98.03 45.34,98.28
3D3V_MSATA_S0 on BOTTOM: 248.69,16.6 248.59,16.7 248.59,17.66 248.44,17.82 248.44,21.14 248.56,21.27 251.99,21.27 252.25,21.02 252.25,20 252.3,19.95 255.12,19.95 255.37,20.2 257.76,20.2 257.81,20.15 257.81,18.63 257.4,18.22 251.49,18.22 249.86,16.6 ; 5 cut-outs
3D3V_RUN_FFS on BOTTOM: 105.16,4.3 105.03,4.43 105.03,5.83 104.9,5.95 104.52,5.95 104.39,6.08 104.39,6.84 104.52,6.97 105.41,6.97 105.92,6.46 105.92,4.56 105.66,4.3 ; 2 cut-outs
3D3V_S0 on TOP: 131.47,79.31 131.34,79.44 131.34,80.27 131.98,80.91 132.64,80.91 132.79,80.76 132.79,79.44 132.66,79.31
3D3V_S0 on TOP: 146.1,62.88 146.05,62.93 146.05,65.31 146.48,65.75 146.48,66.03 146.51,66.05 146.51,67.47 146.63,67.6 148.31,67.6 148.62,67.3 148.62,66.18 147.96,65.52 147.96,63.74 147.09,62.88
3D3V_S0 on TOP: 134.5,49.33 134.26,49.58 134.26,50.73 134.38,50.86 135.09,50.86 135.49,50.46 138,50.46 138.4,50.07 138.4,49.5 138.23,49.33
3D3V_S0 on TOP: 39.24,78.47 39.24,79.36 38.48,80.12 35.69,80.12 33.53,82.28 33.53,83.81 33.78,84.06 37.97,84.06 38.04,84 39.24,85.2 45.85,85.2 48.39,87.74 53.95,87.74 54.15,87.54 54.15,83.22 51.69,80.76 47.75,80.76 46.61,81.9 42.04,81.9 40.51,80.38 40.51,78.73 40.26,78.47 ; 5 cut-outs
3D3V_S0 on TOP: 45.49,49.08 43.74,50.84 43.74,55.97 44.04,56.27 46.58,56.27 47.24,55.61 47.24,53.53 46.41,52.69 46.41,51.85 46.71,51.55 49.02,51.55 49.28,51.8 49.94,51.8 50.75,52.61 51.18,52.61 51.44,52.87 51.44,54.29 51.61,54.47 52.98,54.47 53.24,54.21 53.24,53.66 53.39,53.5 53.95,53.5 54.05,53.4 54.05,52.69 53.26,51.9 53.26,50.94 52.63,50.3 51.28,50.3 50.06,49.08 ; 4 cut-outs
3D3V_S0 on BOTTOM: 45.85,83.3 45.59,83.55 45.59,86.35 45.82,86.57 46.86,86.57 47.75,87.46 47.75,87.49 48.13,87.87 49.15,87.87 49.4,88.12 49.4,88.5 49.53,88.63 51.69,88.63 52.2,88.12 54.25,88.12 54.84,88.71 55.52,88.71 55.75,88.94 56.24,88.94 56.25,88.92 56.27,88.92 56.49,88.71 57.3,88.71 57.56,88.96 58.04,88.96 58.29,88.71 58.85,88.71 59.56,88 59.56,85.71 59.44,85.58 58.67,85.58 58.17,85.08 57.02,85.08 56.52,85.58 54.74,85.58 54.36,85.2 52.15,85.2 52.13,85.19 50.71,85.19 50.37,84.85 46.91,84.85 46.61,84.54 46.61,83.42 46.48,83.3 ; 1 cut-out
3D3V_S0 on BOTTOM: 75.18,87.49 74.8,87.87 74.8,88.5 74.93,88.63 77.72,88.63 77.85,88.5 77.85,88.12 77.72,88 77.34,88 76.83,87.49
3D3V_S0 on BOTTOM: 265.94,27.04 265.68,27.29 265.68,28.18 265.81,28.31 267.33,28.31 267.59,28.56 267.59,32.12 267.39,32.32 266.17,32.32 266.01,32.17 265.35,32.17 265.2,32.32 265.2,33.16 265.25,33.21 268.1,33.21 268.73,32.57 268.73,30.07 269.61,29.2 269.61,28.42 268.22,27.04 ; 6 cut-outs
3D3V_S0 on BOTTOM: 139.57,80.25 139.32,80.5 139.32,83.17 139.19,83.3 137.16,83.3 137.03,83.42 137.03,85.58 137.16,85.71 137.67,85.71 138.56,84.82 141.73,84.82 141.86,84.69 141.86,81.52 141.6,81.27 141.6,80.5 141.48,80.38 140.34,80.38 140.21,80.25 ; 8 cut-outs
3D3V_S0 on BOTTOM: 246.02,21.75 245.9,21.88 245.9,23.71 246.1,23.91 250.49,23.91 250.6,23.81 250.6,23.4 250.88,23.12 251.84,23.12 252.02,22.95 252.02,22.01 251.76,21.75 ; 6 cut-outs
3D3V_S0 on L2VCC: 217.88,6.27 218.12,6.51 218.12,10.73 217.65,11.21 213.06,15.8 202.95,15.8 202.87,15.8 202.87,15.8 199.34,15.8 191.96,23.18 191.96,57.6 189.69,59.87 185.12,59.87 183.72,61.26 171.24,61.26 168.56,58.58 154.99,45.01 72.55,45 66.88,50.67 65.88,50.67 65.47,50.25 65.47,45.4 53.29,57.58 51.36,57.58 48.56,54.79 43.62,54.79 43.62,56.68 46.81,59.87 58.21,59.87 62.28,55.8 72.57,55.8 76.38,51.99 156.29,51.99 162.88,58.58 162.88,64.3 163.91,65.33 195.66,65.33 195.96,65.63 196.79,64.8 196.79,47.66 198.06,46.39 198.06,23.78 201.72,20.11 214.81,20.11 223.31,11.61 233.89,11.61 242.63,20.35 242.63,23.4 244.43,25.19 250.24,25.19 251.52,23.91 251.52,21.78 250.1,20.35 243.13,13.38 239.57,13.38 236.92,10.73 232.7,6.51 232.46,6.27
3D3V_S0 on L3: 53.04,51.83 51.74,51.83 49.53,54.04 44.93,54.04 42.98,55.99 42.98,63.13 38.66,67.45 38.66,72.25 37.52,73.39 37.52,79.44 34.37,82.59 34.37,83.75 35.05,84.44 37.39,84.44 40.54,81.29 40.54,74.74 42.06,73.21 42.06,69.4 46.33,65.14 46.33,60.77 47.65,59.45 47.65,57.47 48.87,56.25 50.34,56.25 52.02,54.57 53.19,54.57 53.39,54.37 53.39,52.18
3D3V_S0 on L6: 262.46,27.9 253.11,27.9 249.71,24.5 249.71,22.97 248.95,22.21 247.42,22.21 246.15,23.48 246.15,25.49 244.65,26.99 240.36,26.99 237.01,30.34 235.1,30.34 234.14,31.3 234.14,32.34 234.52,32.73 242.09,32.73 242.47,32.34 242.47,30.44 242.29,30.26 242.29,29.42 243,28.71 245.59,28.71 249.35,32.47 262,32.47 262.46,32.01
3D3V_S5 on TOP: 24.51,45.96 22.23,48.25 22.23,50.79 22.61,51.17 28.7,51.17 29.08,50.79 32.26,50.79 32.51,50.53 32.51,46.34 32.13,45.96 ; 1 cut-out
3D3V_S5 on TOP: 153.92,45.07 153.8,45.2 153.8,46.72 154.18,47.1 156.08,47.1 156.34,47.36 156.34,48.25 156.21,48.37 154.56,48.37 154.43,48.5 154.43,49.26 154.56,49.39 156.84,49.39 157.48,48.75 157.48,46.09 156.46,45.07
3D3V_S5 on TOP: 174.65,54.44 174.22,54.87 174.22,55.84 175.01,56.63 176.66,56.63 179.45,59.42 181.23,59.42 181.61,59.04 181.61,58.28 177.77,54.44
3D3V_S5 on TOP: 208.74,42.48 208.31,42.92 208.31,45.76 208.5,45.95 209.31,45.95 209.68,45.58 209.68,42.76 209.41,42.48 ; 4 cut-outs
3D3V_S5 on TOP: 200.53,4.33 199.85,5.01 199.85,5.34 198.81,6.39 198.81,7.61 198.96,7.76 199.44,7.76 199.82,7.38 199.82,6.59 200.05,6.36 202.49,6.36 202.62,6.23 202.62,5.52 202.55,5.46 202.55,5.05 201.83,4.33
3D3V_S5 on TOP: 51.74,54.6 51.4,54.94 51.4,57.04 50.55,57.9 50.04,57.9 49.91,58.02 49.91,62.85 50.04,62.98 52.32,62.98 52.83,62.47 52.83,58.02 54.03,56.83 54.03,54.85 53.98,54.8 53.11,54.8 52.92,54.61 52.59,54.61 52.58,54.6 ; 1 cut-out
3D3V_S5 on TOP: 90.58,98.82 89.53,99.86 89.53,101.84 89.66,101.97 93.73,101.97 93.85,101.84 93.85,100.57 92.1,98.82
3D3V_S5 on BOTTOM: 50.29,2.02 50.16,2.14 50.16,5.07 50.29,5.19 52.7,5.19 53.59,6.08 56.39,6.08 56.52,5.95 56.52,4.56 56.39,4.43 54.61,4.43 53.98,3.8 53.34,3.8 53.21,3.67 53.21,3.03 53.72,2.53 53.72,2.14 53.59,2.02 ; 5 cut-outs
3D3V_S5 on BOTTOM: 215.67,45.71 215.65,45.73 215.65,47.89 216.08,48.32 217.45,48.32 217.75,48.02 217.75,46.39 217.58,46.21 216.59,46.21 216.08,45.71 ; 1 cut-out
3D3V_S5 on BOTTOM: 175.31,54.09 174.6,54.8 174.6,56.14 174.74,56.28 175.3,56.28 175.31,56.3 176.12,56.3 176.35,56.07 176.35,55.72 176.4,55.67 179.29,55.67 179.6,55.36 179.6,54.26 179.43,54.09
3D3V_S5 on BOTTOM: 123.14,54.49 122.96,54.67 122.96,55.43 122.99,55.46 125.48,55.46 125.63,55.31 125.63,54.57 125.55,54.49
3D3V_S5 on BOTTOM: 150.67,87.06 149.91,87.82 149.5,87.82 149.4,87.92 149.4,88.4 149.48,88.48 151.92,88.48 153.16,89.72 153.54,89.72 153.72,89.55 153.72,89.24 152.07,87.59 152.07,87.16 151.97,87.06
3D3V_S5 on L2VCC: 69.26,41.07 69.34,41.07 158.22,41.04 158.24,41.07 158.32,41.07 173.74,56.49 176.5,56.49 176.85,56.14 176.85,55.02 181.93,49.94 181.93,43.86 174.93,43.86 165.28,34.21 62.18,34.21 48.34,48.05 24.43,48.05 23.56,47.18 23.56,41.59 21.89,39.93 20.24,39.93 19.37,39.05 19.37,19.75 18.59,18.97 17.1,18.97 15.68,20.38 15.68,37.15 14.29,38.55 14.29,40.67 15.81,42.2 15.81,44.61 21.4,50.2 21.4,51.98 22.94,53.52 24.84,53.52 25.73,54.4 48.72,54.4 51.51,57.2 53.13,57.2
3D3V_S5 on L3: 154.76,46.9 154.76,44.54 154.77,44.52 154.77,44.17 158.72,40.22 159.82,40.22 159.92,40.32 164.87,40.32 165.61,39.58 167.21,39.58 167.44,39.81 167.44,41.64 161.04,48.04 155.91,48.04
3D3V_S5 on L3: 51.82,84.69 51.82,88 50.29,89.52 50.29,96.63 49.15,97.78 45.47,97.78 43.94,96.25 42.55,96.25 41.02,94.73 35.94,94.73 35.69,94.98 35.69,96.12 36.07,96.51 40.89,96.51 41.66,97.27 43.94,97.27 45.72,99.05 54.61,99.05 54.86,98.79 54.86,90.03 56.26,88.63 56.26,83.81 55.05,82.6 55.05,55.93 53.85,54.72 51.94,54.72 48.39,58.28 48.39,67.55 45.72,70.22 45.72,78.6
3D3V_S5 on L3: 17.75,20.58 19.76,20.58 20.04,20.86 22.48,20.86 24.31,19.04 26.67,19.04 26.89,19.25 26.9,19.24 39.04,19.24 39.47,18.81 39.47,11.69 39.45,11.67 39.45,10.27 44.65,5.07 53.8,5.07 54.15,4.71 54.15,2.19 53.87,1.92 40.39,1.92 36.32,5.98 36.32,7.86 36.58,8.11 36.58,9.15 32.61,13.12 32.61,14.44 32.64,14.46 32.64,16.01 31.9,16.75 27.81,16.75 26.42,15.35 23.5,15.35 23.24,15.61 23.24,16.24 22.73,16.75 19.94,16.75 19.86,16.83 17.75,16.83 17.63,16.95 17.63,20.46
3D3V_S5 on L4: 15.24,39.86 15.37,39.99 17.78,39.99 17.91,39.86 17.91,30.59 18.16,30.34 18.16,24.5 17.78,24.12 17.78,21.32 18.67,20.43 18.67,18.78 18.54,18.65 15.75,18.65 15.24,19.16
3D3V_S5 on L4: 54.18,92.06 54.53,91.7 54.53,90.16 55.5,89.19 55.5,88.12 55.37,88 50.29,88 50.29,92.82 51.69,94.22 53.59,94.22 54.18,93.63
3D3V_S5 on L4: 52.58,97.83 53.47,96.94 90.78,96.94 92.19,98.35 92.19,102.23 89.66,104.76 72.64,104.76 71.37,103.49 62.08,103.49 60.91,104.66 53.42,104.66 52.58,103.82
3D3V_S5_KBC on TOP: 222.12,8.11 221.87,8.37 221.87,10.65 222,10.78 223.77,10.78 224.28,10.27 224.28,8.62 223.77,8.11
3D3V_S5_KBC on TOP: 173.13,21.83 171.7,23.25 171.7,25.28 172.21,25.79 172.21,30.08 172.48,30.35 172.48,37.34 171.7,38.11 171.7,39.23 172.21,39.74 173.48,39.74 173.66,39.56 173.66,22.03 173.46,21.83
3D3V_S5_PCH on TOP: 151.89,45.07 151.76,45.2 151.76,45.32 151.38,45.71 145.29,45.71 144.4,46.59 144.4,47.74 144.53,47.86 145.92,47.86 146.18,48.12 149.73,48.12 150.62,47.23 152.78,47.23 153.16,46.85 153.16,45.32 152.91,45.07 ; 5 cut-outs
3D3V_S5_PCH on TOP: 148.55,74.88 148.26,75.17 147.07,75.17 146.94,75.3 146.94,75.8 146.69,76.06 145.92,76.06 145.8,76.19 145.8,76.69 145.92,76.82 145.92,80.73 146.13,80.93 146.13,81.8 146.43,82.1 147.12,82.1 147.32,81.9 147.32,80.99 147.29,80.96 147.29,76.31 147.7,75.91 148.72,75.91 149.17,75.45 149.17,74.99 149.12,74.94 149.11,74.94 149.05,74.88 ; 2 cut-outs
3D3V_S5_PCH on TOP: 148.21,64.73 148.06,64.88 148.06,65.16 149.07,66.18 149.07,67.98 149.05,68.01 149.17,68.13 151.21,68.13 152.63,66.71 153.21,66.71 153.37,66.56 153.37,66.13 153.21,65.97 152.68,65.97 152.04,65.34 149.2,65.34 148.59,64.73
3D3V_S5_PCH on BOTTOM: 147.19,70.72 147.07,70.85 147.07,71.61 147.19,71.74 148.72,71.74 148.97,71.49 148.97,70.98 148.72,70.72
3D3V_S5_PCH on BOTTOM: 126.47,91.37 126.26,91.58 126.26,93.25 126.77,93.76 128.68,93.76 128.91,93.53 128.91,91.45 128.83,91.37
3D3V_S5_PCH on BOTTOM: 156.46,51.17 155.7,51.93 155.7,52.44 155.83,52.56 160.15,52.56 160.66,53.07 160.66,53.83 162.94,56.12 169.54,56.12 170.56,55.1 170.56,52.31 170.31,52.06 169.8,52.06 167.13,54.72 163.7,54.72 162.31,53.33 162.31,51.42 162.05,51.17 ; 5 cut-outs
3D3V_S5_PCH on L3: 148.56,65.26 147.85,65.26 146.84,64.25 146.84,62.42 147.12,62.14 147.12,60.84 147.83,60.13 147.84,60.13 148.04,59.93 148.04,59.69 148.64,59.09 148.64,57.52 149.83,56.32 149.83,51.01 150.34,50.51 150.34,49.41 148.59,47.66 148.59,46.59 149.07,46.11 153.92,46.11 156.41,48.6 156.41,52.28 154.1,54.6 154.1,57.9 150.67,61.33 150.67,62.19 149.66,63.21 149.66,64.17
3D3V_S5_PCH on L3: 148.08,68.95 150.62,66.41 151.64,66.41 151.89,66.66 151.89,67.3 149.48,69.71 149.48,71.36 149.22,71.61 148.34,71.61 148.08,71.36
3D3V_S5_WLAN on TOP: 36.32,49.13 35.81,49.64 35.81,50.02 35.94,50.15 36.32,50.15 36.7,50.53 36.7,51.8 36.83,51.93 37.85,51.93 38.61,51.17 38.61,49.64 38.1,49.13 ; 2 cut-outs
3D3V_S5_WLAN on TOP: 49.28,57.9 48.64,58.53 43.81,58.53 42.57,59.78 42.57,63.71 42.04,64.25 37.72,64.25 37.46,64.51 37.46,67.01 37.62,67.17 39.88,67.17 40.68,66.37 43.75,66.37 46.35,63.76 46.35,60.82 46.61,60.56 49.53,60.56 49.66,60.44 49.66,58.02 49.53,57.9 ; 6 cut-outs
3D3V_S5_WLAN on BOTTOM: 36.32,49.13 35.81,49.64 35.81,51.04 35.94,51.17 37.85,51.17 38.1,51.42 38.1,53.58 39.37,54.85 39.37,64.12 37.97,65.52 37.97,67.42 37.47,67.93 36.07,67.93 35.94,68.06 35.94,69.07 36.32,69.45 38.23,69.45 39.24,68.44 39.24,66.53 41.15,64.63 41.15,54.09 39.62,52.56 39.62,50.66 38.1,49.13
3D3V_S5_WWAN on TOP: 89.48,102.07 89.43,102.12 89.43,102.55 89.53,102.65 89.94,102.65 91.14,103.85 91.14,104.1 92.23,105.19 93.75,105.19 93.93,105.01 93.93,103.85 93.57,103.49 93.07,103.49 91.8,102.22 90.2,102.22 90.04,102.07
3D3V_S5_WWAN on BOTTOM: 99.06,99.05 98.81,99.3 98.81,100.06 95.71,103.16 92.41,103.16 91.87,103.69 91.87,104.89 92.13,105.14 97.66,105.14 97.92,105.4 97.92,121.02 97.54,121.4 95,121.4 94.74,121.65 94.74,123.94 95.12,124.32 96.9,124.32 97.79,125.21 100.33,125.21 100.84,124.7 100.84,123.05 99.69,121.91 99.69,109.97 99.82,109.84 99.82,101.97 100.2,101.59 101.22,101.59 101.35,101.46 101.35,99.17 101.22,99.05
3D3V_TPM on BOTTOM: 253.09,31.38 252.93,31.53 251.08,31.53 250.77,31.84 250.77,32.67 250.7,32.75 249.56,32.75 249.48,32.83 249.48,33.41 249.61,33.54 252.5,33.54 253.01,34.05 253.01,34.07 254.05,34.07 254.15,33.97 254.15,31.48 254.05,31.38 ; 4 cut-outs
3D3V_VGA_S0 on TOP: 177.55,64.5 176.91,65.14 176.91,66.03 177.16,66.28 179.96,66.28 180.09,66.15 180.09,64.63 179.96,64.5
3D3V_VGA_S0 on BOTTOM: 175.5,76.13 175.36,76.27 175.36,77.45 175.48,77.57 176.78,77.57 177.05,77.29 177.05,76.35 176.83,76.13
81208_AGND on TOP: 143.76,109.84 143.64,109.97 143.64,115.68 143.38,115.94 143.26,115.94 142.88,116.32 142.88,117.71 143,117.84 143.64,117.84 143.76,117.71 143.76,116.95 143.89,116.83 147.32,116.83 147.57,117.08 148.34,117.08 148.46,116.95 148.46,116.32 148.59,116.19 148.84,116.19 148.97,116.06 148.97,115.43 149.48,114.92 149.48,112.51 149.61,112.38 152.27,112.38 152.65,112.76 152.65,114.41 152.78,114.54 153.42,114.54 153.54,114.41 153.54,112.38 152.78,111.62 148.72,111.62 148.34,111.24 144.53,111.24 144.4,111.11 144.4,109.97 144.27,109.84 ; 21 cut-outs
+DC_IN on TOP: 49.78,111.24 49.15,111.87 49.15,119.24 49.91,120 57.28,120 57.66,119.62 57.66,118.98 57.28,118.6 53.72,118.6 53.47,118.35 53.47,114.79 53.21,114.54 51.94,114.54 51.69,114.29 51.69,111.87 51.05,111.24
+DC_IN on TOP: 56.77,107.43 56.39,107.81 56.39,109.97 56.64,110.22 60.07,110.22 62.23,112.38 63.37,112.38 63.63,112.13 63.63,111.62 63.12,111.11 63.12,108.44 62.99,108.32 61.34,108.32 61.21,108.19 61.21,107.68 60.96,107.43 ; 3 cut-outs
