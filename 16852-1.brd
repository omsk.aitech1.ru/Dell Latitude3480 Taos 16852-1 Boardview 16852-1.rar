# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
CFG11: length 42.7
  TOP w0.114: XDP1.18 66.5,92.87 66.06,93.31 65.37,93.31 v1(65.02,92.96)
  BOTTOM w0.089: 89.37,83.97 89.74,83.97 90.02,83.68 91.28,83.68 91.29,83.67 91.85,83.43 92.89,83.43 CPU1.G68
  BOTTOM w0.114: 89.37,83.97 89.36,83.96 86.91,83.96 86.02,83.06 83.11,83.06 82.06,82.01 72.41,82.01 72.39,81.98 67.96,81.98 65.78,84.17 65.78,86.1 v2(65.43,86.45) 64.94,86.94 64.94,87.97 65.06,88.08 65.06,88.97 65.02,89.01 v1(65.02,92.96)
CFG12: length 39.8
  TOP w0.114: XDP1.28 64,89.55 63.38,88.94 v1(63.17,88.94)
  BOTTOM w0.089: 90.99,82.21 91.93,82.21 92.05,82.26 CPU1.H70
  BOTTOM w0.114: v1(63.17,88.94) 63.17,88.4 63.21,88.36 63.21,84.49 68.05,79.65 70.16,79.65 70.61,80.1 74.22,80.1 74.71,79.62 75.59,79.62 75.64,79.67 79.17,79.67 79.65,79.18 v2(80.49,79.18) 81.48,79.18 83.77,81.47 87.02,81.47 87.52,81.98 90.75,81.98 90.99,82.21
CFG13: length 39.8
  TOP w0.114: v1(63.51,92.4) 63.53,92.39 63.53,90.75 XDP1.30
  BOTTOM w0.089: 89.82,83.26 91.07,83.26 91.18,83.16 CPU1.G71
  BOTTOM w0.114: v1(63.51,92.4) 63.51,89.82 64.06,89.27 64.06,89.07 64.42,88.71 64.42,88.35 64.31,88.23 64.31,85.84 65.02,85.12 65.02,84.03 68.4,80.65 v2(69.49,80.65) 69.81,80.65 70.22,81.06 74.79,81.06 75.11,81.37 82.32,81.37 83.38,82.43 86.28,82.43 87.17,83.32 87.76,83.32 87.99,83.55 89.53,83.55 89.82,83.26
CFG14: length 43.6
  TOP w0.114: XDP1.34 62.5,92.43 v1(62.38,92.54)
  BOTTOM w0.089: 88.22,83.14 89.3,83.14 89.58,82.86 89.77,82.86 89.78,82.87 90.89,82.87 91.04,82.72 91.45,82.72 91.46,82.73 91.53,82.76 91.71,82.76 91.84,82.72 92.09,82.72 92.19,82.76 92.39,82.76 CPU1.H69
  BOTTOM w0.114: v1(62.38,92.54) 63.2,91.73 63.2,89.68 63.61,89.27 63.61,88.75 63.55,88.69 63.55,84.6 68.18,79.97 70.03,79.97 70.48,80.42 74.35,80.42 74.84,79.94 75.46,79.94 75.51,79.99 81.84,79.99 83.64,81.79 86.87,81.79 v2(87.55,82.48) 88.22,83.14
CFG15: length 43.1
  TOP w0.114: v1(62.1,93.11) 61.81,92.82 61.81,92.5 62,92.31 XDP1.36
  BOTTOM w0.089: CPU1.G70 91.82,83.16 91.66,83.32 91.24,83.5 89.91,83.5
  BOTTOM w0.114: v1(62.1,93.11) 62.37,93.11 62.78,93.53 63.15,93.53 64.47,92.22 64.47,89.12 64.74,88.84 64.74,88.22 64.62,88.1 64.62,86.26 65.46,85.42 65.46,84.03 67.95,81.54 70.84,81.54 v2(70.97,81.42) 74.71,81.42 74.98,81.69 82.19,81.69 83.24,82.74 86.15,82.74 87.04,83.64 87.76,83.64 87.88,83.75 89.66,83.75 89.91,83.5
CFG16: length 34.9
  TOP w0.114: v1(68.73,86.73) 68.73,86.93 68.12,87.54 v2(68.1,87.54) 68.1,88.12 69.5,89.52 XDP1.6
  L3 w0.114: v1(76.15,84.67) 77.62,86.14 80.55,86.14 81.36,85.32 82.95,85.32 83.08,85.45 93.74,85.45 94.71,84.49 v1(95.69,84.49)
  L6 w0.114: v1(68.73,86.73) 68.73,86.7 68.99,86.45 71.52,86.45 71.76,86.2 72.19,86.2 73.73,84.67 v1(76.15,84.67)
  BOTTOM w0.114: v1(95.69,84.49) 95.74,84.43 95.93,84.43 CPU1.E63
CFG17: length 36.3
  TOP w0.114: XDP1.4 70,89.39 68.66,88.05 v1(68.66,87.69)
  L3 w0.114: v1(77.19,84.55) 77.19,85.08 77.93,85.82 80.42,85.82 81.23,85.01 83.08,85.01 83.21,85.14 93.77,85.14 v1(95.78,83.13)
  BOTTOM w0.114: CPU1.F63 96.14,83.4 95.87,83.13 v1(95.78,83.13) ; v1(68.66,87.69) 68.29,87.32 68.29,86.27 70.33,84.23 76.55,84.23 v2(76.67,84.35) 76.69,84.35 76.71,84.36 77.01,84.36 v1(77.19,84.55)
CFG18: length 36.2
  TOP w0.114: XDP1.24 65,89.3 65.78,88.52 v1(66.58,88.52)
  L3 w0.114: v1(80.62,83.96) 81.06,84.4 84.06,84.4 84.2,84.26 87.08,84.26 87.76,84.93 92.94,84.93 v1(93.71,84.16)
  BOTTOM w0.114: v1(93.71,84.16) 93.81,84.05 CPU1.E66 ; v1(66.58,88.52) 66.58,87.92 67.34,87.15 67.34,84.62 v2(67.39,84.57) 68.7,83.25 71.86,83.25 71.89,83.28 79.94,83.28 v1(80.62,83.96)
CFG19: length 43.7
  TOP w0.114: v1(64.36,94.31) 64.17,94.11 64,94.11 63.89,94 63.89,93.42 64,93.31 64.03,93.31 64.81,92.52 64.86,92.52 65.5,91.89 XDP1.22
  L3 w0.114: v1(81.31,83.96) 84.05,83.96 84.07,83.94 90.66,83.94 91.45,84.73 92.66,84.73 92.9,84.5 92.9,84.34 v1(93.72,83.52)
  BOTTOM w0.114: v1(64.36,94.31) 64.95,93.72 65.34,93.72 65.41,93.65 65.52,93.65 66.41,92.75 66.41,90.69 66.71,90.39 66.71,89.01 67.05,88.67 67.05,87.9 67.66,87.29 67.66,86 70.07,83.6 79.55,83.6 v2(79.73,83.78) 80.35,84.4 80.87,84.4 v1(81.31,83.96) ; v1(93.72,83.52) 93.84,83.4 CPU1.F66
CFG_RCOMP: length 4
  TOP w0.305: R601.1 95.82,81.96 96.77,82.92 v1(96.77,82.97)
  TOP w0.508: v2(97.33,82.92) 96.82,82.92 v1(96.77,82.97)
  BOTTOM w0.152: v1(96.77,82.97) 96.82,82.97 96.88,83.02 97.4,83.02 97.66,83.28 97.66,83.47 CPU1.E60
CHARGER_SRC:
  vias: v2(221.36,24.88) v3(221.36,23.81)
CHG_AGND: length 10.4
  TOP w0.508: PC4404.1 230.49,12.72 230.91,13.14 v1(230.91,13.19) ; PC4412.1 228.32,13.65 228.14,13.83 v1(228.14,14.95) ; v1(229.49,22.08) 229.62,21.96 PR4423.2 PC4421.2 ; PR4424.2 v1(239.5,22.29) ; PC4403.1 233.18,12.95 v1(232.92,13.22) ; v1(234.62,23.53) 234.92,23.23 234.92,22.81 PC4422.2
  BOTTOM w0.508: v1(243.05,15.3) 243.05,14.03 242.95,13.93 242.95,13.07 v1(242.34,12.46)
  vias: v1(232.36,16.98) v1(233.17,17.71) v1(233.17,17) v1(233.17,16.27) v1(233.99,17) v2(243.26,14.62)
CHG_AMBER_LED#: length 7.7
  TOP w0.127: Q2417.3 200.26,12.23 200.11,12.38 v2(200.11,12.39) 200.1,12.39 199.71,12.78 199.71,14.42 200.25,14.96 200.25,15.89 200.46,16.09 v1(200.46,16.14)
  BOTTOM w0.127: v1(200.46,16.14) 200.46,16.95 199.79,17.62 Q6406.1
CHG_AMBER_LED#_M: length 2.4
  BOTTOM w0.127: Q6406.6 199.79,20.67 199.64,20.81 199.64,21.07 v2(199.52,21.19) 199.26,21.45 R6405.1
CHG_AMBER_LED_R#: length 30.8
  TOP w0.127: v1(211.63,7.48) 211.63,7.37 Q6403.B
  L6 w0.127: v1(211.63,7.48) 207.77,7.48 204.01,11.24 203.91,11.24 203.44,11.71 200.37,11.71 199.64,12.44 199.64,13.31 198.21,14.75 198.21,22.3 198.6,22.69 v1(198.6,22.82)
  BOTTOM w0.127: v1(198.6,22.82) 199.01,22.41 v2(199.01,22.34) 198.63,21.96 198.04,21.96 197.68,21.59 R6405.2
CKEA0: length 52.1
  TOP w0.127: VRAM1.K9 162.06,108.84 163.7,108.84 v1(164.2,108.34)
  L4 w0.127: v1(174.65,86.25) 174.61,86.21 173.18,86.21 172.93,86.46 172.93,89.51 ; 158.68,108.25 159,108.58 161.3,108.58 161.7,108.98 163.57,108.98 v1(164.2,108.34)
  L4 w0.254: 172.93,89.51 171.68,90.76 166.85,90.76 166.82,90.79 166.81,90.79 166.18,91.43 163.75,91.43 163.4,91.07 160.63,91.07 156.64,95.06 156.64,106.59 156.7,106.65 156.7,106.66 158.08,108.04 158.09,108.04 158.31,108.25 158.68,108.25
  BOTTOM w0.127: VRAM2.K9 167.78,108.84 166.38,108.84 166.09,108.56 165.26,108.56 165.04,108.34 v1(164.2,108.34)
  BOTTOM w0.14: v1(174.65,86.25) 174.4,86 GPU1.K20
CKEA1: length 53.4
  TOP w0.127: v1(186.69,108.34) 186.19,108.84 184.56,108.84 VRAM4.K9
  L4 w0.127: v1(176.97,87.14) 177.82,87.14 178.59,87.91 178.59,89.06 179.16,89.64 182.21,89.64 ; 192.53,108.32 190.72,108.32 190.6,108.44 190.6,108.7 190.47,108.82 189.86,108.82 189.49,109.19 188.78,109.19 188.62,109.02 188.62,107.85 188.49,107.72 187.84,107.72 187.58,107.98 187.58,108.21 187.45,108.34 v1(186.69,108.34)
  L4 w0.254: 192.53,108.32 192.64,108.32 196.12,104.84 196.12,96.28 193.26,93.43 191.8,93.43 191.79,93.44 191.78,93.44 191.4,93.81 190.48,93.81 190.03,93.37 188.25,93.37 185.49,90.61 183.97,90.61 183.43,90.07 182.64,90.07 182.21,89.64
  BOTTOM w0.127: VRAM3.K9 190.28,108.84 188.43,108.84 188.14,108.56 187.91,108.56 187.7,108.34 v1(186.69,108.34)
  BOTTOM w0.14: GPU1.J17 176.57,86.8 176.9,87.14 v1(176.97,87.14)
CL_CLK: length 436.2
  TOP w0.14: R6109.1 37.2,59.22 37.54,59.22 37.79,58.97 37.79,58.97 v1(37.97,58.79)
  L3 w0.127: v1(141.97,3.68) 142.31,3.68 146.27,7.64 174.66,7.64 174.95,7.34 184.71,7.34 185.01,7.64 190.54,7.64 191.12,8.21 198.1,8.21 198.37,8.48 198.74,8.48 198.82,8.4 212.77,8.4 213.15,8.02 v1(213.15,7.22)
  L6 w0.114: v1(133.49,89) 133.32,88.83 133.32,87.79 133.77,87.35 137.02,87.35 141.91,82.47 141.93,82.47 145.02,79.37 145.02,74.1 146.2,72.92 147.9,72.92 149.94,70.88 149.94,69.91 150.34,69.51 153.78,69.51 154.31,68.98 155.41,68.98 155.79,69.36 155.79,70.38 156.17,70.76 160.06,70.76 160.44,70.38 160.44,66.91 163.94,63.41 170.79,63.41 172.58,61.61 177.74,61.61 179.03,60.32 179.03,57.79 180.4,56.42 186.56,56.42 188.05,57.91 192.07,57.91 192.95,57.03 192.95,56.63 v1(192.66,56.33) ; v1(213.15,7.22) 213.15,7.78 213.02,7.92 209.49,7.92 207.19,10.22 206.04,10.22 205.72,10.54 205.5,10.54 204.45,11.59 204.45,12.21 203.91,12.75 203.91,13.12 203.56,13.47 201.48,13.47 199.34,15.62 199.34,19.54 199.69,19.89 199.69,21.59 200.08,21.98 200.08,24.62 200.47,25.02 200.47,26.46 199.4,27.53 198.94,27.53 198.48,28 198.48,29.93 199.24,30.69 199.24,30.99 199.38,31.12 199.38,33.68 198.08,34.97 198.08,39.85 196.58,41.35 196.58,45.63 197.06,46.11 197.06,47.69 v1(196.96,47.79) ; v1(37.97,58.79) 38.28,58.79 38.7,59.21 39.08,59.21 41.87,61.99 46.16,61.99 46.57,61.59 47.11,61.59 47.67,62.15 57.97,62.15 59.68,60.43 59.68,57.76 62.66,54.78 63.78,54.78 67.24,51.31 67.24,47.38 65.14,45.28 65.14,39.16 55.18,29.19 55.18,24.27 53.3,22.4 44.65,22.4 39.03,16.79 39.03,13.64 47.63,5.05 53.11,5.05 56.17,1.99 61.91,1.99 62.56,1.34 64.33,1.34 65.99,2.99 67.37,2.99 68.08,2.29 80.4,2.29 81.07,1.62 134.22,1.62 136.53,3.92 141.73,3.92 v1(141.97,3.68)
  BOTTOM w0.089: 132.64,84.33 131.95,83.64 131.8,83.64 131.64,83.58 131.01,83.58 CPU1.G3
  BOTTOM w0.14: 132.64,84.33 132.64,84.38 132.82,84.56 132.82,87.24 133.41,87.83 133.41,88.92 v1(133.49,89) ; v2(192.23,56.93) 192.23,56.76 v1(192.66,56.33) 192.91,56.08 192.91,55.66 194.78,53.79 196.69,53.79 197.27,53.21 197.27,48.09 v1(196.96,47.79)
CL_CLK_R: length 4.5
  TOP w0.14: R6109.2 35.18,58.91 34.67,58.41 34.58,58.41 v1(34.54,58.37) 34.54,58.36 v2(34.54,57.77)
  BOTTOM w0.14: v1(34.54,58.37) 34.54,58.37 34.68,58.5 WLAN1.42
CL_DATA: length 435.2
  TOP w0.14: v1(142.26,4.29) 142.26,4.28 142.54,4.28 v2(142.77,4.51) ; v1(37.97,59.42) 37.91,59.48 37.21,59.48 R6119.1
  L3 w0.127: v1(213.96,7.22) 213.4,7.79 213.4,8.12 212.87,8.64 198.92,8.64 198.84,8.72 198.27,8.72 198,8.45 191.02,8.45 190.44,7.88 184.91,7.88 184.61,7.58 175.06,7.58 174.76,7.88 146.17,7.88 142.58,4.29 v1(142.26,4.29)
  L6 w0.114: v1(197.74,47.79) 197.27,47.32 197.27,46.02 196.8,45.54 196.8,41.44 198.3,39.94 198.3,35.06 199.59,33.77 199.59,31.03 199.46,30.9 199.46,30.6 198.7,29.84 198.7,28.09 199.03,27.75 199.49,27.75 200.69,26.55 200.69,24.93 200.29,24.53 200.29,21.89 199.9,21.5 199.9,19.8 199.56,19.45 199.56,15.71 201.57,13.69 203.65,13.69 204.13,13.21 204.13,12.84 204.67,12.3 204.67,11.68 205.59,10.76 205.81,10.76 206.13,10.44 207.28,10.44 209.58,8.13 213.11,8.13 213.37,7.87 213.37,7.78 213.4,7.78 v1(213.96,7.22) ; v1(37.97,59.42) 38.99,59.42 41.78,62.21 46.25,62.21 46.66,61.8 47.02,61.8 47.58,62.36 58.06,62.36 59.9,60.52 59.9,57.85 62.75,54.99 63.87,54.99 67.46,51.4 67.46,47.29 65.36,45.19 65.36,39.07 55.39,29.1 55.39,24.18 53.39,22.19 44.74,22.19 39.25,16.7 39.25,13.73 47.72,5.26 53.19,5.26 56.26,2.2 62,2.2 62.65,1.55 64.24,1.55 65.9,3.21 67.46,3.21 68.17,2.51 80.48,2.51 81.16,1.83 134.13,1.83 136.44,4.14 142.11,4.14 v1(142.26,4.29) ; v1(193.44,56.33) 193.17,56.6 193.17,57.12 192.16,58.13 187.96,58.13 186.47,56.63 180.49,56.63 179.25,57.88 179.25,60.41 177.83,61.83 172.67,61.83 170.88,63.62 164.03,63.62 160.66,67 160.66,70.47 160.15,70.98 156.08,70.98 155.57,70.47 155.57,69.45 155.32,69.2 154.4,69.2 153.87,69.73 150.43,69.73 150.15,70 150.15,70.97 147.98,73.14 146.29,73.14 145.24,74.19 145.24,79.46 142.02,82.68 142,82.68 137.11,87.56 133.86,87.56 133.54,87.88 133.54,88.12 v1(133.88,88.46)
  BOTTOM w0.089: CPU1.G2 131.48,83.4 131.68,83.4 131.84,83.46 132.1,83.46 132.95,84.31
  BOTTOM w0.14: v1(197.74,47.79) 197.54,47.99 197.54,53.33 196.8,54.06 194.89,54.06 193.18,55.77 193.18,56.08 v1(193.44,56.33) ; 132.95,84.31 132.95,84.31 133.09,84.45 133.09,87.13 133.68,87.72 133.68,88.26 v1(133.88,88.46)
CL_DATA_R: length 4.5
  TOP w0.14: v2(34.49,59.57) 34.54,59.52 34.54,59.01 v1(34.56,59) 34.89,59 35.07,59.18 35.38,59.18 R6119.2
  BOTTOM w0.14: v1(34.56,59) WLAN1.40
CL_RST#: length 144.8
  TOP w0.14: R6108.1 32.7,60.25 32.64,60.31 v1(32.64,60.44)
  L4 w0.114: v1(134.12,89.05) 133.61,89.56 133.61,90.74 132.27,92.09 128.59,92.09 126.87,93.81 125.6,93.81 124.99,94.42 118.53,94.42 118.53,94.42 118.23,94.42 117.13,93.32 110.8,93.32 107.26,96.86 106.53,96.86 106.53,96.86 101.19,96.86 95.09,90.76 90.72,90.76 89.86,89.9 84.2,89.9 79.19,84.9 77.46,84.9 77.25,85.11 75.36,85.11 74.56,84.31 70.63,84.31 69.26,85.68 66.64,85.68 65.36,86.96 62.7,86.96 62.28,86.54 61.92,86.54 60.95,87.51 56.43,87.51 50.58,81.67 47.66,81.67 47.41,81.91 41.04,81.91 32.02,72.89 32.02,64.87 33.43,63.46 33.43,62.08 32.64,61.29 v1(32.64,60.44)
  BOTTOM w0.089: CPU1.G1 132,83.27 132.48,83.27
  BOTTOM w0.14: v1(134.12,89.05) 134.16,89.05 ; 134.16,89.05 134.29,88.92 134.29,87.58 133.43,86.72 133.43,84.36 133.61,84.18 133.61,83.71 133.17,83.27 132.48,83.27 ; 134.16,89.05 134.18,89.05 135,89.88 v2(135,90.31) EC1805.1
CL_RST#_R: length 4.8
  TOP w0.14: R6108.2 34.48,60.44 v1(35.05,60.44) 35.43,60.44 v2(35.81,60.82)
  BOTTOM w0.14: WLAN1.38 35.99,59.5 v1(35.05,60.44)
CLK_ITE8010: length 15.1
  TOP w0.14: U9601.19 71.91,77.79 71.65,78.06 71.61,78.06 v1(71.42,78.24) 71.42,78.35 70.93,78.85 68.94,78.85 68.12,78.04 68.12,73.9 68.45,73.57 68.45,72.49 R2474.2
  BOTTOM w0.14: v1(71.42,78.24) 72.34,79.16 v2(73.05,79.16) R9602.2
CLK_LAN_REQ4#_R: length 9.8
  TOP w0.127: R3113.2 49.4,96.89 v1(48.9,96.38) 48.9,96.38 v2(48.39,95.87)
  L4 w0.127: v1(44.18,99.24) 45.14,98.28 46.99,98.28 48.89,96.38 v1(48.9,96.38)
  BOTTOM w0.127: v1(44.18,99.24) 44,99.05 LOM31.12
CLK_PCI_LPC: length 15.5
  TOP w0.14: v1(285.34,30.12) 285.31,30.16 R9127.2 286.15,32.02 DB1.9
  L6 w0.114: v1(285.34,30.12) 285.41,30.06 285.41,28.34 279.91,22.85 v1(279.65,22.85)
  BOTTOM w0.14: R9121.2 279.4,22.59 v1(279.65,22.85) 280.24,23.43 v2(280.24,23.49)
CLK_PCI_LPC_MEC: length 97.9
  TOP w0.14: KBC24.57 205.52,38.44 v1(205.49,38.47)
  BOTTOM w0.14: R1805.2 EC1801.1 132.94,55.9 133.71,55.14 v2(133.71,54.47) 133.71,54.04 134.26,53.48 134.98,53.48 136.21,52.26 137.75,52.26 139.45,50.55 139.45,50.23 147,42.68 167.14,42.68 167.31,42.85 170.49,42.85 170.76,42.59 172.4,42.59 172.9,42.09 172.9,41.53 174.92,39.51 180.78,39.51 180.97,39.7 182.14,39.7 182.49,39.35 183.75,39.35 184.58,40.17 185.2,40.17 185.39,40.37 186.17,40.37 186.61,39.92 186.61,39.15 186.99,38.78 188.91,38.78 189.25,39.12 189.25,41.35 189.68,41.78 191.16,41.78 193.22,43.84 194.78,43.84 194.82,43.8 197.27,43.8 199.63,46.16 200.66,46.16 200.93,45.9 204.21,45.9 204.47,45.64 204.47,45.63 206.3,43.8 206.3,43.31 206.05,43.06 206.05,41.52 206.83,40.74 206.83,39.74 205.55,38.47 v1(205.49,38.47)
CLK_PCI_LPC_R: length 252.4
  TOP w0.14: R9127.1 284.39,31.21 283.52,31.21 282.68,30.36 v1(282.68,30.21) ; v1(77.39,8.75) 77.39,8.16 v2(77.63,7.93) 78.74,6.82 U9103.8
  L3 w0.127: v1(77.39,8.75) 79.68,11.03 97.95,11.03 98.27,11.35 109.98,11.35 111.02,12.39 114.22,12.39 114.9,11.71 116.44,10.17 117.07,10.17 117.84,9.4 118.95,9.4 119.39,8.96 125.44,8.96 126.69,10.21 142.92,10.21 144.59,11.89 147.84,11.89 148.04,12.09 180.99,12.09 183.6,14.7 183.6,15.62 183.75,15.77 183.75,22.23 185.41,23.89 187.08,23.89 188.38,22.6 188.38,21.38 188.14,21.14 188.14,17.88 188.41,17.61 189.26,17.61 189.55,17.32 189.88,17.32 191.85,15.35 194.36,15.35 195.13,14.59 197.48,14.59 197.68,14.78 198.93,14.78 199.28,14.42 199.65,14.42 199.82,14.59 204.25,14.59 204.95,15.29 206.21,15.29 206.34,15.16 212.37,15.16 215.02,12.51 223.85,12.51 224.16,12.81 224.16,13.07 224.41,13.32 225.17,13.32 227.28,11.21 227.28,9.31 228.68,7.91 233.88,7.91 235.26,9.28 236.49,9.28 237.03,9.82 237.03,10.11 239.34,12.42 241.61,12.42 244.07,14.88 244.07,15.54 247.83,19.3 247.83,20.14 247.51,20.46 247.51,24.48 248.75,25.71 250.08,25.71 251.13,24.66 251.13,24.61 251.72,24.01 253.57,24.01 254.44,23.14 255.04,23.14 255.61,23.71 256.97,23.71 259.3,26.03 262.01,26.03 262.89,26.91 263.65,26.91 264.92,28.18 270,28.18 271.35,29.53 279.98,29.53 280.67,30.21 v1(282.68,30.21)
CLK_PCIE_N5_WWAN#: length 65.5
  TOP w0.102: v1(101.02,119.16) 101.02,119.39 100.91,119.49 97.79,119.49 97.54,119.24 ; v1(91.95,89.75) 91.85,89.65 91.49,89.65 91.36,89.77 91.36,90.71 91.9,91.25 93.14,91.25 94.6,92.7 94.6,98.73 96.04,100.17 96.04,109.22 95.16,110.1 95.16,115.63 95.71,116.18 95.71,117.41 97.54,119.24 ; 97.54,119.24 v2(97.66,119.11)
  L6 w0.102: v1(109.65,84.34) 109.5,84.34 108.85,84.98 108.85,85.72 107.58,86.99 107.58,87.49 107.14,87.93 105.11,87.93 104.44,88.61 99.46,88.61 98.83,87.98 98.4,87.98 97.67,88.71 92.27,88.71 91.95,89.04 91.95,89.06 v1(91.95,89.75)
  BOTTOM w0.102: WWAN1.53 103.5,117.25 103.36,117.4 103.17,117.4 102.79,117.77 102.79,118.04 101.71,119.12 101.71,119.61 101.6,119.72 101.4,119.72 101.02,119.34 v1(101.02,119.16) ; CPU1.E40 109.43,83.99 109.65,84.21 v1(109.65,84.34)
CLK_PCIE_P5_WWAN: length 65.5
  TOP w0.102: 99.19,119.7 100.73,119.7 v1(101.05,120.02) ; 99.19,119.7 97.71,119.7 95.5,117.49 95.5,116.26 94.96,115.71 94.96,110.02 95.83,109.14 95.83,100.25 94.4,98.81 94.4,92.79 93.06,91.45 91.81,91.45 91.16,90.8 91.16,89.69 91.47,89.39 v1(91.47,89.15) ; 99.19,119.7 v2(99.19,119.87)
  L6 w0.102: v1(91.47,89.15) 91.49,89.15 92.17,88.47 97.57,88.47 98.3,87.74 98.93,87.74 99.56,88.36 104.34,88.36 105.01,87.69 107.04,87.69 107.34,87.39 107.34,86.89 108.61,85.62 108.61,84.88 109.27,84.22 109.27,84.04 v1(109.65,83.65)
  BOTTOM w0.102: CPU1.E38 109.99,83.99 v1(109.65,83.65) ; v1(101.05,120.02) 101.15,119.92 101.68,119.92 101.92,119.69 101.92,119.21 103,118.13 103,117.86 103.25,117.6 103.36,117.6 103.5,117.75 WWAN1.55
CLK_TP_SIO: length 98.6
  TOP w0.14: v2(200.03,18.02) 200.61,18.02 v1(200.66,17.97) ; RN6503.1 135.31,4.5 135.12,4.31 134.68,4.31 EC6503.1 134.05,4.31 133.48,4.31 133.14,4.65 v1(133.14,4.71) ; v1(203.89,30.62) 203.53,30.27 203.14,30.27 202.75,29.87 202.23,29.87 202.16,29.94 KBC24.78
  L4 w0.127: v1(200.66,17.97) 200.66,17.5 200.26,17.1 199.3,17.1 198.61,17.8 194.66,17.8 192.39,15.53 192.39,13.05 187.68,8.34 142.79,8.34 139.37,4.92 136.17,4.92 135.47,4.23 133.5,4.23 133.14,4.59 v1(133.14,4.71)
  L6 w0.114: v1(203.89,30.62) 203.58,30.31 203.25,30.31 202.68,29.75 202.62,29.75 202.24,29.36 202.24,29.3 200.98,28.05 200.98,27.48 201.43,27.02 201.43,24.62 201.04,24.22 201.04,21.67 201.16,21.55 201.16,18.5 200.66,18 v1(200.66,17.97)
  BOTTOM w0.14: v1(133.14,4.71) 133.34,4.5 RN6504.4
CLKA0: length 58.7
  TOP w0.152: VRAM1.J7 163.32,107.81 163.45,107.94 163.62,107.94 163.99,107.57 164.37,107.57 164.86,107.08 v1(164.86,107.04) ; v1(170.56,108.04) 170.7,108.18 170.7,108.18 171.53,108.18 R7805.1
  L6 w0.127: v1(170.56,108.04) 170.38,108.21 168.28,108.21 167.77,108.72 166.85,108.72 166.34,108.22 166.34,107.91 165.67,107.24 165.06,107.24 v1(164.86,107.04) 164.86,107.1 164.51,107.45 163.86,107.45 163.34,107.98 163.34,108.27 163.09,108.52 162.75,108.52 161.95,108.52 161.46,108.04 158.54,108.04 157.99,107.48 157.99,100.13 156.9,99.04 156.9,90.35 158.17,89.08 158.17,86.83 158.65,86.36 159.78,86.36 160.14,85.99 160.14,85.53 160.27,85.41 160.86,85.41 160.99,85.53 160.99,85.99 161.26,86.27 162.03,86.27 162.31,85.99 162.31,85.51 162.43,85.38 162.84,85.38 162.97,85.51 162.97,85.99 163.24,86.27 166.81,86.27 168.25,87.71 168.25,88.28 168.4,88.43 168.67,88.43 168.92,88.18 v1(168.92,88.04)
  BOTTOM w0.152: v1(170.56,108.04) 170.61,107.99 v2(170.61,107.48) ; VRAM2.J7 166.52,107.76 166.39,107.89 166.18,107.89 165.74,107.44 165.27,107.44 v1(164.86,107.04) ; v1(168.92,88.04) 168.92,87.81 169.13,87.6 GPU1.H26
CLKA0#: length 59.3
  TOP w0.152: v1(170.56,108.7) 170.81,108.44 171.64,108.44 R7806.1 ; v1(164.87,107.68) 164.72,107.84 164.1,107.84 163.73,108.21 163.43,108.21 163.32,108.31 VRAM1.K7
  L6 w0.127: v1(169.72,88) 169.32,87.59 168.5,87.59 166.92,86.01 163.35,86.01 163.22,85.89 163.22,85.4 162.95,85.13 162.33,85.13 162.05,85.4 162.05,85.89 161.93,86.01 161.37,86.01 161.24,85.89 161.24,85.43 160.96,85.15 160.16,85.15 159.89,85.43 159.89,85.89 159.67,86.1 158.54,86.1 157.92,86.73 157.92,88.97 156.64,90.25 156.64,99.14 157.73,100.23 157.73,107.59 158.09,107.94 158.44,108.29 161.36,108.29 161.84,108.77 162.64,108.77 162.64,108.77 163.2,108.77 163.59,108.38 163.59,108.08 163.97,107.71 164.61,107.71 164.64,107.68 v1(164.87,107.68) 165.06,107.49 165.57,107.49 166.09,108.02 166.09,108.33 166.74,108.98 167.88,108.98 168.39,108.47 170.33,108.47 v1(170.56,108.7)
  BOTTOM w0.152: GPU1.H25 v1(169.72,88) ; v2(170.87,109.28) 170.87,109 v1(170.56,108.7) ; VRAM2.K7 166.42,108.5 165.63,107.71 164.9,107.71 v1(164.87,107.68)
CLKA0_CLKA0#: length 3
  TOP w0.127: R7805.2 C8146.1 ; R7805.2 v2(173.69,107.81) ; R7805.2 R7806.2
CLKA1: length 59.4
  TOP w0.152: v1(187.34,106.96) 187.31,106.96 186.77,107.5 186.52,107.5 186.08,107.95 185.95,107.95 185.82,107.82 VRAM4.J7 ; R8201.1 180.71,107.23 181.75,107.23 v1(182.03,106.95)
  L6 w0.127: v1(183.28,88.8) 183.28,88.72 183.74,88.25 184.07,88.25 184.73,87.6 185.15,87.6 185.93,88.38 190.8,88.38 191.14,88.04 191.14,87.12 191.36,86.91 191.71,86.91 191.83,87.02 191.83,87.61 191.83,87.61 191.83,87.82 192.1,88.1 192.48,88.1 192.69,88.1 192.97,87.82 192.97,87.01 193.08,86.9 193.47,86.9 195.23,88.66 195.23,90.56 196.27,91.6 196.27,104.3 195.9,104.67 195.23,105.34 195.23,105.55 195.23,105.55 195.23,107.05 193.96,108.32 190.6,108.32 190.39,108.52 189.06,108.52 188.77,108.24 188.77,107.79 188.2,107.22 187.6,107.22 v1(187.34,106.96) 187.34,107.01 187.11,107.24 186.5,107.24 185.84,107.9 185.84,108.31 185.48,108.67 184.54,108.67 183.51,107.64 182.96,107.64 182.63,107.3 182.39,107.3 v1(182.03,106.95)
  BOTTOM w0.152: v2(181.48,107.1) 181.88,107.1 v1(182.03,106.95) ; GPU1.G9 183.27,88.76 183.27,88.79 v1(183.28,88.8) ; v1(187.34,106.96) 187.71,107.33 188.26,107.33 188.64,107.7 VRAM3.J7
CLKA1#: length 59.9
  TOP w0.152: v1(182.03,107.78) 181.75,107.5 180.71,107.5 R8202.1 ; v1(187.35,107.59) 187.33,107.59 187.16,107.77 186.63,107.77 186.19,108.21 185.93,108.21 185.82,108.32 VRAM4.K7
  L6 w0.127: v1(183.37,88) 183.96,88 184.6,87.37 184.6,87.37 184.62,87.34 185.25,87.34 186.04,88.13 190.69,88.13 190.89,87.94 190.89,87.01 191.25,86.65 191.82,86.65 192.08,86.91 192.08,87.72 192.21,87.84 192.59,87.84 192.72,87.72 192.72,86.91 192.98,86.65 193.57,86.65 195.48,88.55 195.48,90.46 196.52,91.5 196.52,104.4 196,104.92 196,104.92 195.48,105.44 195.48,107.15 194.06,108.57 190.7,108.57 190.5,108.77 188.95,108.77 188.52,108.34 188.52,107.89 188.1,107.47 187.46,107.47 v1(187.35,107.59) 187.24,107.49 186.6,107.49 186.09,108 186.09,108.42 185.58,108.93 184.44,108.93 183.4,107.89 182.86,107.89 182.52,107.55 182.28,107.55 182.28,107.55 182.26,107.55 v1(182.03,107.78)
  BOTTOM w0.152: v1(182.03,107.78) 181.74,108.08 v2(181.74,108.44) ; v1(187.35,107.59) 188.15,107.59 189.02,108.46 VRAM3.K7 ; GPU1.H9 182.94,87.6 183.34,88 v1(183.37,88)
CLKA1_CLKA1#: length 3.1
  TOP w0.127: C8221.1 179.51,107.83 R8202.2 R8201.2 179.49,106.89 v2(178.61,106.89)
CLKREQ_PCIE#1: length 138.9
  TOP w0.102: R6112.2 35.5,54.98 38.23,54.98 38.35,55.1 39.12,55.1 39.37,54.85 41.76,54.85 v1(42.01,55.1) ; RN1803.5 145.66,66.78 145.53,66.91 v2(144.65,66.91) 144.63,66.89 143.77,66.89 143.23,67.42 135.15,67.42 133.97,66.24 131.48,66.24 130.48,67.24 129.11,67.24 v1(128.83,67.52)
  L4 w0.102: v1(42.01,55.1) 40.2,56.92 40.2,61.16 42.06,63.03 42.52,63.03 42.77,63.28 42.77,63.65 43.09,63.97 46.63,63.97 48.44,65.78 48.67,65.78 49.94,67.05 49.94,67.89 51.1,69.05 52.7,69.05 55.85,72.19 55.92,72.19 57.35,73.62 60.05,73.62 62.29,71.38 71.39,71.38 72.99,69.79 v1(73.03,69.79)
  L6 w0.102: v1(73.03,69.79) 73.41,69.4 76.6,69.4 81.88,74.69 84.72,74.69 85.39,75.36 87.55,75.36 87.78,75.13 96.11,75.13 99.25,71.99 99.25,71.6 99.48,71.37 100.26,71.37 100.34,71.28 119.75,71.28 120.09,70.94 123.17,70.94 123.74,70.38 123.74,70.15 124.08,69.81 124.4,69.81 124.77,69.44 124.77,67.44 125.09,67.11 126.21,67.11 126.46,67.36 126.46,67.82 126.61,67.97 127.16,67.97 127.36,67.77 127.36,67.38 127.63,67.11 128.41,67.11 v1(128.83,67.52)
  BOTTOM w0.102: CPU1.AT7 128.45,67.85 128.78,67.52 v1(128.83,67.52)
CLKREQ_PCIE#2: length 128.9
  TOP w0.102: v1(50.91,97.6) 50.48,97.17 R3113.1 ; RN1803.7 146.1,65.63 145.97,65.5 145.31,65.5 144.72,64.91 144.2,64.91 143.61,65.49 v2(143.61,65.57) 142.57,65.57 141.12,67.02 135.35,67.02 134.19,65.86 131.1,65.86 130.61,66.35 130.61,66.35 130.58,66.38 129.65,66.38 129.49,66.22 128.01,66.22 127.58,66.64 127.58,67.33 127.55,67.36 127.55,67.84 v1(127.89,68.18) ; v1(84.83,76.9) 84.83,77.2 85.5,77.86 85.5,86.67 86.79,87.97 86.79,94.24 86.52,94.51 85.89,94.51 v1(85.88,94.5)
  L4 w0.102: v1(127.89,68.18) 126.8,68.18 126.49,68.49 126.49,70.34 125.56,71.27 122.73,71.27 120.93,73.07 120.64,73.07 120.32,72.74 118.1,72.74 116.63,71.27 92.73,71.27 87.33,76.67 85.06,76.67 v1(84.83,76.9) ; v1(50.91,97.6) 51.96,96.56 83.82,96.56 v1(85.88,94.5)
  BOTTOM w0.102: CPU1.AT8 127.56,67.85 v1(127.89,68.18)
CLKREQ_PCIE#3: length 23.7
  TOP w0.102: v1(126.96,67.56) 126.91,67.56 126.49,67.15 v2(126.49,67.15) 126.49,66.84 128.29,65.05 129.1,65.05 129.17,65.12 131.05,65.12 131.53,64.65 132.27,64.65 132.3,64.62 132.62,64.62 132.66,64.65 132.73,64.65 133.38,65.29 134.62,65.29 135.74,66.41 140.33,66.41 143.61,63.13 RN1804.2
  BOTTOM w0.102: v1(126.96,67.56) 126.96,67.62 126.72,67.85 CPU1.AT10
CLKREQ_PCIE#4: length 21.8
  TOP w0.102: RN1804.1 143.42,63.78 140.6,66.61 135.53,66.61 134.4,65.48 132.22,65.48 131.98,65.24 131.62,65.24 v2(131.6,65.21) 131.23,65.21 131.13,65.31 129.1,65.31 129.02,65.24 128.44,65.24 126.99,66.69 v1(126.99,66.9)
  BOTTOM w0.102: v1(126.99,66.9) 127.14,66.9 CPU1.AU8
CLKREQ_PCIE#5: length 137.4
  TOP w0.102: R6208.1 91.8,116.57 v1(92.46,117.23) 92.51,117.23 92.96,117.69 AFTP6257.1 ; RN1803.6 145.9,66.13 v1(145.75,65.97) 145.24,66.48 144.14,66.48 143.76,66.1 142.87,66.1 141.75,67.22 135.25,67.22 134.08,66.05 131.22,66.05 130.28,66.99 128.52,66.99 127.98,67.53 v1(127.96,67.53)
  L4 w0.102: v1(145.75,65.97) 145.52,65.97 145.01,66.48 144.96,66.48 143.33,68.11 143.33,68.47 143.94,69.07 144.65,69.07 145.85,70.27 145.85,72.22 147.14,73.52 147.88,73.52 148.08,73.72 148.08,76.89 150.19,79 150.19,81.7 150.06,81.84 150.06,82.91 150.7,83.54 150.7,84.06 150.29,84.46 150,84.46 149.63,84.84 149.63,85.36 150,85.73 150.29,85.73 150.7,86.14 150.7,91.73 140.84,101.59 122.33,101.59 121.79,102.12 108.41,102.12 106.6,103.93 106.6,109.05 104.52,111.14 104.52,117.59 102.87,119.24 101.75,119.24 99.09,116.57 97.08,116.57 97.05,116.6 93.32,116.6 92.68,117.23 v1(92.46,117.23)
  BOTTOM w0.102: v1(127.96,67.53) 128.29,67.2 CPU1.AU7 ; v1(92.46,117.23) 93.09,116.6 95.54,116.6 95.95,117 WWAN1.52
CLKREQ_PEG#0: length 88.7
  TOP w0.102: v1(172.87,55.56) 171.93,56.5 169.16,56.5 168.95,56.72 168.95,61.01 168.26,61.69 168.26,61.7 165.99,63.97 165.99,67.83 166.95,68.79 168.19,68.79 168.21,68.82 170.33,68.82 171.78,70.27 173.52,70.27 173.79,70 Q7903.D ; RN1803.8 145.82,64.98 v1(145.44,64.6) 145.16,64.32 v2(144.3,64.32) 143.17,64.32 140.68,66.81 135.43,66.81 134.29,65.67 131.32,65.67 131.15,65.5 129.02,65.5 128.94,65.43 128.52,65.43 127.39,66.56 127.39,67.25 127.36,67.28 127.36,67.78 127.1,68.03 126.44,68.03 126.05,67.64 v1(126.05,67.5)
  L4 w0.102: v1(148.72,63.99) 151.18,66.46 156.43,66.46 156.99,65.9 160.91,65.9 161.98,64.83 161.98,62.93 161.82,62.77 161.82,61.61 166.5,56.93 166.88,56.93 167.31,56.5 171.93,56.5 v1(172.87,55.56)
  BOTTOM w0.102: v1(126.05,67.5) 126.05,68.05 126.5,68.5 CPU1.AR10 ; v1(145.44,64.6) 147.62,64.6 148.23,63.99 v1(148.72,63.99) 148.72,63.38 148.65,63.31 R7943.2
CLKRUN#: length 82.3
  TOP w0.102: v1(143.13,52.56) 143.13,52.64 142.85,52.92 v2(142.47,52.92) 141.91,52.36 141.62,52.36 R2401.1 140.72,52.37 R1819.2 ; v1(201.42,37.25) 201.8,37.63 202.89,37.63 203.11,37.4 KBC24.63
  L4 w0.102: v1(143.13,52.56) 142.44,51.88 142.44,50.34 144.66,48.13 151.14,48.13 153.2,46.07 168.21,46.07 168.96,45.33 181.05,45.33 181.55,45.82 183.96,45.82 184.5,45.27 191.85,45.27 192.48,45.91 194.47,45.91 196.8,48.25 200.03,48.25 v1(200.61,47.66)
  L6 w0.102: v1(201.42,37.25) 201.29,37.37 201.29,40.24 199.84,41.7 199.84,42.46 201.47,44.09 201.47,46.04 200.61,46.9 v1(200.61,47.66)
CLKRUN#_R: length 28
  TOP w0.14: v1(138.33,51.04) 138.33,51.14 v2(138.85,51.66) 139.45,52.26 139.76,52.26 ; R1818.1 139.76,52.26 ; 139.76,52.26 R1819.1
  L6 w0.114: v1(125.81,66.56) 126.52,66.56 126.79,66.29 128.68,66.29 128.75,66.36 132.32,66.36 134.69,63.99 134.69,58.6 136.09,57.2 136.09,53.1 138.15,51.04 v1(138.33,51.04)
  BOTTOM w0.14: v1(125.81,66.56) 125.81,66.41 125.76,66.36 CPU1.AW11
CLKTESTA: length 3
  TOP w0.14: v2(182.52,85.48) 182.52,85.41 183.17,84.76 C7822.1 183.45,84.76 v1(184.15,85.46)
  BOTTOM w0.14: GPU1.K8 184.15,85.57 v1(184.15,85.46)
CLKTESTA_C: length 1.9
  TOP w0.14: C7822.2 184.06,83.87 v2(184.1,83.91) 184.9,83.91 R7821.1
CLKTESTB: length 9.1
  BOTTOM w0.089: GPU1.L7 184.64,84.88 185.46,84.88 186.2,84.14 186.2,84 186.6,83.6 186.6,83.47 186.79,83.28 187.05,83.28 187.1,83.33 187.11,83.33 187.12,83.34 187.52,83.34 187.53,83.33 187.54,83.33 187.59,83.28 188.07,83.28 188.34,83.55
  BOTTOM w0.14: 188.34,83.55 189.76,83.55 189.8,83.59 190.43,83.59 190.83,83.2 v2(190.83,82.94) 191.03,82.94 191.5,83.41 C7821.1
CLKTESTB_C: length 2.2
  BOTTOM w0.14: R7820.1 192.28,81.89 v2(192.28,82.79) 192.28,83.74 C7821.2
CMP_VOUT0: length 236.3
  TOP w0.114: v1(75.82,72.38) 78.64,72.38 79.43,71.58 v1(79.45,71.58) ; v1(203.68,27.37) 203.53,27.37 203.31,27.14 KBC24.85 ; v1(166.37,33.78) 157.39,33.78 150.34,40.83 149.84,41.33 146.71,41.33 146.71,41.33 144.55,41.33 124.17,41.33 123.67,40.83 118.48,35.64 59.32,35.64 58.57,36.38 v1(58.27,36.38)
  L3 w0.114: v1(166.37,33.78) 166.63,33.52 184.15,33.52 185.1,32.57 186.83,32.57 187.67,33.41 190.65,33.41 191.52,32.54 191.52,29.9 191.63,29.79 192.9,29.79 193.81,28.88 199.59,28.88 201.06,27.42 203.63,27.42 v1(203.68,27.37) ; v1(75.82,72.38) 75.58,72.61 75.58,75.95 75.91,76.28 75.91,78.4 76.85,79.34 76.85,81.07 74.54,83.38 74.54,85.31 77.53,88.3 v1(79.3,88.3)
  BOTTOM w0.114: v1(58.27,36.38) 58.47,36.18 59.18,36.18 60.2,37.2 60.2,37.42 60.68,37.91 60.68,39.1 61.32,39.74 62.23,39.74 62.91,40.42 62.91,40.42 63.25,40.76 63.83,40.76 64.31,41.24 64.31,42.43 63.83,42.91 63.83,44.1 64.29,44.56 65.66,44.56 71.81,50.72 73.94,50.72 76.08,52.86 76.08,64.44 79.48,67.84 79.48,71.02 79.45,71.05 v1(79.45,71.58) ; v1(79.3,88.3) 78.49,87.49 R2602.2 78.03,87.1 v2(78.03,86.58) 76.59,86.58 R2607.2 R2612.2
CMP_VOUT1: length 6.1
  TOP w0.14: v1(199.9,27.96) 199.91,27.94 KBC24.83
  BOTTOM w0.14: R2418.1 R2417.1 202.5,26.78 Q2408.G v2(201.14,27.96) v1(199.9,27.96)
CPM_RST_R: length 23
  TOP w0.102: U9102.18 86.35,4.55 86.61,4.29 86.61,4.28 87.22,3.67 v1(87.27,3.67)
  BOTTOM w0.102: R9124.1 R9125.2 69.48,4 Q9103.S 74.2,2.11 81.03,2.11 81.18,1.96 84.7,1.96 v2(86,3.26) 86.41,3.67 v1(87.27,3.67)
CPU_A16_TP: length 4.2
  BOTTOM w0.102: TP1902.1 129.03,60.79 129.03,61.63 127.04,63.63 CPU1.BB9
CPU_D1_TP: length 5.9
  BOTTOM w0.089: CPU1.M2 131.49,80.76 131.72,80.76 131.83,80.81 132.18,80.81 132.36,80.64 134.12,80.64 134.33,80.85 134.33,81.44
  BOTTOM w0.102: TP1801.1 135.74,82.84 134.33,81.44
CPU_D3_TP: length 6.8
  BOTTOM w0.102: TP1807.1 135.24,83.94 135.13,83.94 134.85,83.66 134.85,82.89 134.24,82.28 131.95,82.28 131.83,82.15 130.3,82.15 130.02,81.88 CPU1.J4
CPU_D4_TP: length 3.9
  BOTTOM w0.102: CPU1.V1 131.65,77.2 132.35,77.2 132.47,77.08 132.5,77.04 134.24,77.04 134.32,76.96 134.6,76.69 TP1804.1
CPU_D5_TP: length 2.2
  TOP w0.102: v1(129.57,77) 129.62,77 129.67,76.95 TP1805.1
  BOTTOM w0.102: CPU1.V2 130.62,76.89 130.13,76.89 130.03,77 v1(129.57,77)
CPU_D6_TP: length 6.6
  BOTTOM w0.089: CPU1.M1 132.19,80.55 132.28,80.46 134.32,80.46 134.52,80.66 134.52,81.29
  BOTTOM w0.102: 134.52,81.29 135.61,82.38 136.22,82.38 TP1806.1
CPU_DP1_CTRL_CLK: length 135.2
  TOP w0.14: v1(34.2,73.01) 34.2,73.01 33.39,73.01 32.57,73.83 30.45,73.83 29.96,74.32 29.76,74.52 25.75,74.52 25.38,74.52 25.27,74.41 23.11,72.25 22.23,72.25 v1(21.97,72.5) 21.46,72.5 21.08,72.88 v2(21.08,73.34) 21.08,73.77 21.79,74.48 v1(22.2,74.48)
  L4 w0.127: v1(34.2,73.01) 34.32,72.9 34.32,72.38 34.62,72.07 36.42,72.07 36.98,72.63 36.98,73.59 42.63,79.23 51.22,79.23 52.11,78.34 53.71,78.34 56.51,81.14 59.29,81.14 59.49,81.14 60.94,82.59 67.71,82.59 68.86,81.44 84.14,81.44 88.28,85.58 94.35,85.58 95.81,87.05 97.54,88.77 97.54,89.3 97.89,89.65 98.28,89.65 102.6,93.97 106.21,93.97 106.62,93.56 106.62,91.23 106.24,90.85 106.24,89.38 106.96,88.66 107.98,88.66 109.35,90.03 112.65,90.03 113.22,89.46 113.92,88.76 115.32,88.76 116.46,87.62 117.35,87.62 119.15,85.82 120.42,85.82 121.16,85.08 121.16,81.98 122.2,80.93 124.62,80.93 124.72,80.84 124.72,80.65 v1(124.34,80.27)
  BOTTOM w0.14: v1(124.34,80.27) 124.65,80.58 CPU1.L13 ; RN801.4 22.17,72.7 v1(21.97,72.5) ; Q5702.4 21.73,74.96 v1(22.2,74.48)
CPU_DP1_CTRL_DATA: length 137.9
  TOP w0.14: v1(18.43,73.66) 18.43,72.87 v2(18.9,72.4) 21.19,72.4 21.46,72.12 v1(21.46,71.87) 21.58,71.98 23.22,71.98 25.46,74.22 25.49,74.25 25.64,74.25 25.64,74.25 29.65,74.25 30.02,73.88 30.34,73.56 32.46,73.56 33.28,72.74 33.83,72.74 34.01,72.56 34.5,72.56 v1(34.82,72.88)
  L4 w0.127: v1(34.82,72.88) 34.56,72.62 34.56,72.48 34.72,72.31 36.32,72.31 36.74,72.73 36.74,73.69 42.53,79.48 51.32,79.48 52.21,78.58 53.61,78.58 56.41,81.38 59.39,81.38 60.84,82.83 67.81,82.83 68.96,81.68 84.04,81.68 88.18,85.82 94.25,85.82 95.64,87.22 97.29,88.87 97.29,89.4 97.79,89.89 98.18,89.89 102.5,94.21 106.31,94.21 106.86,93.66 106.86,91.13 106.48,90.75 106.48,89.48 107.06,88.9 107.88,88.9 109.25,90.27 112.75,90.27 113.32,89.7 114.02,89 115.42,89 116.56,87.86 117.45,87.86 119.25,86.06 120.52,86.06 121.4,85.18 121.4,82.08 122.3,81.18 124.72,81.18 v1(125.63,80.26)
  BOTTOM w0.14: RN801.3 21.65,72.05 v1(21.46,71.87) ; Q5702.1 v1(18.43,73.66) ; CPU1.L12 125.3,80.59 v1(125.63,80.26)
CPU_DP1_HPD: length 250.9
  TOP w0.102: v1(34.86,73.59) 34.23,74.23 30.91,74.23 29.69,75.45 24.21,75.45 v2(23.62,76.03) 18.72,76.03 v1(18.31,75.63) ; v1(62.53,42.5) 62.28,42.25 62.28,41.67 62.69,41.26 62.99,41.26 63.75,40.5 109.14,40.5 116.1,47.46 116.76,47.46 119.63,44.59 151.49,44.59 158.18,37.89 161.39,37.89 161.86,38.36 v1(161.87,38.36)
  L3 w0.102: v1(161.87,38.36) 161.26,38.98 151.16,38.98 142.04,48.1 142.04,53.83 142.79,54.58 142.79,56.77 141.77,57.78 141.77,70.09 139.9,71.96 139.9,76.29 140.13,76.51 140.13,78.82 138.61,80.34 138.61,81.83 138.36,82.08 133.02,82.08 131.61,80.67 127.97,80.67 v1(127.57,80.27) ; v1(34.86,73.59) 34.17,73.59 33.77,73.19 33.77,72.22 36.91,69.08 36.91,63.71 37.82,62.8 37.86,62.8 39.85,60.8 39.85,54.19 41.68,52.36 48.11,52.36 48.52,51.95 50.62,51.95 51.69,50.89 54.26,50.89 56.62,48.52 59.13,48.52 61.52,46.14 61.52,46.14 61.82,45.83 61.82,45.04 62.12,44.75 62.12,43.66 62.53,43.24 v1(62.53,42.5)
  BOTTOM w0.102: R5719.1 18.31,75.89 v1(18.31,75.63) ; CPU1.L9 v1(127.57,80.27)
CPU_DP2_CTRL_CLK: length 13.4
  L3 w0.127: v1(137.54,80.12) 137.41,80.25 135.01,80.25 134.75,79.99 133.6,79.99 133.1,79.49 130.56,79.49 130.29,79.23 129.42,79.23 129.01,79.63 128.68,79.63 128.27,79.23 v1(128.19,79.23)
  BOTTOM w0.14: v2(136.63,79.89) 136.86,80.12 v1(137.54,80.12) 138.26,80.12 138.64,80.5 R803.2 ; CPU1.N7 128.36,79.39 v1(128.19,79.23)
CPU_DP2_CTRL_DATA: length 13.6
  TOP w0.14: v2(125.86,78.71) 126.39,78.71 126.85,79.17 v1(126.94,79.17)
  L3 w0.127: v1(136.41,80.75) 136.15,80.49 134.91,80.49 134.65,80.23 133.5,80.23 133,79.73 130.46,79.73 130.19,79.47 129.52,79.47 129.12,79.87 128.58,79.87 128.45,79.74 128.02,79.74 127.45,79.17 v1(126.94,79.17)
  BOTTOM w0.14: R804.2 136.42,80.76 v1(136.41,80.75) ; CPU1.N8 127.28,79.17 v1(126.94,79.17)
CPU_DP2_HPD: length 109.7
  TOP w0.102: R806.1 127.85,81.21 128.91,81.21 129.5,81.81 R805.2 129.68,81.81 130.45,82.59 v2(130.45,82.87) 130.05,83.27 130.05,83.82 130.46,84.23 130.46,84.25 130.64,84.42 130.64,88.08 131.23,88.67 131.23,88.92 132.04,89.74 v1(132.44,89.74)
  L4 w0.102: v1(194.18,46.59) 191.97,46.59 191.52,46.14 184.32,46.14 184.16,46.3 181.35,46.3 181.19,46.14 173.3,46.14 172.72,46.72 171.48,46.72 169.67,48.52 158.99,48.52 157.96,47.5 153.25,47.5 148.7,52.04 145.9,52.04 141.5,56.45 141.5,62.6 138.66,65.43 138.66,68.08 134.58,72.16 134.58,72.39 133.32,73.65 132.97,73.65 132.22,74.39 132.22,77.32 131.95,77.59 131.95,83.19 132.98,84.22 132.98,88.98 132.44,89.51 v1(132.44,89.74)
  BOTTOM w0.102: IOBD4.16 193.88,46.9 v1(194.18,46.59)
CPU_DP2_HPD1: length 2.4
  TOP w0.102: R805.1 129.37,80.92 129.26,80.81 v2(128.52,80.81) 128.5,80.81 128.24,80.55 v1(128.24,80.27)
  BOTTOM w0.102: v1(128.24,80.27) 128.27,80.27 128.56,80.56 CPU1.L7
CPU_POPIRCOMP: length 8
  TOP w0.203: RN401.4 118.54,71.36 119.89,71.36 120.07,71.18 120.95,71.18 121.26,70.88 v2(122.76,70.88) 122.86,70.77 122.86,70.31 122.86,70.31 122.86,68.66 v1(122.4,68.2)
  BOTTOM w0.254: CPU1.AT16 122.53,68.2 v1(122.4,68.2)
CPVDD: length 8.1
  TOP w0.203: v1(26.67,8.49) 26.37,8.8 HDA27.36
  TOP w0.305: R2726.2 28.77,5.07 C2714.1 27.73,5.01 C2701.1 26.83,4.97 v1(26.8,4.94) 26.62,4.94 v2(26.19,5.37)
  L3 w0.305: v1(26.8,4.94) 26.67,5.07 v1(26.67,8.49)
CPVEE: length 3.1
  TOP w0.203: HDA27.34 25.33,7.93 v1(25.53,7.73)
  BOTTOM w0.305: v1(25.53,7.73) 25.53,8.37 v2(25.27,8.62) 25.27,9.45 C2704.2
CSA0#_0: length 50.5
  TOP w0.127: VRAM1.L2 166.98,109.64 166.28,109.64 166.13,109.5 164.22,109.5 v1(164.06,109.66)
  L4 w0.152: v1(164.06,109.66) 162.78,110.94 161.94,110.94 161.72,110.73 161.16,110.73 160.53,110.09 159.15,110.09 159,110.25 158.51,110.25 155.75,107.48 155.75,93.92 161.62,88.05 166.67,88.05 167.77,89.14 168.52,89.14 168.64,89.27 170.68,89.27 171.45,88.5 171.45,87.91 v1(172.19,87.17)
  BOTTOM w0.127: VRAM2.L2 162.88,109.66 v1(164.06,109.66)
  BOTTOM w0.14: v1(172.19,87.17) 172.29,87.17 GPU1.H22
CSA1#_0: length 51.1
  TOP w0.127: v1(188.17,110.17) 188.68,109.66 189.46,109.66 VRAM4.L2
  L4 w0.089: v1(180.56,88.03) 180.56,88.03 180.59,88 180.7,88 181.34,87.36 182.51,87.36 182.75,87.61 183.14,87.61 183.15,87.6 183.59,87.6
  L4 w0.152: v1(188.17,110.17) 190.21,112.22 192.44,112.22 193.31,111.35 193.31,109.57 193.6,109.28 193.6,109.27 193.87,109 193.88,109 197.48,105.4 197.48,95.48 190.09,88.09 186.02,88.09 185.34,87.41 184.66,87.41 184.46,87.6 183.59,87.6
  BOTTOM w0.127: VRAM3.L2 185.36,109.64 185.96,109.64 186.06,109.54 187.43,109.54 188.06,110.17 v1(188.17,110.17)
  BOTTOM w0.14: GPU1.G13 180.06,88.4 180.39,88.07 180.46,88.07 180.49,88.05 180.52,88.05 180.53,88.03 v1(180.56,88.03)
CSI2_COMP: length 2.7
  TOP w0.508: R1501.1 126.33,85.3 v2(125.42,85.3) 125.42,84.59 v1(125.43,84.57)
  BOTTOM w0.305: v1(125.43,84.57) 124.84,83.99 CPU1.E13
DAT_ITE8010: length 11.4
  TOP w0.14: R2471.2 68.72,72.43 68.72,73.16 ; 68.72,73.16 68.72,73.68 68.39,74.01 68.39,77.93 69.05,78.59 70.57,78.59 70.79,78.37 v1(70.79,78.22) 70.79,78.17 71.42,77.54 U9601.20 ; 68.72,73.16 v2(68.94,73.16)
  BOTTOM w0.14: R9603.2 70.68,78.79 70.74,78.73 70.74,78.27 v1(70.79,78.22)
DAT_TP_SIO: length 98.6
  TOP w0.14: RN6503.2 135.31,3.85 135.12,4.04 134.68,4.04 EC6501.1 134.05,4.04 133.42,4.04 v1(133.14,3.76) ; KBC24.79 202.16,29.54 202.23,29.61 202.86,29.61 203.26,30 203.67,30 v1(203.89,29.79)
  L4 w0.127: v1(133.14,3.76) 133.36,3.99 135.57,3.99 136.27,4.68 139.47,4.68 142.89,8.1 187.78,8.1 192.63,12.95 192.63,15.43 194.76,17.56 198.51,17.56 199.2,16.86 200.8,16.86 201.38,17.44 v1(201.38,17.97)
  L6 w0.114: v1(201.38,17.97) 201.38,21.64 201.26,21.76 201.26,24.13 201.65,24.53 201.65,27.11 201.2,27.56 201.2,27.96 202.46,29.21 202.46,29.28 202.71,29.53 202.77,29.53 203.34,30.1 203.58,30.1 v1(203.89,29.79)
  BOTTOM w0.14: RN6504.3 133.23,3.85 v1(133.14,3.76) 132.72,4.18 v2(132.59,4.18)
DBC_EN_R: length 8.8
  BOTTOM w0.102: LCD1.8 56.15,76.42 55.27,77.3 55.27,81.04 55.7,81.47 56.49,81.47 v2(56.87,81.85) 56.77,81.95 R5518.1
DBC_PANEL_EN: length 137.1
  TOP w0.102: v1(135.76,58.61) 135.76,58.33 135.79,58.3 135.79,54.32 v2(135.64,54.16) 135.64,54.14 135.79,53.99 135.79,52.5 136.77,51.51 136.78,51.51 136.91,51.38 RN2001.2
  L4 w0.102: v1(57.45,84.44) 58.32,85.3 58.32,86.34 58.56,86.59 60.63,86.59 61.56,85.66 63.17,85.66 64.07,84.76 68.66,84.76 68.78,84.64 70,83.42 81.5,83.42 87.05,88.97 89.8,88.97 90.97,90.14 95.85,90.14 101.69,95.98 106.89,95.98 110.44,92.43 117.79,92.43 118.89,93.53 124.62,93.53 125.23,92.92 126.5,92.92 128.22,91.2 129.38,91.2 130.43,90.16 130.43,88.67 130.94,88.15 130.94,83.06 128.66,80.78 128.66,80.11 128.39,79.83 125.44,79.83 123.88,78.27 123.88,75.02 125.41,73.48 125.55,73.48 127.19,71.84 127.19,71.69 127.52,71.36 127.95,71.36 129.75,69.56 v1(129.75,69.42)
  L6 w0.102: v1(129.75,69.42) 131.93,67.24 132.87,67.24 133.22,66.89 133.22,66.04 135.31,63.96 135.31,59.75 135.76,59.3 v1(135.76,58.61)
  BOTTOM w0.102: R5518.2 56.77,84.06 57.15,84.44 v1(57.45,84.44) ; v1(129.75,69.42) 129.67,69.5 129.67,70.06 CPU1.AM5
DC_IN_D: length 3.2
  TOP w0.254: v2(72.21,107.86) PR4405.2 72.54,108.98 73.05,109.48 PQ4402.3
DCBATOUT: length 60.1
  TOP w0.127: v1(90.7,106.36) 90.68,106.33 R6220.1
  TOP w0.203: v1(49.5,43.7) 49.61,43.7 50.06,43.24 PU4501.12
  TOP w0.305: EC9707.1 70.93,125.52 v3(71.5,126.1) ; PC4518.1 48.79,44.41 v1(49.5,43.7)
  TOP w0.508: v1(225.93,9.64) 226.87,8.7 228.89,8.7 FC9737.1 PR4458.1 ; R6103.1 v1(46.82,60.98)
  L3 w0.254: v3(144.91,125.99) 143.64,124.72 143.64,109.84 143.13,109.33 142.37,109.33 141.6,108.57 v1(141.6,108.44)
  L6 w0.127: v1(90.7,106.36) 90.63,106.28 87.25,106.28 86.36,107.17 84.07,107.17 83.31,106.41 82.8,106.41 81.41,107.81 78.23,107.81 76.96,106.54 72.77,106.54
  BOTTOM w0.254: v1(141.6,108.44) 141.6,109.22 PR4601.1
  BOTTOM w0.508: v1(225.93,9.64) 226.16,9.87 226.16,13.44 226.11,13.49 226.11,15.05 v3(224.31,16.85)
  vias: v2(46.24,45.92) v2(47.51,39.77) v2(47.66,46.97) v2(54.47,68.32) v2(55.31,78.77) v2(56.01,72.12) v2(71.93,82.87) v2(72.26,102.22) v2(116.23,126.32) v2(140.86,126.41) v2(204.56,106.24) v2(205.42,119.33) v2(218.57,49.01) v2(221.62,39.1) v3(44.07,42.4) v3(44.07,41.39) v3(44.99,43.28) v3(44.96,42.4) v3(44.96,41.39) v3(45.82,43.8) v3(45.85,42.91) v3(45.82,41.97) v3(47.9,37.88) v3(47.98,36.84) v3(48.79,38.57) v3(48.79,37.48) v3(54.1,72.32) v3(54.36,64.25) v3(54.48,65.16) v3(54.71,72.98) v3(55.24,64.55) v3(55.88,65.16) v3(55.93,63.99) v3(67.18,101.97) v3(68.07,101.97) v3(68.96,101.97) v3(69.85,101.97) v3(70.61,123.81) v3(70.74,101.97) v3(71.5,127.11) v3(71.5,124.32) v3(71.5,123.3) v3(106.3,125.72) v3(106.3,124.7) v3(107.31,125.72) v3(107.31,124.7) v3(107.82,126.48) v3(108.33,125.72) v3(108.33,124.7) v3(109.22,125.72) v3(118.11,126.86) v3(119.13,126.86) v3(120.14,126.86) v3(121.16,126.86) v3(122.17,126.86) v3(123.19,126.86) v3(145.8,125.97) v3(146.69,125.97) v3(153.29,124.57) v3(154.31,126.1) v3(154.31,125.21) v3(154.31,124.19) v3(203.61,73.16) v3(203.6,72.32) v3(203.63,71.49) v3(204.37,72.78) v3(204.37,71.94) v3(208.71,120.64) v3(209.3,98.28) v3(209.3,97.27) v3(209.4,119.9) v3(209.55,120.89) v3(210.44,98.28) v3(210.44,97.27) v3(210.46,120.91) v3(210.49,120.05) v3(211.58,98.28) v3(211.58,97.27) v3(212.72,98.28) v3(212.72,97.27) v3(215.73,71.08) v3(216.33,70.39) v3(216.79,71.18) v3(217.04,53.45) v3(217.04,52.31) v3(218.19,53.45) v3(218.19,52.31) v3(219.13,36.36) v3(219.33,52.31) v3(219.35,37.25) v3(220.01,37.88) v3(220.24,36.99) v3(220.8,16.87) v3(220.95,37.91) v3(221.74,16.85) v3(222.63,16.85) v3(223.47,16.85)
DCBATOUT_+VCCSA:
  vias: v2(131.55,123.38)
DCBATOUT_CAMERA: length 5.6
  TOP w0.508: v2(70.9,88.53) 70.76,88.53 v1(70.35,88.94) 69.88,88.46 C5542.2 69.94,87.63 C5516.1 71.55,88.21 EC5505.1 72,88.38 R5501.1
DCBATOUT_LCD:
  vias: v2(60.07,77.33) v4(60.38,76.01) v4(60.9,75.49)
DCBATOUT_VCCGT:
  vias: v2(106.83,119.58) v3(109.21,121.36) v3(109.35,122.18) v3(109.35,117.71) v3(110.24,121.4) v3(110.24,117.71)
DCBATOUT_VCORE:
  vias: v2(123.23,122.83) v3(120.17,123.56) v3(121.01,123.56) v3(121.87,123.58) v3(121.97,122.75) v3(122.71,123.66) v3(123.7,123.81)
DDC_CLK_HDMI: length 18.3
  TOP w0.14: v1(15.35,75.02) 15.35,75.34 v2(15.06,75.63) 14.2,74.76 14.2,73.67 14.1,73.57 11.79,73.57 11.62,73.74 10.98,73.74 10.54,73.3 10.54,72.12 10.07,71.65 HDMI1.15
  BOTTOM w0.14: RN5702.1 23.62,75.17 23.4,75.39 22.71,75.39 22.55,75.55 20.78,75.55 20.18,74.96 Q5702.3 17.42,74.96 ED5703.7 ED5703.4 15.41,74.96 v1(15.35,75.02)
DDC_CLK_PH1: length 6.6
  BOTTOM w0.14: RN5702.4 23.62,76.28 24.31,76.97 24.31,79.03 24.64,79.36 25.1,79.36 D5701.2 26,80.26 v2(27.05,80.26)
DDC_DATA_HDMI: length 14.4
  TOP w0.14: HDMI1.16 12.45,73.3 14.16,73.3 v2(15.04,72.42) 15.42,72.81 v1(15.42,72.83)
  BOTTOM w0.14: RN5702.2 22.97,74.13 22.48,73.65 21.24,73.65 Q5702.6 21.23,73.29 20.95,73.01 17.86,73.01 ED5703.10 ED5703.1 16.04,73.46 v1(15.42,72.83)
DDC_DATA_PH2: length 4.7
  BOTTOM w0.14: D5701.1 23.92,80.12 v2(23.92,77.12) 23.71,76.91 23.51,76.91 22.97,76.36 RN5702.3
DDPD_CTRLDATA: length 1.4
  TOP w0.102: v1(125,80.27) 125.54,80.81 TP802.1
  BOTTOM w0.102: v1(125,80.27) 125.3,79.96 CPU1.N12
DDR4_DRAMRST#: length 233.1
  TOP w0.127: v1(69.34,8.49) 70.26,8.49 v2(71.24,9.47) 71.57,9.81 ED1302.1 ; v1(146.3,54.95) 146.38,54.95 147.19,55.76 R504.2 ; v1(148.21,10.17) 148.02,10.36 ED1217.1
  L3 w0.127: v1(148.21,10.17) 148.65,10.61 186.77,10.61 188.38,12.23 v1(192.61,12.23) ; v1(194.21,38.97) 194.11,38.97 193.47,39.61 189.48,39.61 187.9,41.2 186.27,41.2 184.93,39.85 184.37,39.85 183.79,39.27 183.43,39.27 182.58,39.27 182.12,38.81 181.76,38.81 181.5,39.07 181.13,39.07 180.91,38.85 165.49,38.85 164.34,39.99 151.42,39.99 144.77,46.64 144.77,49.45 145.1,49.78 145.1,51.94 145.68,52.52 145.68,54.33 v1(146.3,54.95)
  L4 w0.127: v1(69.34,8.49) 72.36,8.49 72.51,8.34 75.95,8.34 76.6,7.69 85.92,7.69 86.07,7.54 89.67,7.54 90.42,8.29 91.47,8.29 93.51,10.34 109.49,10.34 110.63,9.19 112.22,9.19 112.48,8.94 115.21,8.94 115.54,9.27 117.54,9.27 118.3,10.03 119.22,10.03 119.36,9.89 122.96,9.89 123.56,10.49 128.34,10.49 128.66,10.17 v1(148.21,10.17)
  L6 w0.127: v1(192.61,12.23) 192.75,12.23 194.97,14.44 194.97,15.4 195.19,15.61 195.19,17.7 196.56,19.07 196.56,23.9 195.19,25.27 195.19,27.61 195.75,28.17 195.75,31.5 196.79,32.54 196.79,33.24 195.94,34.09 195.94,37.24 v1(194.21,38.97)
  BOTTOM w0.127: v1(69.34,8.49) 71.53,10.68 71.53,11.35 DM1.108 ; v1(148.21,10.17) 148.47,10.44 DM2.108
DDR_VREF_S3: length 3.1
  TOP w0.254: PC5123.1 60.33,48.63 v2(60.58,48.37) 61.39,48.37 61.83,48.81 PU5102.6
DGPU_HOLD_RST#: length 24
  BOTTOM w0.089: CPU1.P3 130.87,79.23 131.27,78.82 131.71,78.82 131.8,78.79 131.8,78.78 132.84,78.78 132.86,78.8 133.18,78.8 133.38,78.6 134.62,78.6
  BOTTOM w0.127: 134.62,78.6 134.65,78.6 135.14,79.08 137.19,79.08 137.41,79.3 RN2009.4 138.39,79.48 138.53,79.48 138.82,79.77 140.45,79.77 140.49,79.74 EC2002.1 142.18,78.73 v2(145.19,78.73) 145.8,78.73 146.36,79.29 D7601.2 147.46,79.29 148.26,78.5 148.26,77.91 148.37,77.8 148.96,77.8 150.51,76.25 R7623.1
DGPU_PWR_EN: length 95.4
  TOP w0.127: v1(176.47,60.54) 176.97,60.03 178.52,60.03 178.76,60.28 v1(180.92,60.28) 181.33,59.87 190.18,59.87 193.12,56.93 199.21,56.93 200.08,57.8 201.13,57.8 201.86,57.06 201.86,56.85 203.37,55.34 204.02,55.34 204.28,55.08 204.28,55.01 PD8501.K
  L4 w0.127: v1(180.92,60.28) 180.92,60.7 181.21,60.99 181.21,61.36 179.53,63.04 179.53,64.62 177.26,66.89 173.38,66.89 169.81,70.46 167.48,70.46 166.5,71.44 166.5,72.5 164.72,74.28 164.72,74.88 161.6,78 154.5,78 v1(151.87,75.37)
  BOTTOM w0.089: 134.86,77.77 134.15,77.77 134.03,77.65 132.7,77.65 132.63,77.72 132.61,77.74 132.1,77.74 CPU1.U1
  BOTTOM w0.127: v1(151.87,75.37) 151.69,75.55 151.05,75.55 150.94,75.44 150.41,75.44 149.05,76.79 146.3,76.79 144.91,78.18 v2(141.45,78.18) 139.1,78.18 138.63,78.65 RN2009.3 137.22,78.65 136.44,77.87 134.97,77.87 134.86,77.77 ; v1(176.47,60.54) 176.71,60.78 PR8661.1
DGPU_PWR_EN_R: length 6.2
  BOTTOM w0.127: v2(175.77,61.61) 175.9,61.61 176.59,62.3 PR8661.2 176.77,62.3 PC8602.1 177.88,63.59 178.31,64.02 178.99,64.02 179.03,63.98 179.46,63.98 179.96,63.49 PQ8604.2
DGPU_PWROK: length 150.1
  TOP w0.127: v1(204.39,46.42) 204.39,48.58 201.41,51.56 201.41,55.39 201.67,55.65 202.15,55.65 v1(202.77,55.03) ; R7904.1 173.19,66.3 173.19,66.31 172.17,67.33 168.69,67.33 168.53,67.17 v1(168.45,67.17)
  L3 w0.127: v1(129.51,90.46) 131.45,90.46 132.25,91.26 132.41,91.26 133.71,92.56 133.71,93.28 134.32,93.9 135.23,93.9 136.64,95.3 136.83,95.43 146.01,95.43 152.28,89.16 153.03,89.16 153.19,89.01 154.24,89.01 154.95,88.29 154.95,87.13 155.66,86.43 157.59,86.43 162.24,81.78 162.24,77.26 161.15,76.17 161.15,75.07 162.36,73.86 164.21,73.86 166.91,71.16 166.91,71.03 168.45,69.48 v1(168.45,67.17)
  L4 w0.127: v1(168.45,67.17) 168.92,67.17 171.88,64.21 172.24,64.21 173.23,65.2 176.38,65.2 176.64,64.94 176.64,63.75 179.83,60.56 179.83,58.54 181.24,57.14 184.56,57.14 184.75,57.33 185.93,57.33 186.59,57.99 194.48,57.99 195.28,57.19 197.55,57.19 199.98,54.76 202.5,54.76 v1(202.77,55.03)
  L6 w0.127: v1(210.82,35.49) 210.82,35.51 210.52,35.82 210.52,36.29 209.23,37.57 209.23,41.72 209.25,41.74 204.58,46.42 v1(204.39,46.42)
  BOTTOM w0.127: PR8520.2 206.69,53.77 v2(206.12,53.2) 204.6,53.2 v1(202.77,55.03) ; EC2401.1 R2427.1 210.85,35.16 210.82,35.19 v1(210.82,35.49) ; EC1903.1 R1904.2 129.44,90.76 129.51,90.69 v1(129.51,90.46) 129.51,90.05 128.94,89.48 128.94,87.77 128.07,86.9 128.07,85.96 CPU1.C8
DGPU_PWROK_KBC: length 7
  TOP w0.127: v1(212.34,32.88) 212.83,32.88 213.76,31.94 KBC24.24
  BOTTOM w0.127: R2427.2 210.85,33.36 211.33,32.88 v2(211.47,32.88) v1(212.34,32.88)
DGPU_PWROK_R: length 3.7
  TOP w0.127: Q7903.G 173.3,68.01 173.3,66.91 173.43,66.79 v2(173.43,66.76) 173.51,66.76 174.36,65.91 R7904.2 R7942.2
DMIC_CLK: length 82.1
  TOP w0.14: v1(48.03,67.35) 47.75,67.64 47.75,68.74 46.87,69.62 46.87,70.67 ; RN5504.4 47.06,71.67 46.87,71.48 46.87,70.67 ; R2716.1 26.73,19.04 EC2723.2 FC2701.1 27.11,20.43 27.18,20.43 v1(27.3,20.56) ; v2(47.02,70.67) 46.87,70.67
  L6 w0.114: v1(48.03,67.35) 47.73,67.05 47.73,64.09 46.21,62.58 36.7,62.58 35.9,61.78 35.9,57.06 34.94,56.1 34.94,56.1 33.99,55.16 31.19,52.35 27.65,52.35 27.27,51.97 22.82,51.97 22.57,51.71 22.57,49.68 17.7,44.81 17.7,41.74 21.17,38.26 21.17,37.59 22.2,36.57 22.52,36.24 22.52,30.98 24.85,28.65 24.85,26.69 26.71,24.84 26.71,23.36 27.01,23.06 27.01,20.85 v1(27.3,20.56)
DMIC_CLK_EDP: length 6.5
  TOP w0.14: v2(47.19,76.01) 46.99,76.01 ; 46.99,76.01 46.99,75.11 EC5501.1 47.31,74.76 46.93,74.38 46.93,74.11 47.06,73.98 RN5504.1 ; 46.99,76.01 46.99,76.18 46.65,76.52 46.65,76.86 v1(46.99,77.2)
  BOTTOM w0.14: v1(46.99,77.2) 46.65,76.86 LCD1.27
DMIC_CLK_R: length 2.9
  TOP w0.14: R2716.2 26.03,17.2 26.03,16.04 25.68,15.7 25.62,15.7 25.33,15.41 HDA27.3
