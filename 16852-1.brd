# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCCAPLLEBB_1P0: length 5.3
  TOP w0.305: v2(119.79,78.8) 120.15,79.17 C1173.1 ; C1180.1 121.51,79.25 122.18,79.92 v1(122.18,80)
  TOP w0.508: C1180.1 C1173.1 120.69,80.14 120.88,80.33 R1101.2
  BOTTOM w0.305: CPU1.N18 122.18,79.92 v1(122.18,80)
+VCCCLK2: length 30.2
  TOP w0.508: C2113.1 116.79,82.33 v2(117.65,82.33) 117.65,81.58 v1(117.79,81.45)
  L3 w0.508: v4(134.32,86.17) 133.34,87.15 131.96,87.15 131.58,87.53 128.18,87.53 127.58,86.92 126.49,86.92 126.37,86.8 122.88,86.8 121.08,85 120.16,85 119,83.84 119,82.51 117.94,81.45 v1(117.79,81.45)
  BOTTOM w0.254: CPU1.K19 121.16,81.28 120.79,81.65 119.62,81.65 119.36,81.38 117.85,81.38 117.78,81.45 v1(117.79,81.45)
  BOTTOM w0.508: v4(134.32,86.17) 134.46,86.17 135,86.71 135.42,86.71 136.11,87.4 136.11,87.4 136.7,88 136.7,88 136.96,88.25 R2109.2
+VCCCLK4: length 28.5
  TOP w0.508: C2114.1 118.03,77.58 118.57,78.12 119.26,78.12 119.39,78.26 v1(119.42,78.26)
  L3 w0.254: v1(119.42,78.26) 119.42,78.29 120.6,79.46 120.6,80.36 121.91,81.67 121.91,84.05
  L3 w0.508: v4(134.42,84.67) 134.01,84.67 132.95,85.73 127.37,85.73 127.25,85.61 123.47,85.61 121.91,84.05
  BOTTOM w0.127: CPU1.N20 120.25,79.29 120.01,79.29 119.6,78.89 119.6,78.47 119.42,78.29 v1(119.42,78.26)
  BOTTOM w0.508: R2108.2 137.29,86.47 v2(136.5,85.68) 136.23,85.42 135.5,85.42 135.39,85.3 135.37,85.3 134.74,84.67 v4(134.42,84.67)
+VCCCLK5: length 31.2
  TOP w0.508: v1(119.39,79.25) 119.38,79.25 117.72,79.25 117.43,79.55
  L3 w0.254: v1(119.39,79.25) 119.39,79.27 119.66,79.54 119.66,80.77 121.56,82.68 121.56,83.73 121.44,83.85 121.44,84.44 121.7,84.7 121.7,84.71 122.07,85.08
  L3 w0.508: 122.07,85.08 123.19,86.2 127,86.2 127.13,86.33 133.2,86.33 133.98,85.54 134.73,85.54 v4(135,85.81)
  BOTTOM w0.127: CPU1.L19 120.9,80.13 120.35,80.13 120.12,79.9 119.78,79.9 119.6,79.73 119.6,79.51 119.39,79.29 v1(119.39,79.25)
  BOTTOM w0.508: v4(135,85.81) 135.27,86.08 135.72,86.08 137,87.36 139.42,87.36 R2107.2
  vias: v2(117.63,80.33)
+VCCDSW_1P0: length 4.2
  TOP w0.254: v1(133.25,69.86) 133.25,70.29 133.02,70.52 v2(132.95,70.52) 132.95,70.59 132.58,70.97 C2103.1
  BOTTOM w0.127: CPU1.AL1 132.5,70.61
  BOTTOM w0.254: 132.5,70.61 v1(133.25,69.86)
+VCCFUSEPRG: length 0.6
  BOTTOM w0.254: v1(120.59,83.01) 120.67,83.01 120.99,82.69 CPU1.G20
  vias: v2(121.31,83.76)
+VCCGT: length 6.5
  BOTTOM w0.203: CPU1.A66 v1(94.39,87.4) ; v1(96.89,87.43) 96.89,87.38 96.87,87.36 CPU1.A62 ; CPU1.A53 101.83,87.26 v1(101.79,87.3) ; CPU1.A48 104.31,86.79 104.14,86.95 v1(104.14,86.97) ; CPU1.A58 v1(99.35,87.4)
  BOTTOM w0.305: PL4801.2 113.59,105.03 PG4809.2
  vias: v1(90.1,80.52) v1(91.63,79.2) v1(91.63,77.37) v1(91.63,75.54) v1(92.28,79.2) v1(92.28,75.54) v1(92.93,79.2) v1(92.93,77.37) v1(93.58,77.37) v1(93.58,75.54) v1(94.23,79.2) v1(94.23,75.54) v1(94.89,79.21) v1(94.88,77.37) v1(95.54,79.2) v1(96.19,79.2) v1(98.35,77.81) v1(98.27,74) v1(98.93,77.25) v1(99.23,79.64) v1(99.46,80.86) v1(99.52,76.72) v1(99.62,79.03) v1(99.67,80.13) v1(100,72.29) v1(100.11,80.89) v1(100.07,79.6) v1(100.15,76.11) v1(100.44,80.14) v1(100.53,78.99) v1(100.53,78.19) v1(100.47,71.72) v1(100.82,80.89) v1(100.82,79.61) v1(100.79,75.47) v1(100.91,72.29) v1(101.17,80.14) v1(101.22,78.99) v1(101.24,78.22) v1(101.24,77.48) v1(101.37,72.78) v1(101.53,80.89) v1(101.55,79.61) v1(101.83,72.29) v1(102.28,72.78) v1(102.3,71.72) v1(102.49,93.2) v1(102.74,72.29) v1(103.12,93.33) v1(103.19,72.83) v1(103.5,91.81) v1(103.66,72.29) v1(103.76,81.23) v1(104.09,72.82) v1(104.13,71.72) v1(104.39,92.06) v1(104.45,81.23) v1(104.57,72.29) v1(105.05,72.82) v1(105.1,81.21) v1(105.49,72.29) v1(105.89,93.56) v1(105.87,91.6) v1(105.97,72.8) v1(105.96,71.72) v1(106.36,97.3) v1(106.4,72.29) v1(106.85,72.83) v1(107.31,72.29) v1(107.69,71.77) v1(107.8,72.77) v2(81.86,76.87) v2(96.97,86.15) v2(97.16,76.11) v2(109.33,101.39) v3(108.08,104.61) v3(108.81,103.62) v3(108.97,106.18) v3(108.99,105.34) v3(108.99,104.51) v3(109.12,107.58) v3(109.52,106.84) v3(109.7,103.26) v3(109.93,106.08) v3(109.88,105.24) v3(109.85,104.4) v3(110.01,107.6) v3(110.36,106.82) v3(110.72,104.3) v3(110.85,107.58) v3(110.77,105.98) v3(110.77,105.14) v3(110.77,103.46) v3(111.2,106.79) v3(111.68,107.73) v3(112.19,107)
+VCCIO: length 127.8
  TOP w0.508: v1(106.4,81.09) 105.4,82.09 R801.1
  L3 w0.152: 114.68,83.26 114.68,82.79 114.96,82.51 115.19,82.51 115.52,82.84 115.52,83.22 115.08,83.66 114.68,83.26
  L3 w0.305: 114.96,82.51 114.96,82.13 114.2,81.37 114.2,80.4 115.04,79.56 115.04,75.78 114.91,75.65 v1(114.91,72.6)
  L3 w0.457: v1(141.63,92.57) 141.63,92.04 148.49,85.18 148.88,85.18 150.22,83.85 150.22,83.12 149.89,82.79 149.89,82.28 151.76,80.4 151.76,77.59 154.94,74.42 154.94,70.98 155.57,70.34 155.57,66.83 157.14,65.26 v3(158.37,65.26)
  L3 w0.508: v4(130.55,94.35) 130.17,94.73 124.21,94.73 119.08,89.6 118.45,89.6 115.91,87.07 115.91,86.91 115.06,86.06 115.06,84.06 115.08,84.05 115.08,83.66
  L4 w0.254: v1(114.91,72.6) 115.47,73.16 115.47,79.41 114.2,80.68 114.2,82.26 114.6,82.66 114.6,83.44 114.63,83.47 114.63,83.87 115.19,84.43 115.19,85.96 115.95,86.73 115.95,87.23 114.94,88.25 113.67,88.25 112.46,89.46 109.47,89.46 108.18,88.16 106.47,88.16 105.28,86.98 105.28,84.57 105.66,84.19 105.66,81.82 v1(106.4,81.09)
  L6 w0.508: v4(130.55,94.35) 131.5,95.3 131.5,95.43 132.15,96.09 138.48,96.09 141.63,92.93 v1(141.63,92.57)
  BOTTOM w0.305: CPU1.AM42 108.54,70.16 v1(108.67,70.16) 108.7,70.19 CPU1.AL42
  BOTTOM w0.508: 166.09,63.64 166.43,63.29 C4007.1
  BOTTOM w0.635: v4(130.55,94.35) 130.55,94.68 130.71,94.84 R4048.1
  vias: v1(114.22,72.58) v1(114.81,71.96) v1(115.57,72.25) v2(162.51,66.28) v2(166.73,64.04) v3(159.13,64.63) v3(159.61,65.31)
+VCCMPHYGTAON_1P0_LS_SIP: length 6.7
  TOP w0.305: v1(123.49,79.19) 123.59,79.19 123.6,79.18 124.09,79.18 124.11,79.19 124.12,79.21 v1(124.22,79.21) 124.3,79.13 124.3,79.09 124.33,79.02 124.36,78.95 124.41,78.9 124.47,78.85 124.54,78.82 124.61,78.8 124.64,78.79 124.77,78.65 C1174.1
  TOP w0.508: R1102.1 146.89,84.19 147.57,84.19 147.79,83.96 147.79,83.44 v1(148.26,82.97) ; v1(123.49,79.19) 122.85,79.82 122.85,80.25 R1101.1
  vias: v1(150.5,82.54) v1(151.76,83.04) v1(151.76,82.41) v2(152.6,82.56)
+VCCPAZIO: length 1.8
  TOP w0.254: R2101.2 121.02,72.59 v1(120.91,72.48) 120.88,72.5 v2(120.35,72.5)
  BOTTOM w0.254: CPU1.AJ19 120.91,72.36 v1(120.91,72.48)
+VCCPDSW_3P3: length 42.2
  TOP w0.254: v1(131.79,63.59) 131.84,63.64 132.5,63.64 133.54,64.68 134.99,64.68 135.14,64.83 135.55,64.83 136.15,65.42 140.1,65.42 143.58,61.95 145.93,61.95 v2(146.02,61.86) 146.08,61.91 148.77,61.91 149.38,61.3 R1711.2 149.61,61.07 149.03,60.5 R1707.1
  L4 w0.254: v1(131.79,63.59) 130.94,64.45 130.94,66.3 129.62,67.63 129.62,68.58 129.29,68.91 129.29,69.01 129.01,69.29 128.97,69.29 128.46,69.8 128.46,70.47 127.98,70.95 127.21,70.95 125.77,72.4 124.19,72.4 124.11,72.48 v1(122.2,72.48)
  BOTTOM w0.152: CPU1.AJ17 122.83,72.38 122.83,73.02 123.23,73.41 123.29,73.41 123.48,73.6 123.48,73.86 123.09,74.25 123.03,74.25 122.71,74.57 CPU1.AD17
  BOTTOM w0.254: CPU1.AD17 122.41,74.57 122.37,74.61 121.98,74.61 121.94,74.57 CPU1.AD18 ; v1(122.2,72.48) 122.2,72.38 122.51,72.07 CPU1.AJ17
+VCCPRIM_CORE: length 0.6
  L4 w0.508: v1(117.31,76.12) v1(117.31,75.48)
  vias: v1(119.2,77.26) v1(119.58,73.3) v1(120.23,73.3) v1(140.84,73.52) v1(140.97,74.53) v1(148.13,84.57) v2(149.75,77.78) v3(148.72,84.08) v3(149.5,83.55)
+VCCPRTC_3P3: length 36.2
  TOP w0.254: v1(125.44,59.89) 125.76,59.89 126.44,59.21 126.44,56.85 126.98,56.32 126.98,53.87 C2117.1 C2118.1 C2119.1
  L4 w0.203: v1(120.57,70.11) 120.14,69.69 120.14,68.41
  L4 w0.254: v1(125.44,59.89) 124.97,59.89 124.64,60.22 124.2,60.22 123.23,61.19 123.23,63.31 120.63,65.91 120.63,67.93 120.14,68.41
  BOTTOM w0.203: CPU1.BB14 123.93,64.39 123.93,62.43
  BOTTOM w0.254: R2106.2 126.59,54.31 126.59,57.28 126.52,57.36 126.52,57.37 125.49,58.4 125.49,58.41 125.37,58.53 125.37,59.75 125.44,59.81 v1(125.44,59.89) 125.44,60.76 v2(125.37,60.82) 125.37,60.98 123.93,62.43 ; v1(120.57,70.11) 120.57,70.55 121.11,71.08 121.11,71.12 CPU1.AK19
+VCCSA: length 10.1
  TOP w0.508: PC1048.1 PC1068.1 115.85,72.91 v1(116.31,72.45)
  L4 w0.508: 116.4,72.97 116.4,72.54 v1(116.31,72.45)
  L4 w1.016: 116.4,80.31 116.4,72.97
  vias: v1(114.96,81.04) v1(115.62,81.02) v1(116.02,83.02) v1(116.93,83.02) v2(136.6,106.89) v3(134.44,104.13) v3(134.42,103.24) v3(135.46,104.15) v3(135.46,103.24) v3(136.53,103.26) v3(136.55,104.2)
+VCCSRAM_1P0: length 7.8
  TOP w0.305: v2(143.51,81.19) 143.13,81.57 142.16,81.57 v3(142.11,81.52)
  BOTTOM w0.203: v1(120.23,74.13) 120.23,74.12 120.56,73.79 CPU1.AF20
  BOTTOM w0.254: v1(120.23,74.13) 120.22,74.13 119.91,73.82 CPU1.AF21
  BOTTOM w0.635: R1106.2 145.19,81.27 C1176.1 144.61,81.84 C1175.1 142.43,81.84 v3(142.11,81.52)
  vias: v1(120.89,77.48)
+VCCST_CPU: length 225.7
  TOP w0.254: R421.2 R409.2 R408.2 R416.2 81.23,102.41 81.14,102.5 80.15,102.5 80.06,102.41 R417.2 79.34,102.95 79.34,103.12 79.31,103.15 R422.2 ; R421.2 R423.2 ; R421.2 84.85,101.52 85.09,101.28 v1(85.09,101.08) ; v1(151.51,102.47) 151.51,101.92 v2(151.46,101.86) 151.46,101.83 148.96,99.33 130.08,99.33 v1(129.29,98.54) ; v1(61.11,101.2) 60.68,100.77 R9906.1 ; v1(150.97,123.22) 150.97,122.86 150.46,122.35 PR4622.1 PR4624.1 ; v1(126.49,96) 126.49,95.84 122.94,92.29 122.94,89.98 122.35,89.39 122.35,89.39 121.18,88.22 121.18,87.85 121.31,87.72 121.75,87.72 v1(121.95,87.92)
  L3 w0.254: v1(76.71,107.17) 77.22,106.67 77.22,101.88 80.43,98.66 82.17,98.66 82.55,99.05 82.55,99.51 84.12,101.08 v1(85.09,101.08) ; v1(91.69,95.46) 92.68,96.45 92.68,98.64 v1(92.64,98.68) 93.07,99.11 93.07,103.01 91.59,104.48 91.59,105.42 92.15,105.98 92.15,107.53 91.57,108.11 91.57,111.2 99.57,119.2 99.57,120.39 99.99,120.81 106.24,120.81 110.47,125.03 112.95,125.03 v1(113.49,124.49) ; v1(61.95,105.04) 61.47,104.56 61.47,101.56 v1(61.11,101.2)
  L4 w0.254: v1(151.51,102.47) 151.51,108.77 152.53,109.79 152.53,111.49 155.47,114.44 155.47,118.96 151.22,123.22 v1(150.97,123.22)
  L6 w0.254: v1(150.97,123.22) 149.18,123.22 148.08,124.32 145.41,124.32 141.99,127.75 116.76,127.75 v1(113.49,124.49)
  BOTTOM w0.203: v1(121.95,87.92) 121.65,87.62 CPU1.A18
  BOTTOM w0.254: PR4623.1 150.14,122.37 PR4621.1 150.24,122.37 150.48,122.37 150.97,122.86 v1(150.97,123.22) 150.89,123.14 PC4610.1 ; R419.1 92.7,93.97 R723.1 94.46,93.68 94.46,93.4 94.58,93.27 R727.1 ; R419.1 92.68,92.97 92.77,92.89 92.77,91.07 R603.2 93.9,90.75 R726.1 ; R419.1 92.32,93.98 91.69,94.6 v1(91.69,95.46) ; v1(61.95,105.04) 62.56,105.65 66.96,105.65 67.21,105.9 74.04,105.9 75.31,107.17 v1(76.71,107.17) ; v1(92.64,98.68) 92.56,98.61 88.12,98.61 85.75,100.98 85.39,100.98 85.29,101.08 v1(85.09,101.08) ; v1(126.49,96) 126.49,95.62 127.25,94.85 C716.1 R4045.2 127.44,96.95 128.02,97.52 R4036.2 128.46,97.89 129.11,98.54 v1(129.29,98.54)
+VCCSTG: length 217.8
  TOP w0.254: v1(149.58,127.75) 148.08,126.25 v1(148.08,125.08) 148.08,124.83 147.57,124.32 PR4669.1 ; R703.2 119.15,87.2 v1(119.02,87.33) 120.05,87.33 120.71,87.98 120.71,88.42 122.43,90.14 122.43,92.5 125.86,95.93 125.86,96.26 126.3,96.71 127.92,96.71 v1(128.02,96.61) 128.02,97.99 129.74,99.71 148.62,99.71 v1(150.88,101.97)
  L3 w0.254: v1(81.92,99.17) 80.46,99.17 77.93,101.7 77.93,104.46 79.25,105.78 79.25,109.26 78.16,110.35 78.16,116.86 76.98,118.05 70.69,118.05 69.48,119.26 65.88,119.26 v1(65.26,119.88)
  L4 w0.254: v1(150.88,101.97) 150.88,108.68 152.02,109.82 152.02,111.52 154.18,113.68 154.18,118.48 151.76,120.89 151.76,121.84 151.25,122.35 150.81,122.35 v1(148.08,125.08) ; v1(149.58,127.75) 149.08,128.24 133.68,128.24 133.38,127.95 90.86,127.95 90.82,127.91 69.51,127.91 65.26,123.66 v1(65.26,119.88)
  BOTTOM w0.254: v1(81.92,99.17) 82.88,98.21 82.94,98.21 83.2,97.95 85.27,95.88 85.27,95.88 86.04,95.11 86.64,95.11 86.79,95.26 87.43,95.26 87.99,94.7 v2(87.99,93.1) 87.95,93.06 R401.1 88.01,91.62 C717.1 88.84,91.55 R1722.1 ; R2440.1 129.39,96.59 R4048.2 129.13,95.74 R4045.1 128.33,96.29 v1(128.02,96.61) ; v1(119.02,87.33) 119.13,87.22 119.13,87.09 119.13,87.08 119.13,86.58 119.17,86.47 CPU1.A22
+VDDQ_CPU_CLK: length 17.3
  TOP w0.254: R705.2 103.71,66.38 103.25,65.92 103.25,65.95 102.29,66.91 v2(102.29,67.45) 102.29,68.59 101.37,69.5 v1(101.37,70.14) 101.89,70.66 C722.1
  L6 w0.254: v1(109.6,70.17) 108.96,70.8 102.03,70.8 v1(101.37,70.14)
  BOTTOM w0.254: v1(109.6,70.17) 109.31,70.45 CPU1.AM40
AV1_TP: length 1.4
  TOP w0.102: TP2307.1 132.55,66.66 132.58,66.63 v1(132.61,66.63)
  BOTTOM w0.102: CPU1.AV1 132.45,66.57 132.51,66.63 v1(132.61,66.63)
AV71_TP: length 6.6
  BOTTOM w0.102: TP2304.1 86.88,64.49 88.07,64.49 89.07,65.48 89.07,65.88 89.44,66.25 90.86,66.25 91.1,66.5 CPU1.AV71
DVSS: length 5.3
  TOP w0.102: HDA27.4 24.93,15.64 25.46,16.18 25.46,16.15 v1(25.49,16.15)
  BOTTOM w0.102: R2721.1 28.92,16.46 28.73,16.47 v2(28.04,16.47) 27.71,16.14 25.5,16.14 v1(25.49,16.15)
GND: length 2735.9
  TOP w0.203: U4001.11 v1(54.71,54.16) ; KBC24.17 215.59,29.14 215.39,28.94 v1(215.14,28.94) ; KBC24.84 200.38,27.54 200.3,27.47 199.6,27.47 199.19,27.87 199.19,28.24 v1(199.13,28.29) ; KBC24.124 v1(213.51,22.44) ; PWR1.4 268.25,35.9 268.5,36.15 268.76,36.15 ; KBC24.100 v1(203.92,22.46) ; XDP1.59 56,94.87 56.68,94.18 56.68,93.05 56.1,92.47 v1(56.06,92.47) ; KBC24.64 v1(202.06,36.69) ; v1(207.39,38.21) 207.92,37.69 KBC24.51 ; PU5301.4 47,28.7 v1(47.12,28.81) ; PU4401.22 231.14,18.55 231.39,18.81 v1(231.39,18.91)
  TOP w0.254: v1(62.23,67.71) PU5101.18 64.86,67.71 v1(65.02,67.55) ; v1(62.23,67.71) 61.78,68.16 PU5101.7 60.05,68.16 v1(59.82,67.93) 60.03,67.71 PU5101.8 v1(62.23,67.71) ; 205.86,43.5 205.94,43.5 206.53,44.08 206.53,45.03 207.05,45.55 C7002.2 ; v1(62.83,52.36) 62.33,52.86 PU5102.4
  TOP w0.305: VRAM4.J8 v1(185.42,108.1) ; U5601.3 v1(263.14,34.07) ; VRAM1.D8 v1(162.12,104.1) VRAM1.E8 ; VRAM4.T1 v1(191.21,113.3) ; U9104.9 251.88,31.68 v1(252.3,31.68) ; C8008.2 177.36,72.87 177.04,73.19 v1(176.94,73.19) ; v1(110.21,4.4) 110.21,5.04 C6703.2 109.77,5.48 U6701.8 ; v1(168.76,102.08) 168.74,102.1 VRAM1.B1 ; 83.44,10.91 83.44,10.96 83.69,11.22 RN1201.2 ; XDP1.37 61.5,95.21 61.3,95.02 v1(61.3,94.98) ; RN401.2 117.64,70.35 117.64,69.75 v1(117.88,69.5) ; VRAM4.E2 v1(190.22,104.9) ; XDP1.2 70.5,90.04 71.12,89.42 v1(71.12,89.14) ; C3120.2 51.75,92.32 52.1,91.97 52.1,90.69 v1(52.07,90.66) ; v1(152.93,48.42) 153.52,48.42 154,47.94 U4101.1 ; XDP1.26 64.5,92.19 63.83,92.85 63.8,92.85 63.52,93.13 63,93.13 v1(62.97,93.1) 62.97,92.16 63,92.13 XDP1.32 ; PR4510.2 55.08,38.15 v1(54.61,37.68) ; 105.83,82.89 105.83,83.61 105.35,84.09 105.35,84.31 ; C1218.2 96.32,17.58 96.85,17.05 v1(97.21,17.05) ; v1(73.05,78.47) 73.03,78.45 73.03,78.22 72.92,78.11 U9601.17 ; v1(90.12,82.48) 90.12,83.18 C1150.2 89.35,83.95 89.35,84.85 89.14,85.07 88.49,85.07 RN402.1 ; v1(63.96,98.38) 64.14,98.38 64.5,98.03 XDP1.25 ; v1(119.02,85.25) 119.02,85.07 119.05,85.03 119.05,83.85 119,83.79 R734.2 ; v1(42.17,25.39) 42.8,25.39 43.03,25.62 PU5301.19 ; v1(247.4,31.74) 247.68,31.46 247.71,31.46 U9104.16 ; XDP1.19 v1(66,95.09) ; U6701.7 109.09,4.4 v1(109.58,4.4) ; v1(252.15,25.03) 251.82,25.03 251.43,25.41 U9104.32 ; U6701.6 108.02,4.38 v1(107.82,4.18) 107.52,4.48 U6701.5 ; C1174.2 124.84,77.76 124.37,77.3 124.37,76.89 124.66,76.6 124.67,76.6 124.83,76.43 124.83,76.24 v1(125.02,76.06) 125.22,75.85 R1901.2 ; VRAM4.D1 191.14,103.7 v1(191.59,104.14) 191.3,104.43 190.69,104.43 VRAM4.E1 ; v1(89.41,103.87) 89.74,103.54 C6203.2 ; XDP1.13 67.5,95.28 67.3,95.09 v1(66.66,95.09) ; R1501.2 126.81,86.15 127.38,86.73 v1(127.38,87.62) ; U3401.14 26.04,55.49 v1(26.29,55.74) ; VRAM1.T9 v1(161.19,113.3) ; FPR1.1 275.18,18.45 275.69,17.94 v1(275.69,17.75) ; VRAM4.A9 184.22,100.33 184.39,100.16 v1(184.39,100.14) ; v1(115.98,71.75) 116.4,71.33 RN401.1 ; VRAM1.J8 v1(162.92,108.1) ; U5601.18 v1(266.32,31.1) ; U9101.4 253.86,35.28 v1(253.11,34.53) ; v1(23.36,20.22) 23.36,19.56 C2718.2 ; XDP1.7 69,94.91 v1(68.4,94.32) ; R1502.2 132.14,69.19 v1(132.38,68.95) ; XDP1.31 62.96,96.66 62.96,95.31 62.93,95.28 62.93,95.09 62.87,95.03 v1(62.82,95.03) ; FC9718.2 64.97,101.46 v1(64.87,101.36) ; VRAM1.G8 v1(162.12,105.7) ; C721.2 119.77,80.49 C720.2 118.99,80.06 v1(119.19,79.86) ; VRAM4.M9 183.76,110.1 v1(183.64,110.22) ; XDP1.8 v1(69,92.44) ; v1(3.67,98.89) 6.13,98.89 RJ45.10 6.47,98.89 v1(8.75,98.89) ; VRAM1.P9 v1(161.19,111.7) ; XDP1.49 v1(58.5,98.94) ; v1(76.87,6.04) 76.61,5.78 76.61,4.79 75.76,3.94 U9103.4 ; v1(263.12,28.05) 263.14,28.08 U5601.13 ; VRAM4.F9 183.96,105.3 v1(183.54,105.73) 183.91,106.1 VRAM4.G9 ; C8055.2 184.83,86.5 v1(184.92,86.41) ; v1(149.48,57.8) 149.48,57.57 149.17,57.26 148.98,57.26 ED502.1 ; VRAM1.B9 v1(161.13,102.1) ; PC8635.2 148.21,55.36 147.33,54.48 147.29,54.48 146.64,53.83 145.88,53.83 145.68,54.04 v1(145.24,54.04) ; U9102.32 82.1,9.51 v1(81.61,9.99) ; v1(191.26,110.35) 191.01,110.1 VRAM4.M1 ; U9104.23 246.62,27.44 246.09,26.9 v1(246.09,26.9) ; VRAM4.G8 v1(184.62,105.7) ; TPAD1.4 178.4,12.01 ; DB3.8 v1(285.26,40.66) ; XDP1.20 66,92.1 v1(65.66,92.44) ; v1(70.23,10.15) 70.68,10.59 ED1302.2 ; v1(127.04,81.73) 126.73,81.42 R806.2 126.1,80.99 125.75,81.34 125.42,81.34 125.06,80.99 FC708.2 ; VRAM4.E8 v1(184.62,104.1) VRAM4.D8 ; ED6001.8 ED6001.3 264.92,23.23 263.4,24.75 v1(263.4,25) ; VRAM1.J2 v1(166.92,108.1) ; VRAM4.B9 v1(183.63,102.1) ; v1(189.41,102.5) 189.41,102.45 189.06,102.1 VRAM4.B3 ; PU5102.8 v1(62.83,48.25) ; v1(286.02,46) 286.26,45.76 DB3.7 ; VRAM1.M9 v1(161.19,110.1) ; XDP1.14 67.5,92.38 67.34,92.54 v1(67.34,92.6) ; v1(95.06,125.4) 95.52,125.85 FC6201.2 ; C1315.2 110.68,67.49 111.43,68.23 v1(111.43,69.4) ; VRAM1.M1 v1(168.71,110.1) ; v1(168.73,105.73) 168.36,106.1 VRAM1.G1 ; DB3.4 v1(284.98,42.66) ; VRAM4.T9 v1(183.69,113.3) ; C2112.2 126.35,65.8 v1(126.36,65.8) ; VRAM1.T1 v1(168.71,113.3) ; VRAM4.G1 190.86,106.1 v1(191.23,105.73) ; VRAM1.A9 v1(161.72,100.14) ; VRAM4.B1 191.24,102.1 v1(191.26,102.08) ; VRAM1.E1 168.53,104.5 168.89,104.14 v1(169.09,104.14) 168.64,103.7 VRAM1.D1 ; U9102.26 85.1,8.64 v1(84.96,8.77) ; ED6201.8 101.68,116.44 102.22,115.9 v1(102.52,115.9) ; VRAM4.P1 v1(191.21,111.7) ; XDP1.38 61.5,93.05 v1(61.47,93.07) ; U9102.11 83.1,2.61 v1(83.31,2.4) 83.44,2.53 84.96,2.53 85.6,3.16 U9102.16 ; AFTP4309.1 198.37,40.88 197.55,40.06 KB1.1 195.89,39.1 193.55,41.44 191.9,41.44 KB1.31 ; v1(166.09,101.69) 166.5,102.1 VRAM1.B3 ; C5501.2 43.69,76.82 v1(43.18,77.33) ; v1(58.6,92.58) 58.6,92.24 58.5,92.14 XDP1.50 ; VRAM1.P1 v1(168.71,111.7) ; VRAM1.G9 161.41,106.1 v1(161.04,105.73) 161.46,105.3 VRAM1.F9 ; v1(89.21,86.34) 89.03,86.16 88.31,86.16 87.84,85.68 RN402.2 ; VRAM4.P9 v1(183.69,111.7) ; VRAM1.E2 v1(167.72,104.9) ; R2018.2 146.71,59.71 147.41,59.71 147.45,59.68 v1(147.6,59.68) ; VRAM4.J2 v1(189.42,108.1) ; PG4411.2 v1(240.66,11.67)
  TOP w0.356: SIM1.5 84,122.16 85.13,123.28 v1(85.13,123.44) ; v1(41.78,77.33) 41.4,77.33 41.02,76.95 C5540.2 ; Q6101.4 50.79,63.95 50.65,63.82 50.62,63.82 v1(50.16,63.36) ; PG4601.2 149.35,116.7 149.38,116.72 v1(149.66,116.72) ; Q6101.1 v1(48.52,65.25)
  TOP w0.381: C2401.2 209.02,41.69 C2417.2 ; C6206.2 R6224.2 88.93,108.67 v1(88.77,108.82) ; v1(89.41,103.87) 89.08,104.2 Q6201.1 ; v1(85.85,106.16) 85.85,106.05 86.11,105.79 Q6201.4 ; v1(127.59,71.85) 127.59,71.22 EC2001.2 ; EC9719.2 259.19,29.49 259.59,29.09 v1(259.74,29.09)
  TOP w0.406: v1(208.23,54.98) 208.23,53.88 208.52,53.59 PQ8501.1 ; PQ4405.4 244.29,13.67 v1(243.59,13.67) ; v1(49.06,54.09) 49.06,53.97 49.62,53.4 Q4001.4 ; v1(127.18,122.08) 127.76,122.67 127.89,122.67 128.27,123.05 FC9723.2 ; Q6701.1 v1(111.66,7) ; PQ8501.4 211.04,52.29 211.05,52.31 211.64,52.3 211.65,52.29 211.91,52.29 EC9718.2 ; v1(51.05,56.37) 50.94,56.26 Q4001.1 ; v1(111.79,4.35) 111.97,4.54 112.3,4.54 112.84,5.08 Q6701.4 ; v1(74.1,108.49) PQ4402.4 ; PQ4402.1 75.54,109.48 v1(76.07,108.95)
  TOP w0.457: C1181.2 144.48,86.01 v1(144.32,86.17) ; C1151.2 105.42,71.35 v1(105.04,71.73) 104.64,71.32 FC704.2
  TOP w0.508: PR4313.2 49.37,99.68 49.33,99.68 v1(49.28,99.63) ; v1(173.58,104.25) 173.13,104.25 172.71,104.67 C8129.2 ; 12.87,49.39 USB1.7 ; USB1.7 12.87,50.81 ; USB1.7 13.58,50.1 ; v1(90.58,7.35) 90.58,7.33 91.06,6.84 91.06,6.67 ; FC9732.2 147.64,128.19 147.83,128.38 ; v1(154.41,127.01) EC9728.2 152.36,127.01 FC9733.2 ; v1(34.04,57.01) 33.62,57.43 EC6102.2 EC6103.2 ; PC4511.2 46.91,43.98 v1(47.37,44.44) 47.37,45.32 47.78,45.73 PC4518.2 ; v1(127.68,75) 127.68,75.28 R1603.2 ; v1(60.44,88.54) 59.79,88.54 C9905.2 ; v1(172.56,13.17) 172.56,13.04 171.39,11.86 C6504.2 R6513.2 ; v1(119.15,10.75) 119.32,10.59 C1216.2 ; v1(80.39,10.02) 79.78,10.63 C1304.2 ; C1202.2 166.14,17.96 v1(166.21,17.89) ; v1(95.06,125.4) C6201.2 C6202.2 ; FC702.2 106.46,82.13 106.32,82.13 105.83,82.62 105.83,82.89 105.2,82.89 v1(105.08,83.01) ; 178.4,12.01 179.45,13.06 v1(180.05,13.06) ; PR4308.2 63.14,106.06 64.2,106.06 v1(64.3,106.16) ; v1(242.87,25.56) 242.82,25.51 AFTP6314.1 ; v1(172.72,17.93) 172.72,17.94 C1214.2 ; PC5110.2 65.55,63.53 PC5112.2 v1(66.65,63.55) ; FC1301.2 40.45,12.75 ; EL5503.2 v1(43.69,69.84) ; EC2904.1 v1(32.19,9.95) ; v1(279.13,23.36) 279.13,23.23 278.55,22.65 FPR1.8 ; 10.65,65.15 HDMI1.2 ; HDMI1.2 11.95,65.15 ; HDMI1.2 11.3,64.58 ; C7714.2 179.45,71.26 v1(179.93,71.74) 179.86,71.82 179.64,71.82 179.36,72.1 C7715.2 ; v1(174.3,92.66) 174.73,92.24 174.73,91.01 C8003.2 C8004.2 175.11,89.73 v1(174.12,89.73) 173.89,89.96 C8001.2 ; C8009.2 182.44,87.93 v1(182.51,88.01) 182.5,88.03 C8014.2 ; EC2501.2 143.03,51.7 v1(142.88,51.55) 142.81,51.48 R2401.2 ; PR8528.2 v1(214.07,65.52) ; v1(191.74,16.62) 191.49,16.37 191.49,15.31 191.9,14.9 KB1.32 ; EC5502.2 45.65,74.91 v1(45.65,77) ; C722.2 101,71.33 v1(101.38,71.71) ; v1(31.11,51.17) 31.31,51.36 FC2403.2 ; C8032.2 169.89,86.32 C8031.2 169.74,87.17 v1(169.75,87.18) ; v1(27.05,69.07) 27.18,69.2 PD4303.3 ; EC2602.2 215.14,43.42 215.65,43.93 215.65,44.38 v1(216.61,45.35) ; C8217.2 173.58,102.64 v1(173.58,103.36) ; v1(47.12,28.81) 47.94,28.81 PR5304.2 48.45,28.62 48.96,29.13 PR5303.2 ; v1(31.7,61.25) 31.84,61.39 PD4302.1 ; v1(55.12,48.98) 55.12,48.6 54.74,48.22 R4006.2 ; AFTP4308.1 221.03,12.81 AFTP4307.1 219.46,12.81 219.07,13.19 v1(219.07,13.22) ; FC1005.2 54.1,18.03 54.03,17.96 v1(54.03,17.83) ; C1117.2 FC703.2 ; FC703.2 104.97,85.33 C1101.2 105.09,84.57 105.35,84.31 ; FC703.2 105.22,86.47 C1116.2 C1103.2 ; v1(155.27,108.62) 155.86,109.21 R7808.1 ; v1(27.3,78.47) 25.51,80.26 FC9705.2 ; v1(36.12,66.58) 36.22,66.69 C6110.2 C6109.2 FC6101.2 ; v1(59.16,67.96) 58.9,68.21 PC5116.2 ; v1(69.3,17.94) 70.53,19.16 EC1063.2 ; v1(219.96,28.94) 219.27,28.24 C2414.2 ; v1(184.9,76.06) 184.9,78.18 C7920.2 ; v1(103.21,82.94) 103.21,82.18 C1149.2 ; PC4510.2 57.63,41.84 57.43,41.64 57.42,41.64 v1(57.38,41.59) ; C2701.2 27.93,3.41 v1(28.83,3.41) C2714.2 ; C1309.2 50.93,9.95 v1(50.98,9.9) ; FC9703.2 199.12,106.12 v1(199.49,105.75) ; C1806.2 EC1806.2 131.25,47.42 128.17,50.51 v1(127.79,50.51) 127.76,50.53 127.71,50.53 127.13,51.12 C2118.2 ; AFTP6201.1 188.93,45.83 KBLIT1.5 ; 232.28,41.39 230.95,40.05 ED4305.1 ; v1(190.83,42.94) 191.9,41.87 KB1.31 ; v1(211.28,17.69) 211,17.97 211,18.39 R2454.2 ; R6101.2 46.72,65.91 46.86,66.05 v1(46.86,66.56) ; R7931.2 182.63,78.13 v1(182.32,78.44) ; v1(60.78,51.06) 60.78,50.61 60.39,50.21 PC5123.2 ; v1(139.72,18.02) 140.08,18.38 PC1056.2 ; v1(123.91,65.76) 123.88,65.76 123.56,65.44 122.86,65.44 122.8,65.38 122.63,65.38 R503.2 122.05,65.12 121.53,65.64 v1(121.53,65.67) 121.53,65.66 121.53,65.43 121.04,64.95 R502.2 R501.2 119.95,65.14 EC1004.2 ; 14.37,25.89 USB2.4 ; USB2.4 14.37,27.31 ; USB2.4 13.66,26.6 ; USB2.4 15.08,26.6 ; R2024.2 153.03,70.22 153.29,70.47 v1(153.4,70.47) ; 10.55,75.41 HDMI1.21 ; HDMI1.21 11.99,76.4 ; HDMI1.21 10.55,77.39 ; EC9203.2 26.47,21.75 v1(26.16,21.45) 25.84,21.13 FC2701.2 EC2723.1 ; v1(115.95,7.25) 115.65,7.55 R1210.1 ; PC8525.2 218.07,60.11 v1(218.12,60.16) PC8516.2 ; v1(111.43,69.4) 111.4,69.43 C1152.2 ; C7919.2 171.04,72.04 171.82,71.26 172.91,71.26 172.97,71.32 C7921.2 R7933.2 ; C7919.2 169.07,72.12 v1(168.89,71.94) ; C7919.2 171.51,72.59 R7929.2 ; v1(51.06,78.04) 50.61,77.59 FC9721.2 ; PC1057.2 129.54,18.16 v1(129.3,17.92) ; Q6501.S 187.85,56.25 KBLIT1.6 189.9,54.78 191.62,56.5 v1(191.72,56.5) ; EC1220.2 62.61,18 62.66,17.95 v1(62.66,17.28) ; EC6305.2 79.25,110.35 v1(79.76,110.86) ; v1(195.33,14.08) 195.33,12.3 195.07,12.05 195.07,10.61 EC9737.2 ; v1(209.93,63.61) PC8501.1 210.63,62.81 PC8524.2 ; v1(35.24,96) C3121.2 ; v1(51.94,66.15) 51.97,66.18 52.32,66.18 52.84,65.66 FC9720.2 52.84,65.39 52.69,65.24 EC9710.2 ; v1(219.07,13.22) 218.63,13.22 LEDBD1.8 ; v1(219.07,13.22) 219.58,13.73 C2428.2 ; PC4508.2 53.03,38.08 53.03,37.67 52.93,37.58 v1(52.93,37.46) ; C2424.1 v1(210.25,15.62) ; PC8509.2 204.6,70.57 v1(204.52,70.65) 204.6,70.72 205.33,70.72 206.13,71.52 FC9701.2 ; 56.47,46.88 56.57,46.78 v1(57.15,46.78) ; 56.47,46.88 PR4505.2 ; 56.47,46.88 PR4517.2 ; EC9720.2 33.08,78.16 LCD2.1 ; v1(175.75,88.59) 175.1,87.93 C8033.2 ; USB2.7 13.58,30.1 ; USB2.7 12.87,30.81 ; USB2.7 12.87,29.39 ; v1(75.82,100.52) 75.12,101.22 Q6301.S ; C1172.2 142.86,83.94 v1(142.62,84.19) ; C2501.2 146.58,49.29 145.82,50.05 v1(145.82,50.07) ; v1(122.35,17.89) 122.43,17.96 C1320.2 ; v1(207.77,4.61) 207.71,4.54 EC6402.2 ; EC6507.2 170.7,43.04 v1(170.94,43.04) ; v3(41.68,30.41) 41.68,30.82 42.27,31.4 43.08,31.4 43.47,31.8 PC5307.2 ; FC9702.2 203.67,125.4 ; C6111.2 C6107.2 35.5,52.25 v1(34.98,52.25) ; C8150.2 173.25,112.25 173.58,111.92 173.58,111.65 173.63,111.6 v1(173.63,111.6) ; v1(246.48,15.1) 246.13,15.45 PQ4405.1 ; C2124.2 145.45,91.11 v4(144.73,91.83) ; R1303.1 188.98,14.26 188.95,14.29 v1(188.95,14.41) ; EC9721.2 v1(64.62,46.19) ; R6505.2 185.17,45.07 186.44,43.8 v1(186.44,43.55) ; v1(32.24,16.59) 31.72,17.12 EC2902.1 ; EC9727.2 214.73,68.03 v3(214.63,67.93) ; Q2505.S 226.7,44.37 227.52,45.2 v1(227.58,45.2) ; v1(60.91,62.88) 61.01,62.98 PR5106.1 61.04,63.53 PR5101.2 ; C8042.2 178.69,89.47 v1(178.55,89.62) 179.01,90.07 C8005.2 179.9,90.54 C8007.2 ; Q3101.S v1(32.58,98.22) ; PC1055.2 91.7,10.63 92.26,10.07 v1(92.48,10.07) ; PQ4306.1 52.25,101.43 v1(52.04,101.23) ; v1(111.75,65.66) 111.6,65.81 FC705.2 ; FC9736.2 224.59,40.87 C2503.2 225.17,40.16 225.43,40.41 v1(225.43,40.47) ; 13.62,44.59 USB1.11 13.62,42.81 ; Q9104.S 256.03,27.77 255.47,27.21 v1(255.13,27.21) ; v1(139.34,48.04) 139.6,47.79 139.6,46.08 Q1802.S ; H3.1 19.9,48.43 ; H3.1 15.47,44 ; H3.1 19.9,39.57 ; v1(210.19,56.24) 210.19,56.5 210.44,56.75 PR8524.1 ; C2420.2 218.55,23.67 217.81,22.92 217.81,22.46 217.41,22.07 v1(216.92,22.07) ; 13.62,55.61 USB1.10 13.62,57.39 ; v1(145.29,49.24) C4101.2 C2502.2 ; TPAD1.9 173.94,8.5 v1(176.02,6.42) ; v1(85.09,102.56) 85.64,103.11 R407.2 ; v1(124,9.41) 124.05,9.41 124.85,10.2 C1306.2 ; C8034.2 177.74,87.3 177.2,87.83 v1(176.97,87.83) ; R1823.2 144.85,74.72 144.68,74.55 v1(144.04,74.55) ; EC1059.2 68.45,10.24 v1(67.97,9.76) ; C2401.2 207.54,43.17 206.19,43.17 205.86,43.5 v1(205.85,43.5) ; FC706.2 113.16,69.61 v1(113.26,69.5) ; 13.62,35.61 USB2.10 ; USB2.10 13.62,37.39 ; USB2.10 15.3,36.5 ; v1(285.62,33.26) 287.21,33.26 DB1.10 ; PQ4403.S 240.52,26.88 239.27,28.13 v1(239.27,28.31) ; C7904.2 C8008.2 ; PR5408.2 PC5411.2 v1(169.86,39.29) ; FC5503.2 45.06,78.98 45.72,78.32 v1(45.72,77.96) ; v1(184.16,84.53) 184.39,84.76 R7821.2 ; KBLIT1.5 189.28,46.8 v1(188.59,47.48) ; KBLIT1.5 190.88,45.82 AFTP6245.1 190.88,43.83 v1(190.91,43.8) ; C9901.2 63.78,101.41 63.6,101.59 v1(63.6,101.74) ; R406.2 82.06,101.49 81.57,101.49 R402.2 80.92,101.52 v1(80.53,101.92) ; USB1.4 15.08,46.6 ; USB1.4 14.37,45.89 ; USB1.4 13.66,46.6 ; USB1.4 14.37,47.31 ; v1(178.56,113.65) 179.01,113.65 C8222.2 C8223.2 ; v1(124.71,91.4) 124.5,91.4 123.7,90.6 123.7,89.75 122.87,88.92 122.87,87.35 122.3,86.78 C2122.2 ; USB2.11 15.53,23.7 ; USB2.11 13.62,24.59 ; USB2.11 13.62,22.81 ; v1(288.04,35.8) 290.09,35.8 DB1.12 ; C5702.2 C5710.2 v1(18.54,78.73) ; 74.35,113.26 v1(73.28,113.26) 73.03,113.26 AFTP6318.1 ; v1(205.44,41.95) 205.36,41.87 C2402.1 ; PR4413.1 v1(243.31,12.1) ; PC4413.2 PR4409.2 238.07,10.55 238.05,10.53 v1(238.05,10.5) ; PC1054.2 117.05,86.45 v1(117.05,87.13) ; 62.65,56.31 WLAN2.1 59.46,59.5 ; v1(199.34,65.42) 199.33,65.4 PR8502.1 PR8501.1 ; EC1002.2 115.14,69.38 v1(115.09,69.43) ; v3(215.01,79.87) 215.26,79.61 EC8536.1 ; EC2603.2 EC2601.2 214.27,48.92 C2604.2 214.27,47.97 v1(214.88,47.36) 215.14,47.1 D2601.A ; C1310.2 104.27,17.95 v1(104.25,17.94) ; C2417.2 209.49,41.17 C2410.2 ; C8146.2 C8154.2 173.02,106.03 173.58,105.47 v1(173.58,105.14) ; C2119.2 C2118.2 ; C2118.2 C2117.2 ; 10.65,68.15 HDMI1.8 11.95,68.15 ; v1(22.4,76.67) 21.74,77.33 17.46,77.33 EC5702.2 17.46,77.07 EC5701.2 ; 5.49,60 HDMI1.22 4.05,59.01 ; EC2912.2 EC2911.2 38.04,15.8 v1(37.85,15.99) ; PC5408.2 PC5407.2 169.04,42.78 v1(169.42,42.4) ; 74.36,120.74 72.36,120.74 v1(71.5,121.6) ; AFTP6102.1 283.08,46.98 v1(282.35,46.24) ; PR4432.2 v1(237.1,13.04) ; v1(31.11,82.03) 31.22,82.13 31.75,82.13 32.64,83.02 C5505.2 ; R1212.1 88.28,12.04 88.28,13.34 88.63,13.69 88.86,13.69 v1(88.89,13.72) ; v1(54.86,103.49) 54.69,103.31 PQ4306.4 ; FC9704.2 53.1,81.28 v1(52.83,81.01) ; EC1808.2 R1837.2 141.6,46.66 141.6,47.03 v1(142.95,48.37) ; C9115.1 242.59,33.77 v1(242.58,33.77) 242.57,33.77 242.57,33.27 242.91,32.93 C9112.2 ; v1(215.77,9.59) 215.77,11.01 214.58,12.2 214.58,12.24 212.82,14 LEDBD1.7 ; C1138.2 C1136.2 97.66,78.47 97.58,78.38 v1(97.58,78.34) ; PWR1.6 273.9,38.84 v1(273.56,39.18) ; C2411.2 v1(200.34,21.12) ; v1(212.6,41.13) 212.15,40.69 EC7001.2 C7001.2 ; EC2508.2 EC2509.2 103.38,4.25 v1(103.76,4.63) ; FC9709.2 42.75,80.12 43.31,80.68 v1(43.31,81.14) ; EC2901.1 32.17,13.18 v1(32.26,13.27) 32.35,13.18 EC2903.1 ; C715.2 101.89,65.96 C1321.2 99.52,65.96 v1(99.41,65.85) 99.3,65.96 C1318.2 ; PR4515.2 57.08,39.87 v1(57.56,40.35) ; 83.44,10.91 82.68,10.15 v1(82.68,10.02) ; EC6303.2 81.22,106.3 81.71,106.79 ED6301.2 82.3,106.79 82.55,106.54 83.38,106.54 EC6304.2 83.83,107 84.84,107 84.94,107.1 86.32,107.1 R6301.1 86.33,106.64 v1(85.85,106.16) 85.09,105.4 EC6301.2 ; FC9719.2 v1(58.61,74.09) ; v1(183.36,83.24) 183.16,83.04 183.16,82.27 R7601.2 ; EC6503.2 133.92,5.51 v1(133.6,5.19) ; EC6403.2 v1(205.93,4.09) ; C7918.2 R7927.2 169.94,74.98 v1(169.73,75.18) ; EC6302.2 81.66,111.11 v1(81.79,111.24) ; v1(23.34,21.4) 23.48,21.26 EC2709.2 EC2708.2 ; v1(28.32,15.73) 28.38,15.8 C2709.2 EC2701.2 27.5,17.35 C2708.2 ; v1(94.1,66.13) 93.42,65.45 PC1061.2 ; C8013.2 168.69,83.85 C8065.2 ; PR4451.2 v1(238.71,8.22) ; Q7903.S 175.83,68.1 v1(176.17,67.75) ; PC5120.2 62.55,46.28 62.74,46.47 v1(62.88,46.47) PC5119.2 ; v1(104.78,126.6) 105.22,126.6 FC9717.2 ; 91.06,6.67 C9107.2 ; 91.06,6.67 EC2507.2 ; EC2703.2 18.85,17.12 18.81,17.16 R2730.2 18.57,17.18 18.57,17.99 v1(18.41,18.15) ; R7811.1 173.2,109.59 v1(173.58,109.21) ; C8017.2 175.31,77.93 PC8636.2 ; R601.2 94.93,81.07 v1(94.89,81.04) ; v1(288.14,19.01) 289.6,19.01 DB1.11 ; C6113.2 47.94,63.68 v1(48.39,63.23) ; C1317.2 96.71,65.57 v1(96.91,65.76) ; C2507.2 v1(104.09,9.89) 104.17,9.81 C2506.2 ; v1(151.76,55.9) 151.59,56.07 PQ8608.S 153.05,58.35 PC8612.2 ; v1(288.49,30.77) 288.49,30.77 DB1.8 ; PC5121.2 65.4,50.92 65.19,51.13 v1(65.19,51.41) 65.19,51.71 65.3,51.83 65.3,51.85 65.53,52.08 PC5122.2 ; 5.49,78.3 HDMI1.23 4.05,79.29 ; C9103.2 v1(248.23,34.28) ; v1(59.39,102.02) 59.21,102.02 58.72,102.51 PQ4304.E ; 10.55,60.91 HDMI1.20 ; HDMI1.20 10.55,62.89 ; HDMI1.20 11.99,61.9 ; v1(165.35,85.53) 165.49,85.53 165.74,85.29 165.74,84.48 R7818.2 C7805.1 ; PU5401.9 159.87,47.1 v1(159.46,47.51) 159.78,47.83 PU5401.8 159.78,50.64 159.58,50.85 PR5411.2 159.45,51.67 C4103.2 ; v1(59.82,74.15) 59.82,74.98 FC5501.2 ; MESW1.2 210.21,118.2 210.64,117.76 v1(210.69,117.76) ; v1(37.72,94.22) 38.71,93.23 C3109.2 ; C7711.2 C7710.2 179.96,73.45 v1(179.35,73.45) ; R1205.1 112.98,7.89 113.55,7.31 113.68,7.31 v1(113.79,7.2) ; v1(147.14,17.89) 147.19,17.95 C1215.2 ; PC8512.2 211.52,66.6 v1(211.96,67.04) ; C719.2 144.39,10.61 143.79,11.21 136.75,11.21 136.27,10.73 C1217.2 128.5,10.73 v1(127.1,9.33) ; C1308.2 65,9.76 65.64,9.76 v1(65.66,9.78) ; v1(181.57,71.82) 182.52,71.82 C7713.2 ; C2103.2 132.27,70.08 v1(132.5,69.85) ; v1(86.52,14.36) 86.33,14.17 86.33,13.66 C1229.2 ; PR4302.2 v1(29.53,65.76) ; v1(240.66,11.67) 240.66,10.95 PR4433.2 ; 251.4,16.43 H4.1 247.97,13 ; PC5311.2 48.2,25.61 47.53,26.27 v1(47.37,26.27) ; C2425.1 v1(205.13,14.84) ; v1(274.6,27.95) 274.6,28.65 PWR1.5 ; EC9718.2 212.66,52.12 213.44,51.34 v1(214.17,51.34) ; R5526.2 49.02,79.55 R5531.2 47.54,79.55 46.61,80.48 v1(46.61,81.01) ; R3111.2 32.37,94.14 v1(33.02,94.14) ; v1(185.9,82.8) 186.47,83.37 Q7902.S ; AFTP2501.1 185.29,9.64 ; C9903.2 v1(59.79,101.1) ; v1(149.56,81.44) 149.15,81.44 148.46,80.76 C2123.2 ; v1(114.17,65.78) 113.99,65.96 C1322.2 ; C1221.2 v1(58.04,10.15) ; FC1003.2 113.4,87.35 v1(113.44,87.39) 113.02,87.81 C1102.2 ; R6707.2 v1(108.41,9.69) 108.28,9.81 108.28,10.26 107.4,11.14 101.5,11.14 101.22,10.85 C1219.2 ; v1(27.56,63.49) 28.17,63.49 28.24,63.55 PQ4302.E ; C5541.2 C5540.2 ; PC4401.1 228.85,19.82 v1(228.85,20.56) ; v1(117.86,112.61) 117.49,112.61 117.36,112.74 116.92,112.74 PC4807.2 ; v1(178.58,110.07) 178.74,110.07 179.22,109.59 R8203.1 C8221.2 ; v1(88.89,17.94) 88.42,18.41 EC1062.2 ; v1(109.38,85.22) 109.47,85.31 FC4702.2 ; v1(274.7,21.7) 274.73,21.73 274.73,23.12 274.12,23.73 273.62,23.73 273.11,24.24 ED9201.2 ; PR5105.2 v1(57.4,65.3)
  TOP w0.635: LIDSW1.1 154.9,120.34 v1(154.81,120.42)
  L3 w0.102: v1(85.67,1.04) 84.49,1.04 84.27,0.82 80.81,0.82 v1(80.59,1.04)
  L3 w0.305: v1(138.68,2.04) 142.46,2.04 146.85,6.43 173.8,6.43 v1(175.69,4.54)
  L3 w0.381: v1(85.67,1.04) v1(90.75,1.04) v1(95.83,1.04) v1(100.91,1.04) v1(105.99,1.04) v1(111.07,1.04) v1(116.15,1.04) v1(121.23,1.04) v1(126.31,1.04) v1(131.39,1.04) 135.8,1.04 136.8,2.04 v1(138.68,2.04) ; v1(80.59,1.04) v1(75.51,1.04) v1(70.43,1.04) v1(60.27,1.04) v1(55.19,1.04) v1(50.11,1.04) v1(45.03,1.04) v1(39.95,1.04) v1(34.87,1.04)
  L3 w0.508: 11.95,68.15 HDMI1.8 10.65,68.15 ; USB1.11 13.62,44.59 ; USB1.11 15.3,43.7 ; USB1.11 13.62,42.81 ; 184.31,123 H2.1 ; H2.1 186.15,121.16 ; H2.1 186.15,124.84 ; H2.1 187.99,123 ; 13.62,22.81 USB2.11 13.62,24.59 ; HDMI1.20 11.99,61.9 ; HDMI1.20 10.55,60.91 ; HDMI1.20 10.55,62.89 ; USB1.4 14.37,47.31 ; USB1.4 13.66,46.6 ; USB1.4 14.37,45.89 ; USB1.4 15.08,46.6 ; 10.65,65.15 HDMI1.2 ; HDMI1.2 11.3,64.58 ; HDMI1.2 11.95,65.15 ; USB2.7 12.87,30.81 ; USB2.7 12.87,29.39 ; USB2.7 13.58,30.1 ; 12.87,49.39 USB1.7 ; USB1.7 12.87,50.81 ; USB1.7 13.58,50.1 ; 10.55,75.41 HDMI1.21 ; HDMI1.21 10.55,77.39 ; HDMI1.21 11.99,76.4 ; H1.1 165.3,124.84 ; H1.1 165.3,121.16 ; H1.1 167.14,123 ; H1.1 163.46,123 ; H5.1 289.4,54.34 ; H5.1 289.4,50.66 ; H5.1 287.56,52.5 ; H5.1 291.24,52.5 ; 5.49,60 HDMI1.22 4.05,59.01 ; 252.48,15.1 251.4,14.02 H4.1 250.12,13 249.43,12.3 ; USB2.4 14.37,27.31 ; USB2.4 14.37,25.89 ; USB2.4 13.66,26.6 ; USB1.10 13.62,57.39 ; USB1.10 13.62,55.61 ; USB1.10 15.3,56.5 ; 13.62,37.39 USB2.10 13.62,35.61
  L4 w0.508: 251.4,14.84 H4.1 249.56,13 ; USB1.7 13.58,50.1 ; USB1.7 12.87,49.39 ; USB1.7 12.87,50.81 ; HDMI1.20 10.55,62.89 ; HDMI1.20 10.55,60.91 ; HDMI1.20 11.99,61.9 ; USB2.7 12.87,30.81 ; USB2.7 13.58,30.1 ; USB2.7 12.87,29.39 ; 13.62,35.61 USB2.10 13.62,37.39 ; 5.49,60 HDMI1.22 4.05,59.01 ; 13.62,22.81 USB2.11 13.62,24.59 ; USB1.11 15.3,43.7 ; USB1.11 13.62,44.59 ; USB1.11 13.62,42.81 ; H5.1 289.4,54.34 ; H5.1 291.24,52.5 ; H5.1 287.56,52.5 ; H5.1 289.4,50.66 ; USB1.4 14.37,47.31 ; USB1.4 15.08,46.6 ; USB1.4 13.66,46.6 ; USB1.4 14.37,45.89 ; 14.37,25.89 USB2.4 ; USB2.4 14.37,27.31 ; USB2.4 13.66,26.6 ; USB1.10 15.3,56.5 ; USB1.10 13.62,57.39 ; USB1.10 13.62,55.61
  L6 w0.508: HDMI1.21 11.99,76.4 ; HDMI1.21 10.55,75.41 ; HDMI1.21 10.55,77.39 ; 13.62,42.81 USB1.11 13.62,44.59 ; H5.1 289.4,54.34 ; H5.1 291.24,52.5 ; H5.1 287.56,52.5 ; H5.1 289.4,50.66 ; HDMI1.2 11.95,65.15 ; HDMI1.2 10.65,65.15 ; HDMI1.2 11.3,64.58 ; 249.56,13 H4.1 251.4,14.84 ; USB2.4 15.08,26.6 ; USB2.4 14.37,25.89 ; USB2.4 14.37,27.31 ; USB2.4 13.66,26.6 ; 12.87,49.39 USB1.7 ; USB1.7 12.87,50.81 ; USB1.7 13.58,50.1 ; 13.62,37.39 USB2.10 13.62,35.61 ; HDMI1.20 11.99,61.9 ; HDMI1.20 10.55,60.91 ; HDMI1.20 10.55,62.89 ; 4.05,79.29 HDMI1.23 5.49,78.3 ; USB1.10 13.62,57.39 ; USB1.10 15.3,56.5 ; USB1.10 13.62,55.61 ; 5.49,60 HDMI1.22 4.05,59.01 ; USB2.11 15.3,23.7 ; USB2.11 13.62,22.81 ; USB2.11 13.62,24.59 ; 14.37,45.89 USB1.4 ; USB1.4 13.66,46.6 ; USB1.4 14.37,47.31 ; 12.87,29.39 USB2.7 12.87,30.81 ; 11.95,68.15 HDMI1.8 10.65,68.15
  BOTTOM w0.089: v1(132.94,81.02) 132.94,81.03 131.87,81.03 131.67,80.94 131.55,80.94 131.42,80.99 131.18,80.99 CPU1.L2
  BOTTOM w0.127: CPU1.BB43 107.85,63.29 v1(107.69,63.13) ; CPU1.N19 121.01,79.6 120.71,79.9 120.43,79.9 120.13,79.6 CPU1.N21 ; CPU1.B34 112.14,86.13 112.14,86.98 112.27,87.11 ; CPU1.BB26 117.79,63.71 117.89,63.61 117.89,62.08 118.44,61.53 118.44,60.02 117.77,59.35 117.77,59.35 v1(117.46,59.03) ; CPU1.BB38 110.45,62.2 v1(110.4,62.15) ; v1(89.17,70.4) 89.2,70.42 90.69,70.42 90.87,70.24 91.63,70.24 CPU1.AM71 ; 112.87,58.72 113.02,58.87 113.02,60.61 113.16,60.75 113.16,62.39 112.8,62.75 CPU1.BB34 ; 110.49,83.69 110.66,83.86 110.66,84.12 110.9,84.35 111.4,84.35 111.74,84.69 CPU1.D34 ; CPU1.L20 120.35,80.44 120.03,80.12 119.69,80.12 119.43,79.86 v1(119.19,79.86) ; v1(89.56,73.31) 89.59,73.29 90.42,73.29 90.82,72.9 CPU1.AG71 ; GPU1.B16 177.32,92.15 v1(177.26,92.21) ; GPU1.B18 175.77,91.25 175.77,93.63 v1(175.71,93.68) ; v1(97.86,63.44) 97.91,63.49 97.91,64.24 CPU1.BB60 ; v1(90.29,67.63) 90.41,67.75 90.67,67.75 90.81,67.89 CPU1.AT71 ; CPU1.AV69 92.93,66.83 92.93,67.37 92.94,67.38 92.94,67.42 93.4,67.88 93.57,67.88 CPU1.AT68 ; CPU1.BB55 100.68,62.37 98.62,60.31 v1(98.62,60.01) ; v1(95.76,63.44) 95.73,63.47 CPU1.BB64 ; v1(90.26,68.81) 90.28,68.84 92.13,68.84 92.36,69.06 CPU1.AP70 ; CPU1.BB30 115.43,62.27 115.43,62.27 v1(115.78,61.92)
  BOTTOM w0.178: CPU1.AW16 122.4,66.36 122.4,66.37 121.54,66.37 CPU1.AW18 ; CPU1.AJ15 123.97,72.22 124.09,72.22 124.2,72.33 CPU1.AH13 ; CPU1.D53 101.84,84.71 CPU1.E53 ; CPU1.AW60 97.66,66.36 97.65,66.37 97.38,66.37 97.37,66.36 CPU1.AW62 ; CPU1.AW26 117.36,66.36 117.36,66.37 117.08,66.37 117.08,66.36 CPU1.AW28 ; GPU1.B6 185.29,91.23 185.29,92.18 v1(185.36,92.25) ; v1(117.05,87.13) 117.05,87.08 117.07,87.06 117.07,85.89 117.37,85.59 CPU1.C25 ; v1(90.12,82.48) 90.14,82.5 CPU1.H71
  BOTTOM w0.203: CPU1.AJ4 130.06,71.19 130.06,70.68 CPU1.AL4 ; v1(170.99,92.31) 170.92,92.24 GPU1.B24 ; CPU1.B22 119.17,85.79 118.82,86.15 118.82,86.89 118.44,87.26 118.44,87.62 v1(118.47,87.65) ; PU4801.5 114.52,114.45 114.96,114.01 115.14,114.01 v1(115.16,114.03) ; CPU1.B53 101.53,85.44 101.53,85.02 CPU1.D53 ; GPU1.AC17 176.32,75.76 v1(176.01,76.06) ; PU4701.5 126.71,118 v1(127.08,117.64) ; CPU1.H15 123.79,81.91 CPU1.K16 123.1,81.28 122.71,81.67 122.47,81.67 122.1,82.04 CPU1.H18 ; v1(165.99,73.72) 165.99,73.71 165.99,73.33 GPU1.AF32 ; v1(113.44,87.39) 113.88,86.94 113.88,86.17 114.22,85.84 CPU1.B30 ; CPU1.AN20 CPU1.AP20 CPU1.AR20 CPU1.AT20 121.04,67.71 121.05,67.71 121.05,67.34 121.04,67.33 CPU1.AU20 121.04,66.96 120.85,66.65 121.01,66.48 121.41,66.48 CPU1.AW18 ; CPU1.L18 121.98,80.56 122.25,80.56 122.37,80.44 CPU1.L17 ; v1(132.5,69.85) 132.5,70 132.21,70.29 131.43,70.29 131.12,70.61 CPU1.AL2 ; GPU1.B26 169.32,91.54 169.32,92.2 v1(169.33,92.2) ; CPU1.AG20 120.67,72.89 120.72,72.95 121.09,72.95 121.14,72.89 CPU1.AG19 CPU1.AG18 121.9,72.93 122.47,72.93 CPU1.AG17 CPU1.AF17 ; GPU1.B20 174.12,92.48 v1(174.3,92.66) ; v1(119.2,74.48) 119.29,74.57 CPU1.AD21 120.04,74.71 120.42,74.71 CPU1.AD20 CPU1.AD19 ; CPU1.BA49 104.26,65.31 104.55,65.6 104.55,66.08 CPU1.AW49 ; CPU1.H18 121.96,82.07 121.54,82.49 121.54,83.58 CPU1.E18 ; CPU1.H18 121.86,81.94 CPU1.K18 ; v1(88.57,80.47) 88.65,80.47 89.29,81.1 91.59,81.1 CPU1.K71 ; CPU1.L4 129.98,81.13 130.2,80.91 130.76,80.91 130.96,81.11 CPU1.L2 ; GPU1.AD32 165.99,74.8 165.61,74.8 165.61,74.8 v1(165.46,74.8) ; v1(125.61,72.87) 125.47,72.73 125.14,72.73 124.75,72.33 CPU1.AH13 ; v1(132.38,68.95) 132.38,68.57 132.11,68.3 131.41,68.3 131.06,67.96 CPU1.AT2 ; CPU1.AG16 123.16,72.91 123.81,73.56 CPU1.AF15 123.81,73.92 CPU1.AD16 ; CPU1.AB21 119.78,75.54 119.78,76.12 119.81,76.15 ; v1(116.93,63.22) 116.77,63.38 116.77,64.98 CPU1.BA28 ; CPU1.D45 106.08,84.79 105.75,84.79 105.69,84.73 105.4,84.73 105.38,84.76 104.99,84.76 CPU1.D47 ; CPU1.BB6 CPU1.BA6 ; v1(172.64,92.36) 172.52,92.24 GPU1.B22 ; v1(123.83,121.15) 123.83,121.14 123.77,121.09 PU4701.31 ; CPU1.AF4 CPU1.AF2 ; GPU1.B14 178.91,91.21 178.91,92.15 178.89,92.16 178.89,92.72 178.88,92.73 v1(178.88,92.85) ; CPU1.J35 v1(111.44,81.54) ; CPU1.BA14 123.95,65.73 v1(123.91,65.76) 123.95,65.8 CPU1.AW14 124.38,66.36 124.4,66.38 124.83,66.38 124.85,66.36 CPU1.AW12 ; GPU1.B10 v1(182.12,92.13) ; v1(134.37,73.39) 134.18,73.2 133.04,73.2 133,73.16 131.97,73.16 131.76,73.24 131.71,73.24 131.69,73.26 CPU1.AF1 ; CPU1.D48 104.31,84.74 104.59,85.03 104.59,85.04 104.64,85.09 104.64,85.41 CPU1.B48 ; CPU1.AT4 129.98,67.78 129.64,67.43 129.64,67.08 129.39,66.84 129.23,66.84 CPU1.AW6 ; v1(165.61,76.9) 166.1,76.4 GPU1.AB32 ; CPU1.AM60 98.06,70.57 97.39,70.57 CPU1.AM61 ; v1(180.49,92.2) 180.52,92.17 GPU1.B12 ; v1(102.64,113.52) 102.74,113.52 102.97,113.75 WWAN1.39 ; CPU1.BB18 CPU1.BA18 ; v1(102.62,112.05) 102.82,112.25 WWAN1.33 ; CPU1.K61 96.96,81.45 CPU1.K63 ; WWAN1.57 v1(105.33,118.25) ; 102.08,65.73 102.08,66.14 101.86,66.36 CPU1.AW53 101.4,66.36 101.39,66.38 101.1,66.38 101.08,66.36 CPU1.AW55 ; PU4701.3 127,118.8 v1(127.13,118.93) ; 120.42,72.5 120.14,72.5 119.91,72.74 CPU1.AG21 ; GPU1.B8 183.72,92.14 v1(183.77,92.18) ; v1(165.48,71.46) 165.62,71.6 165.99,71.6 GPU1.AH32 ; CPU1.AW26 118.29,66.36 118.31,66.38 118.59,66.38 118.61,66.36 CPU1.AW23 ; PU4801.31 v1(111.45,117.66) ; CPU1.AW36 111.17,66.36 111.16,66.38 110.87,66.38 110.85,66.36 CPU1.AW38 ; CPU1.AN58 99.1,69.74 99.07,69.71 99.07,69.19 CPU1.AP58 ; CPU1.AW34 112.95,66.36 112.96,66.35 113.34,66.35 113.36,66.38 113.61,66.38 113.63,66.36 CPU1.AW32 ; WWAN1.51 v1(105.33,116.75) ; CPU1.AW8 127.27,66.36 127.2,66.43 126.87,66.43 126.8,66.36 CPU1.AW10
  BOTTOM w0.229: v1(188.23,87.53) 187.39,87.53 GPU1.H2 ; CPU1.AW23 119.09,66.31 119.42,65.97 119.42,65.58 119.09,65.25 CPU1.BA23 ; v1(188.32,89.15) 188.3,89.13 187.39,89.13 GPU1.F2 ; CPU1.BA41 109.15,65.14 109.45,65.44 109.45,65.83 109.15,66.13 CPU1.AW41 ; CPU1.AW45 106.24,66.36 106.21,66.39 105.91,66.39 105.88,66.36 CPU1.AW47
  BOTTOM w0.254: CPU1.AG20 120.42,72.76 120.42,72.21 120.56,72.07 CPU1.AJ20 121.03,71.59 121.36,71.59 121.73,71.22 CPU1.AK18 CPU1.AJ18 122.28,71.64 122.74,71.64 CPU1.AK16 123.81,71.87 CPU1.AJ15 ; CPU1.AT56 100.18,67.85 100.32,67.99 100.35,67.99 v1(100.52,68.17) 100.6,68.17 CPU1.AR55 ; CPU1.AR15 123.79,68.43 123.39,68.15 123.35,68.11 v1(123.31,68.11) 123.3,68.12 122.87,68.42 CPU1.AR16 CPU1.AP18 ; CPU1.G45 106.45,82.69 106.46,82.7 107.04,82.7 107.04,82.69 CPU1.G43 107.56,82.69 v1(107.79,82.92) ; v1(95.76,83.79) 95.56,83.79 CPU1.E65 ; CPU1.T15 123.81,77.89 123.16,77.24 CPU1.V16 123.01,77.09 123,77.08 122.61,77.08 122.61,77.09 CPU1.V17 CPU1.V18 ; CPU1.AW14 123.67,66.64 123.67,67.09 CPU1.AU15 ; CPU1.B22 119.02,85.58 119.02,85.27 119.02,85.27 v1(119.02,85.25) 119.05,85.21 119.05,84.85 CPU1.D22 119.61,84.28 119.84,84.28 CPU1.E21 ; CPU1.AR55 101.08,68.35 101.69,68.35 CPU1.AR53 101.94,68.5 102.25,68.81 102.44,68.81 CPU1.AR52 ; CPU1.AR55 100.6,68.83 v1(100.52,68.83) v1(100.52,69.46) ; CPU1.B66 CPU1.D66 ; CPU1.AN63 95.86,70.3 CPU1.AL64 CPU1.AL65 CPU1.AL66 94.46,70.55 94.33,70.68 93.92,70.68 ; CPU1.AN63 CPU1.AP63 96.36,69.04 96.36,69.03 96.36,68.63 96.36,68.63 CPU1.AR63 96.23,68.5 96.08,68.35 96.07,68.35 v1(95.9,68.19) 96.08,68.01 96.1,68.01 96.26,67.85 CPU1.AT63 ; CPU1.AN63 96.49,69.94 96.66,69.94 v1(96.84,70.12) 97.18,70.45 CPU1.AM61 ; CPU1.AU32 114.1,66.83 CPU1.AW32 ; v1(94.1,66.13) 93.59,66.64 CPU1.AV68 93.59,66.78 93.9,67.08 v1(93.9,67.25) 93.58,67.56 CPU1.AT68 ; v1(94.1,66.13) 94.47,66.5 CPU1.AW66 ; v1(94.1,66.13) 94.4,65.83 CPU1.AY66 CPU1.BA66 ; CPU1.F4 130.24,83.87 130.43,83.67 130.47,83.67 v1(130.47,83.67) 130.47,83.67 130.66,83.87 CPU1.F2 CPU1.F1 ; CPU1.AW57 99.38,65.89 99.41,65.87 99.41,65.85 ; CPU1.K22 119.18,81.8 119.18,82.66 CPU1.G22 119.13,82.78 119.13,83.26 CPU1.F22 119.13,83.34 119.09,83.38 118.34,83.38 CPU1.F23 117.87,83.77 v1(117.87,84.43) ; CPU1.AL32 v1(114.19,71.77) ; v1(107.83,69.47) 107.83,69.01 CPU1.AR43 106.98,68.85 v1(106.86,68.85) 106.51,68.5 CPU1.AR45 CPU1.AR46 105.25,68.26 104.83,68.26 CPU1.AR48 104.5,68.5 v1(104.14,68.87) 103.93,68.66 103.93,68.66 103.77,68.5 CPU1.AR50 ; v1(107.83,69.47) 108.15,69.15 CPU1.AP42 108.24,69.03 108.22,69.01 108.22,68.61 108.24,68.59 CPU1.AR42 108.24,68.32 108.25,68.31 108.25,67.91 108.24,67.91 CPU1.AT42 ; v1(107.83,69.47) 108.16,69.8 CPU1.AN42 ; CPU1.AM60 98.32,70.45 v1(98.64,70.13) 98.97,69.8 CPU1.AN58 99.56,70.26 CPU1.AL58 ; v1(166.71,92.12) 166.92,91.91 GPU1.A30 ; CPU1.V18 121.86,76.9 CPU1.Y19 CPU1.Y20 120.47,76.25 120.44,76.28 119.98,76.28 119.95,76.25 CPU1.Y21 119.81,76.15 ; CPU1.V18 CPU1.T18 CPU1.T17 CPU1.P17 ; CPU1.AD13 125.15,73.97 125.48,73.97 v1(125.58,73.87) ; CPU1.G10 126.79,82.95 127.06,82.95 CPU1.F8 ; CPU1.D10 126.57,84.76 CPU1.D11 125.93,84.31 CPU1.E11 124.97,83.34 CPU1.F13 ; CPU1.D10 CPU1.B10 ; CPU1.D10 127,84.33 127,83.78 CPU1.F8 ; CPU1.AW6 128.75,65.87 128.78,65.85 v1(128.78,65.82) 128.78,65.74 128.79,65.72 CPU1.BA6 ; v1(113.23,82.99) 113.27,82.95 CPU1.J32 ; v1(113.23,82.99) 113.14,82.99 112.81,83.31 CPU1.F33 112.6,83.55 112.11,83.55 CPU1.F35 111.84,83.34 v1(111.44,82.94) 111.36,82.94 110.99,83.31 CPU1.F37 110.84,83.34 110.49,83.69 ; v1(113.23,82.99) 113.38,82.99 113.73,83.34 CPU1.F32 114.17,83.79 114.17,84.68 CPU1.D30 CPU1.B30 ; CPU1.L17 122.63,80.56 122.98,80.56 123.1,80.44 CPU1.L16 CPU1.K16 ; CPU1.K68 93.68,81.25 CPU1.K67 CPU1.K66 94.54,81.39 v1(94.89,81.04) 95.19,81.33 CPU1.K65 CPU1.K64 CPU1.K63 ; v1(105.08,83.01) 104.9,83.01 CPU1.G48 ; CPU1.B14 CPU1.D14 124.13,84.36 124,84.23 124,84.23 123.88,84.11 123.88,84.08 123.79,83.99 CPU1.E15 123.65,83.99 123.39,84.25 v1(123.32,84.25) 123.21,84.36 122.41,84.36 122.04,83.99 CPU1.E18 121.96,84.47 121.7,84.72 CPU1.D18 CPU1.B18 ; CPU1.AT28 115.56,67.98 115.55,67.99 115.55,68.38 115.56,68.39 CPU1.AR28 115.56,68.62 115.55,68.63 115.55,69.02 115.56,69.03 CPU1.AP28 ; v1(93.99,69.49) 93.58,69.08 CPU1.AP68 ; CPU1.E46 105.86,83.99 106.11,84.24 CPU1.D45 106.12,84.75 106.75,84.75 CPU1.D44 106.78,85.06 v1(106.61,85.24) 106.78,85.41 CPU1.B44 ; v1(187.6,91.8) 187.53,91.72 187.04,91.72 GPU1.A3 ; v1(113.44,87.39) 113.44,88.2 113.72,88.48 113.72,89.48 113.85,89.61 113.85,90.29 115.26,91.7 ; CPU1.AP10 126.23,68.94 v1(126.06,68.77) 125.88,68.77 CPU1.AR11 ; ED3603.8 ED3603.3 v1(17.27,24.24) ; CPU1.AM8 127.45,70.89 127.91,71.35 CPU1.AK8 ; CPU1.J11 125.95,81.05 CPU1.L11 125.95,80.67 126.28,80.34 v1(126.28,80.26) ; 93.92,70.68 93.64,70.96 93.64,71.05 93.26,71.44 CPU1.AK68 ; 93.92,70.68 CPU1.AM68 ; CPU1.BA10 126.37,65.79 v1(126.36,65.8) 126.37,65.82 CPU1.AW10 126.37,66.95 126.53,67.1 CPU1.AU10 ; v1(94.77,83.2) 94.46,82.89 94.41,82.89 CPU1.G66 ; CPU1.F68 CPU1.D69 92.54,84.37 v1(92.5,84.33) ; v1(103.21,82.94) 102.96,82.69 CPU1.G52 ; CPU1.AK68 93.26,71.69 CPU1.AH67 93.91,72.35 v1(93.51,72.75) ; CPU1.AK68 CPU1.AK69 ; CPU1.G60 98.31,82.69 v1(98.64,83.02) 98.97,82.69 CPU1.G58 ; CPU1.AW38 110.35,66.92 CPU1.AU38 109.23,66.36 CPU1.AW41 108.71,66.36 108.66,66.4 108.36,66.4 108.32,66.36 CPU1.AW43 107.48,66.36 107.44,66.4 107.13,66.4 107.09,66.36 CPU1.AW45 106.67,65.77 v1(106.67,65.76) 106.67,65.76 CPU1.BA45 ; v1(93.48,13.07) 93.48,12.86 93.48,12.85 93.48,11.4 DM1.188 ; CPU1.T21 119.91,77.85 120.23,77.53 v1(120.23,77.52) ; CPU1.D48 104.35,84.76 CPU1.D47 ; 127.86,83.62 127.58,83.34 CPU1.F8 ; 127.86,83.62 v1(127.9,83.67) 128.23,83.99 CPU1.E6 128.36,84.02 CPU1.D6 129.06,84.89 129.58,85.41 CPU1.C5 ; 127.86,83.62 127.86,83.16 128.33,82.69 CPU1.G6 ; U4003.3 214.61,45.22 215.06,45.67 215.06,47.18 v1(214.88,47.36) ; CPU1.AL55 100.93,70.47 CPU1.AM55 ; 101.86,66.36 102.28,66.36 102.32,66.4 102.63,66.4 102.67,66.36 CPU1.AW51 103.44,66.36 103.48,66.4 103.79,66.4 103.83,66.36 CPU1.AW49 104.7,66.36 104.74,66.4 105.05,66.4 105.09,66.36 CPU1.AW47 ; CPU1.K70 CPU1.K71 ; CPU1.AW32 114.57,66.36 114.61,66.4 114.92,66.4 114.96,66.36 CPU1.AW30 ; CPU1.AW32 114.1,65.84 v1(114.17,65.78) 114.1,65.72 CPU1.BA32 ; CPU1.BA62 96.9,65.76 v1(96.91,65.76) 96.9,65.77 CPU1.AW62 96.48,66.36 96.44,66.4 96.14,66.4 96.09,66.36 CPU1.AW64 ; v1(159.66,71.71) 159.61,71.71 159.13,71.23 EC1707.2 ; CPU1.BA36 111.75,65.27 v1(111.75,65.66) 111.75,66.24 CPU1.AW36 ; 111.12,90.28 112.27,89.14 112.27,87.11 ; CPU1.D26 117.33,84.72 CPU1.D25 CPU1.C25 ; CPU1.AW34 112.63,66.64 112.63,66.8 112.27,67.16 112.27,67.36 111.9,67.72 CPU1.AT35 CPU1.AR35 ; CPU1.AF2 CPU1.AF1 ; 120.85,66.65 CPU1.AW21 ; CPU1.BA18 v1(121.53,65.67) CPU1.AW18 ; CPU1.AW26 117.88,67.44 CPU1.AT23 ; CPU1.B53 101.83,85.86 102.17,86.2 102.17,86.52 102.16,86.53 102.16,86.96 102.36,87.16 v1(102.36,87.62) ; DM1.213 99.72,17.99 v1(99.67,17.94) ; CPU1.AV70 CPU1.AV69 ; v1(126.26,73.91) 126.31,73.85 126.31,73.63 126.55,73.4 CPU1.AF10 ; CPU1.D39 109.26,84.98 109.38,85.1 v1(109.38,85.22) 109.38,85.25 109.26,85.37 CPU1.B39 ; CPU1.D62 CPU1.B62 ; CPU1.W13 125.01,76.25 125.01,76.07 v1(125.02,76.06) ; 125.24,79.22 CPU1.N13 ; 125.24,79.22 v1(125.48,79.22) ; 125.24,79.22 125.14,79.22 CPU1.R13 ; 99.41,65.85 99.41,65.57 99.38,65.54 CPU1.BA57 ; 99.41,65.85 v1(99.41,65.85) ; v1(96.2,72.8) 96.02,72.63 96.02,72.5 CPU1.AH64 ; CPU1.P19 CPU1.P20 CPU1.P21 ; v1(100.4,84.35) 100.4,84.34 100.05,83.99 CPU1.E56 99.35,84.65 CPU1.D58 CPU1.B58 ; 102.08,65.73 101.86,65.5 CPU1.BA53
  BOTTOM w0.305: v1(52.22,17.61) 52.22,17.62 52.22,18.04 52.22,18.05 DM1.31 ; CPU1.AL55 v1(101.38,71.71) ; R722.2 v1(84.15,80.12) ; CPU1.T2 CPU1.T4 129.98,78.62 129.86,78.75 129.22,78.75 CPU1.R6 128.88,79.06 128.88,79.19 v1(128.85,79.22) 129,79.38 CPU1.N6 ; v1(166.11,16.62) 166.04,16.7 166,16.7 165.71,17 165.71,17.05 165.22,17.53 DM2.167 ; GPU1.K11 181.12,85.71 v1(180.83,85.42) ; v1(178.95,17.88) 179.22,18.15 DM2.223 ; DM1.251 109.22,19.6 109.22,17.94 v1(109.21,17.93) ; v1(153.4,70.47) 154.36,71.43 Q1702.4 154.81,71.45 155.14,71.78 155.14,72.27 155.62,72.75 Q1702.1 ; v1(183.33,17.64) 183.23,17.75 183.23,19.6 DM2.239 ; v1(144.32,86.17) 144.59,86.44 U4006.5 ; v1(255.75,28.66) 255.75,29.12 254.97,29.91 C9117.2 ; v1(30.78,56.81) 30.64,56.81 30.08,56.25 WLAN1.51 ; v1(180.01,14.36) 179.8,14.36 179.04,13.6 179.04,12.95 178.98,12.88 DM2.222 ; DM2.231 181.22,17.84 181.4,17.66 181.4,17.18 181.43,17.16 181.43,16.75 181.94,16.24 v1(182.19,16.24) ; v1(45.32,16.67) 45.19,16.67 43.91,17.95 43.91,19.03 44.47,19.6 DM1.1 ; R7936.2 191.63,81.04 191.63,81.65 R7820.2 ; v1(201.6,88.2) 201.27,87.87 198.31,87.87 C8045.2 ; v1(102.64,110.5) 102.9,110.5 103.14,110.75 WWAN1.27 ; DM1.192 94.48,13.38 95.38,14.29 95.43,14.29 95.61,14.46 v1(95.76,14.46) ; DM1.86 65.97,12.46 66.2,12.69 66.2,14.57 65.74,15.02 v1(65.57,15.02) ; v1(137.52,15.92) 137.47,15.92 136.72,16.67 DM2.61 ; CPU1.N10 126.6,79.9 126.44,80.07 126.44,80.11 v1(126.28,80.26) ; VRAM4.E2 v1(190.22,104.9) VRAM3.F9 190.81,105.3 v1(191.23,105.73) 190.86,106.1 VRAM4.G1 ; v1(134.52,15.5) 134.55,15.5 135.73,16.68 135.73,19.6 DM2.57 ; WLAN1.45 28.21,57.75 27.94,58.02 27.94,59.22 v1(27.91,59.25) WLAN1.39 ; WLAN1.18 37.52,64.5 v1(37.95,64.07) ; v1(139.72,18.02) 139.72,19.6 DM2.73 ; RN9601.3 76.27,67.28 75.65,66.66 74.93,66.66 v1(74.04,67.55) 74.46,67.97 RN9601.4 ; v1(131.09,17.89) 131.23,18.03 DM2.39 ; v1(56.6,13.17) 56.51,13.08 56.51,12.61 56.47,12.58 DM1.48 ; v1(94.44,17.26) 94.72,17.54 DM1.193 ; v1(142.56,16.63) 142.56,16.64 142.42,16.64 141.64,17.42 141.64,18.31 141.7,18.38 141.7,19.58 DM2.81 ; v1(46.86,13.07) 46.97,12.95 46.97,11.4 DM1.10 ; DM2.188 170.47,14.05 171.14,14.72 v1(171.14,14.84) ; DM2.180 v1(168.47,13.07) ; LCD1.36 42.15,76.45 41.91,76.69 41.91,77.2 v1(41.78,77.33) ; DM2.210 175.98,12.47 175.84,12.61 175.84,13.33 176.14,13.62 176.2,13.62 v1(176.35,13.78) ; v1(51.06,78.04) 51.06,77.99 50.65,77.58 LCD1.19 ; DM1.69 61.72,20.51 61.42,20.81 57.53,20.81 57.22,20.51 DM1.51 57.22,18.63 57.4,18.45 57.4,17.54 57.39,17.52 v1(57.39,17.45) ; DM1.206 97.98,11.4 97.98,13.09 v1(97.97,13.09) ; DM2.44 132.48,11.4 132.48,12.36 132.12,12.72 132.12,13.74 132.08,13.79 132.08,13.91 131.42,14.56 131.42,14.57 131.12,14.87 131.12,14.87 v1(130.91,15.07) ; v1(97.62,74.62) CPU1.AD62 96.31,74.62 CPU1.AE64 ; RN1301.2 84.33,54.12 84.05,54.4 C1301.2 83.12,54.4 v1(82.55,54.98) ; v1(191.26,51.29) 191.37,51.4 IOBD4.7 ; DM1.35 53.22,17.13 53.86,16.5 v1(53.91,16.5) ; DM1.94 v1(67.97,9.76) ; DM1.98 68.97,12.66 69.25,12.94 v1(69.97,12.94) ; CPU1.AM46 105.5,70.47 CPU1.AL48 v1(105.04,71.73) ; C9116.1 247.46,31.67 v1(247.4,31.74) ; v1(31.36,54.42) 31.36,54.28 30.88,53.81 30.52,53.81 29.96,53.25 WLAN1.63 ; v1(176.25,16.32) 176.04,16.52 176.04,16.52 175.74,16.82 175.74,16.83 175.64,16.93 175.64,19.51 DM2.209 ; v1(97.97,14.39) 97.79,14.39 96.98,13.57 96.98,12.63 96.97,12.63 DM1.202 ; DM1.39 54.22,18.15 54.03,17.96 v1(54.03,17.83) ; v1(37.99,61.7) 37.79,61.5 WLAN1.30 ; DM1.239 106.22,18.06 v1(106.38,17.91) ; DM1.176 90.47,12.43 90.3,12.61 90.3,13.4 90.07,13.63 90.07,13.93 90.11,13.97 90.11,14.02 90.52,14.43 91.17,14.43 v1(91.19,14.41) ; v1(128.87,77.02) 129.07,76.82 129.07,76.79 129.21,76.66 CPU1.W6 129.89,75.91 CPU1.AA4 CPU1.AA2 ; DM1.235 105.23,19.6 105.23,17.64 106.23,16.64 v1(106.38,16.64) 106.61,16.64 107.22,17.25 DM1.243 ; DM2.94 144.98,12.5 v1(144.41,13.06) 143.97,12.63 143.97,11.4 DM2.90 ; R9931.2 55.8,91.74 55.16,92.39 v1(54.86,92.39) ; v1(99.47,13.78) 99.28,13.78 98.94,13.44 98.94,12.62 98.98,12.58 98.98,11.4 DM1.210 ; CPU1.W13 124.56,76.69 123.55,76.69 CPU1.V16 ; DM2.185 169.73,20.74 169.34,21.13 168.91,21.13 168.73,20.95 168.73,19.6 DM2.181 168.73,18.68 168.32,18.27 168.32,16.97 168.3,16.96 168.3,16.78 167.54,16.01 167.36,16.01 v1(167.23,15.89) ; DM1.214 99.98,11.4 99.98,12.76 100.08,12.86 100.08,13.95 99.57,14.46 v1(99.44,14.46) ; DM1.81 64.72,19.6 64.72,18.06 64.66,17.99 64.66,17.02 65.38,16.29 v1(65.59,16.29) 65.78,16.29 66.73,17.24 DM1.89 ; VRAM1.B9 v1(161.13,102.1) ; DM2.248 185.48,13.26 185.81,13.6 185.89,13.6 v1(185.99,13.7) ; DM1.57 58.73,19.6 58.73,17.88 v1(58.69,17.84) ; DM2.60 136.47,12.57 136.49,12.58 136.49,13.53 136.47,13.55 136.47,13.8 135.91,14.36 v1(135.71,14.36) 135.42,14.36 134.42,13.36 134.42,12.9 134.48,12.85 134.48,11.4 DM2.52 ; v1(67.34,92.6) 67.45,92.48 67.45,90.76 67.5,90.72 67.5,89.33 68.12,88.7 IRCCD1.7 ; DM2.89 143.73,17.66 v1(143.79,17.6) ; v1(101.96,14.46) 102.06,14.36 102.09,14.36 102.98,13.48 102.98,11.4 DM1.226 ; v1(103.21,71.68) CPU1.AL52 ; v1(115.09,69.43) 115.36,69.15 CPU1.AP28 ; CPU1.AN38 110.16,69.8 110.33,69.97 110.34,69.97 v1(110.53,70.17) CPU1.AL38 ; GPU1.F12 180.52,88.7 v1(180.56,88.67) ; v1(268.67,18.47) 268.66,18.46 268.65,18.46 HDD1.4 ; DM2.99 146.23,18.66 145.49,17.93 v1(144.75,17.93) 144.73,17.95 DM2.93 ; DM1.103 70.23,19.6 70.23,17.93 69.6,17.3 v1(69.3,17.3) ; v1(107.37,15.48) 106.27,14.38 106.27,12.98 105.97,12.69 DM1.238 ; RN2009.2 139.95,78.65 140.28,78.98 140.28,79.17 v1(140.34,79.23) 140.26,79.3 RN2009.1 ; v1(102.52,115.9) 102.7,115.9 103.35,115.25 WWAN1.45 ; v1(97.21,17.05) 97.27,17.05 97.72,17.5 DM1.205 ; DM1.65 60.72,18.4 60.83,18.29 60.83,17.51 60.38,17.05 v1(60.27,17.05) ; HDD1.19 261.15,18.49 v1(261.37,18.27) 261.65,18.56 HDD1.18 ; v1(167.33,89.6) 167.34,89.6 167.72,89.98 GPU1.E28 ; DM2.40 131.47,12.45 131.47,12.45 131.47,13.11 131.42,13.16 131.42,13.27 131.12,13.57 131.01,13.57 v1(130.88,13.7) ; v1(63.73,17.71) 63.72,17.72 63.72,19.6 DM1.77 ; v1(126.98,13.07) 126.98,13.07 DM2.22 ; v1(101.98,15.86) 101.73,15.86 100.72,16.86 DM1.217 ; v1(56.57,14.56) 56.54,14.56 55.47,13.5 DM1.44 ; LCD1.16 52.15,76.95 52.36,77.16 v1(52.36,77.71) ; VRAM4.P1 v1(191.21,111.7) ; CPU1.AA68 v1(92.92,75.54) ; v1(124.72,13.08) 124.97,12.82 124.97,11.4 DM2.14 ; v1(174.7,15.76) 174.52,15.76 173.72,16.55 173.72,19.6 DM2.201 ; CPU1.AN40 109.25,69.8 v1(109.58,69.48) 109.79,69.27 109.81,69.27 109.93,69.15 CPU1.AP38 ; v1(53.9,15.2) 54.04,15.2 55.22,16.38 DM1.43 ; v1(140.56,15.29) 140.41,15.13 140.4,15.13 140.1,14.84 140.1,14.83 140.03,14.75 140.03,14.59 139.45,14.01 139.45,11.42 DM2.72 ; ED5702.3 ED5702.8 ; DM2.213 176.73,18.71 176.88,18.55 176.88,17.59 176.4,17.1 176.32,17.1 v1(176.25,17.03) ; CPU1.E65 95.06,84.05 CPU1.D66 ; v1(183.64,110.22) 183.76,110.1 VRAM4.M9 ; CPU1.U69 v1(92.27,77.37) CPU1.U70 ; DM1.244 107.48,13.39 v1(107.44,13.42) ; HDD1.8 v1(266.65,18.35) ; v1(266.65,18.35) 267.15,18.85 HDD1.7 ; v1(266.65,18.35) 266.15,18.85 HDD1.9 ; v1(137.54,17.26) 137.65,17.26 138.07,17.68 138.07,18.16 137.72,18.5 DM2.65 ; DM1.78 63.97,14.37 63.27,15.07 v1(62.58,15.07) ; v1(140.66,13.23) 140.98,12.91 DM2.78 ; v1(58.69,14.36) 58.44,14.36 57.47,13.39 DM1.52 ; v1(168.76,102.08) 168.74,102.1 VRAM1.B1 ; DM2.98 145.98,12.87 146.04,12.93 v1(146.04,13.06) ; v1(96.85,69.48) 96.68,69.48 CPU1.AP63 ; v1(183.32,79.77) 183.32,79.8 GPU1.U9 ; R1719.2 EC1708.2 EC1715.2 92.27,92.61 91.92,92.95 v1(91.92,93.14) ; v1(123.9,15.99) 124.18,15.99 125.23,17.03 DM2.15 ; v1(123.9,17.89) 123.72,18.06 DM2.9 ; v1(116.08,95.82) 116.08,95.62 115.34,94.88 C1802.1 ; v1(97.21,15.63) 97.03,15.81 96.99,15.81 96.63,16.16 96.63,16.17 96.63,18.49 96.72,18.58 DM1.201 ; v1(167.18,17.82) 167.22,17.86 DM2.175 ; v1(178.51,14.04) 178.44,14.04 177.98,13.57 DM2.218 ; GPU1.P6 185.41,82.8 185.88,82.8 185.88,82.8 v1(185.9,82.8) ; VRAM1.P9 v1(161.19,111.7) ; DM1.9 46.73,19.6 46.73,18.41 46.99,18.15 v1(46.99,18.07) ; v1(126.98,14.46) 126.8,14.29 126.73,14.29 125.97,13.53 125.97,11.4 DM2.18 ; v1(45.35,13.78) 45.45,13.78 45.97,13.25 45.97,11.4 DM1.6 ; v1(99.64,71.77) 99.56,71.68 CPU1.AL58 ; DM1.209 98.72,18.68 98.7,18.65 98.7,17.36 99.44,16.62 v1(99.69,16.62) ; CPU1.V17 CPU1.Y17 123.16,75.6 CPU1.AB16 ; v1(52.29,15.03) 52.39,14.93 52.52,14.93 53.21,14.24 53.21,14.24 53.38,14.07 53.38,12.85 53.47,12.75 DM1.36 ; GPU1.K2 v1(187.92,86) ; v1(176.32,14.41) 176.37,14.36 176.65,14.36 176.98,14.04 DM2.214 ; v1(100.98,14.73) 100.98,14.04 100.82,13.89 100.82,13.47 100.98,13.31 100.98,11.4 DM1.218 ; v1(99.51,68.15) 99.71,68.15 CPU1.AT56 ; v1(99.51,68.15) 99.35,68.31 99.31,68.31 99.12,68.5 CPU1.AR58 ; v1(99.51,68.15) 99.4,68.15 CPU1.AT58 ; v1(174.12,89.73) GPU1.F20 ; EC1701.2 R405.2 EC1710.1 R604.2 82.93,86.79 82.8,86.79 82.49,86.47 v1(82.47,86.47) ; v1(52.18,13.07) 51.98,12.86 DM1.30 ; v1(191.26,102.08) 191.24,102.1 VRAM4.B1 ; DM2.5 122.72,18.26 v1(122.35,17.89) ; CPU1.D62 96.87,83.76 v1(96.8,83.69) ; v1(101.9,13.12) 101.9,13.08 101.97,13.01 101.97,11.4 DM1.222 ; v1(132.88,13.57) 133.47,12.98 DM2.48 ; v1(183.69,113.3) VRAM4.T9 ; CPU1.J13 124.7,81.39 124.89,81.2 125.42,81.2 CPU1.J11 ; DM2.238 182.97,12.84 183,12.86 183,13.87 v1(184.48,15.35) ; CPU1.AB8 v1(127.68,75) 127.71,74.94 CPU1.AD8 ; v1(70.82,17.94) 70.97,17.94 71.23,18.19 71.23,19.6 DM1.107 ; WLAN1.75 30.2,50.25 v1(31.11,51.17) ; DM1.230 103.98,11.4 103.98,13.04 v1(104.02,13.09) ; DM2.68 138.47,13.58 137.74,14.32 137.69,14.32 v1(137.52,14.5) ; GPU1.N18 175.7,83.38 175.89,83.57 176.07,83.57 v1(176.1,83.54) ; v1(142.59,17.92) 142.72,18.06 142.72,19.6 DM2.85 ; CPU1.U66 v1(94.22,77.37) CPU1.U67 ; DM2.192 171.48,13.32 v1(171.32,13.47) ; CPU1.AK63 96.51,71.37 95.86,70.72 CPU1.AL64 ; v1(142.59,15.36) 142.79,15.17 142.8,15.17 143.18,14.8 143.18,12.73 142.98,12.53 DM2.86 ; CPU1.AD19 121.86,75.22 121.86,75.23 ; WLAN1.23 27.79,63.25 v1(27.56,63.49) ; v1(135.71,13.07) 135.66,13.07 135.47,12.88 DM2.56 ; DM2.251 186.23,19.6 186.23,18.11 186.18,18.07 v1(186.18,17.94) ; C2403.2 203.26,25.22 v1(203.07,25.03) ; CPU1.AR5 129.44,68.5 CPU1.AT4 ; v1(165.23,90.53) 165.24,90.54 165.4,90.54 165.62,90.76 166.08,90.76 GPU1.C32 ; EC1803.1 123.57,53.01 123.57,51.67 v1(123.06,51.17) ; CPU1.AH6 129.21,72.12 v1(128.89,71.81) ; DM1.227 103.22,17.49 104.05,16.67 v1(104.2,16.67) ; v1(91.25,15.8) 91.25,15.81 90.07,16.99 90.07,18.43 90.22,18.59 DM1.175 ; v1(146.97,13.06) 146.97,13.03 146.98,13.02 DM2.102 ; CPU1.D34 111.54,84.92 v1(111.54,85.21) 111.74,85.41 CPU1.B34 ; v1(88.89,17.94) 88.98,18.03 88.98,18.42 89.22,18.67 DM1.171 ; GPU1.K22 172.68,86 172.34,86.35 v1(172.24,86.35) ; R9605.1 67.6,79.02 v1(66.98,79.64) ; G1801.1 138.26,48.56 C1805.2 ; DM2.27 128.23,17.53 128.37,17.39 129.2,16.56 v1(129.24,16.56) ; v1(55.88,16.77) 55.96,16.77 56.64,17.45 56.64,18.13 56.22,18.54 DM1.47 ; WLAN1.7 29.12,66.16 v1(29.53,65.76) ; v1(69.97,12.94) 70.73,12.94 70.97,12.7 DM1.106 ; v1(69.97,12.94) DM1.102 ; DM2.64 137.51,11.44 137.51,12.85 137.52,12.86 v1(137.52,13.07) ; v1(156.97,68.82) 157.32,69.16 X7901.4 ; DM2.206 174.98,13.45 174.57,13.85 v1(174.44,13.85) ; DM1.19 49.22,18.44 49.2,18.41 49.2,17.66 49.56,17.3 v1(49.73,17.3) 49.94,17.3 50.27,17.63 50.27,18.28 50.22,18.33 DM1.23 ; v1(122.31,16.51) 122.01,16.51 121.43,17.1 121.43,17.4 121.35,17.48 121.35,18.39 121.43,18.46 121.43,18.47 121.73,18.77 121.73,19.6 DM2.1 ; DM2.10 123.98,12.52 123.8,12.7 123.8,13 123.75,13.05 123.75,13.65 123.19,14.21 v1(123.19,14.72) ; DM1.181 91.72,18.64 91.65,18.57 91.65,18.49 91.25,18.08 v1(91.25,17.91) ; CPU1.G55 101,82.69 101.32,83.01 v1(101.35,83.01) ; v1(88.89,14.99) 88.75,14.99 88.31,14.55 88.31,12.8 88.48,12.63 88.48,11.4 DM1.168 ; v1(115.09,70.14) 115.22,70.14 CPU1.AN28 ; v1(153.96,85.96) 153.85,86.08 U4005.3 ; DM2.51 134.23,18.57 134.46,18.33 134.46,17.7 v1(134.46,17.69) ; CPU1.J38 v1(109.61,81.52) ; v1(127.18,122.08) 127.64,122.54 127.64,123.18 128.27,123.81 FC9723.2 FC9724.2 ; DM2.243 184.22,17.13 183.46,16.37 v1(183.33,16.37) ; C1801.1 111.79,95.47 v1(111.79,95.54) ; CPU1.AN35 112.01,69.8 112.18,69.98 112.19,69.98 v1(112.36,70.14) CPU1.AL35 ; v1(92.84,15.73) 92.71,15.73 92.33,16.11 92.33,17.89 92.72,18.29 DM1.185 ; DM2.205 174.73,17.74 v1(174.71,17.72) ; VRAM1.G9 161.41,106.1 v1(161.04,105.73) ; v1(161.19,113.3) VRAM1.T9 ; 48.15,76.96 v1(48.15,77.06) ; 48.15,76.96 LCD1.24 ; 48.15,76.96 47.65,76.46 LCD1.25 ; v1(172.72,17.93) 172.72,18.13 172.73,18.13 DM2.197 ; v1(128.98,15.1) 129.27,15.1 130.36,14.01 130.36,12.73 130.47,12.62 DM2.36 ; DM2.189 170.73,18.49 169.39,17.16 v1(169.08,17.16) ; ED5703.3 ED5703.8 ; DM2.252 186.48,12.5 186.59,12.62 186.59,14.5 v1(186.07,15.02) ; DM1.184 92.47,13.49 93.33,14.34 v1(93.48,14.34) ; v1(122.34,15.1) 122.28,15.1 121.79,14.61 121.79,12.66 121.98,12.47 DM2.2 ; CPU1.U10 126.6,77.63 126.97,77.26 v1(126.97,77.08) 126.97,76.88 CPU1.W9 ; v1(27.66,62.22) 27.81,62.22 28.28,61.75 WLAN1.29 ; DM1.14 47.97,11.4 47.97,12.6 47.9,12.67 47.9,13.32 v1(48.41,13.83) 48.97,13.27 48.97,11.4 DM1.18 ; v1(131.05,16.62) 130.97,16.62 130.23,17.36 DM2.35 ; v1(170.91,17.05) 171.12,17.05 171.73,17.66 DM2.193 ; DM2.23 127.23,18.36 127.32,18.27 127.32,17.7 127,17.39 126.93,17.39 v1(126.81,17.27) ; v1(122.35,13.78) 122.46,13.78 122.97,13.26 122.97,11.4 DM2.6 ; VRAM1.J2 v1(166.92,108.1) ; DM1.248 108.48,12.3 108.46,12.32 108.46,13.23 108.99,13.76 v1(108.99,13.8) ; v1(93.57,79.19) CPU1.N68 93.65,80.05 94.81,80.05 CPU1.N65 ; CPU1.AL45 107.33,70.47 CPU1.AM43 ; CPU1.AL45 106.87,70.91 CPU1.AM45 ; CPU1.AL45 v1(106.87,71.74) ; CPU1.U63 v1(96.17,77.37) CPU1.U64 ; VRAM1.J8 v1(162.92,108.1) ; DM2.31 129.23,17.99 v1(129.3,17.92) ; VRAM4.J2 v1(189.42,108.1) ; CPU1.AW55 100.25,66.36 100.18,66.43 100.05,66.43 99.95,66.53 99.55,66.53 CPU1.AW57 ; CPU1.G5 129.49,82.69 129.73,82.46 v1(129.77,82.46) ; v1(62.58,13.06) 62.47,12.96 DM1.72 ; WWAN1.11 104.18,107.46 v1(104.27,107.55) ; v1(104.25,17.94) 104.23,17.96 104.23,19.6 DM1.231 ; v1(103.2,84.31) 103.35,84.31 CPU1.E50 ; v1(60.3,15.76) 60.1,15.76 59.72,16.13 59.72,17.68 59.72,17.68 59.72,18.1 59.72,18.11 DM1.61 ; DM1.234 104.97,13.76 104.25,14.48 v1(104.02,14.48) ; v1(50.55,14.01) 49.89,13.35 49.89,11.49 DM1.22 ; VRAM2.G8 v1(167.72,105.7) ; v1(172.63,15.17) 172.97,15.17 173.81,14.34 173.81,12.76 173.98,12.6 DM2.202 ; DM2.103 147.23,18.11 147.14,18.02 v1(147.14,17.89) 147.52,17.89 148.23,18.6 DM2.107 ; v1(45.32,17.94) 45.32,18.07 45.72,18.48 DM1.5 ; DM2.171 166.22,17.9 v1(166.21,17.89) ; R7902.1 193.61,90.6 193.9,90.31 193.9,89.04 194.06,88.89 v1(194.06,88.63) ; C3511.2 21.02,34.42 v1(21.02,33.7) ; GPU1.H20 173.92,87.56 173.64,87.28 v1(173.35,87.28) ; DM1.73 62.72,19.6 62.72,17.35 v1(62.66,17.28) ; v1(220.7,55.33) 219.91,55.33 219.38,54.8 218.09,54.8 PWSW2.6 ; v1(109.07,16.44) 108.9,16.62 108.85,16.62 108.23,17.25 108.23,19.6 DM1.247 ; v1(38.35,60.31) 38.27,60.31 37.96,60 WLAN1.36 ; DM1.99 69.23,19.6 69.23,18.01 v1(69.3,17.94) 68.13,17.94 67.73,18.34 DM1.93 ; R2721.2 28.54,15.52 v1(28.32,15.73) ; DM1.85 65.72,19.6 65.72,17.7 v1(65.59,17.56) ; DM2.43 132.23,17 132.7,16.52 v1(132.97,16.52) ; VRAM1.M1 v1(168.71,110.1) ; v1(179.35,73.45) 179.33,73.47 179.27,73.47 178.74,74 GPU1.AE14 ; DM1.172 89.47,13.26 89.01,13.72 v1(88.89,13.72) ; DM2.47 133.23,18.32 133.51,18.04 133.51,17.59 133.19,17.28 133.15,17.28 133.02,17.16 v1(132.99,17.16) ; U5501.2 61.98,86.85 v1(62.1,86.98) ; CPU1.AN30 114.56,69.8 114.39,69.97 114.34,69.97 v1(114.17,70.14) 114.01,69.97 113.98,69.97 113.81,69.8 CPU1.AN32 ; v1(51.7,16.39) 51.59,16.39 51.22,16.76 DM1.27 ; VRAM3.A9 v1(190.62,100.75) ; CPU1.AM13 124.94,70.22 125.12,70.22 125.13,70.2 v1(125.14,70.2) 125.15,70.2 125.15,70.66 125.78,71.3 125.78,71.3 125.88,71.39 CPU1.AK11 126.4,71.84 127.57,71.84 v1(127.59,71.85) 127.59,71.71 CPU1.AK8 ; DM2.226 179.98,12.96 180.05,13.04 v1(180.05,13.06) ; DM2.217 177.73,16.72 178.62,15.82 v1(178.9,15.82) ; DM2.106 147.98,12.41 147.74,12.65 147.74,13.12 147.09,13.77 v1(147,13.77) ; VRAM2.D8 v1(166.92,103.3) ; Q1701.1 153.4,67.64 153.01,67.24 v1(153.01,67.05) ; DM1.223 102.22,18.12 v1(102.01,17.91) ; VRAM4.P9 v1(183.69,111.7) ; DM1.180 91.47,12.79 v1(91.25,13.02) ; v1(94.36,15.73) 94.36,15.78 94.87,16.28 94.87,16.37 95.72,17.22 DM1.197 ; R1309.2 86.61,53.33 86.09,52.8 82.95,52.8 v1(81.66,54.09) ; VRAM4.G9 183.91,106.1 v1(183.54,105.73) ; v1(138.99,121.47) 138.96,121.5 138.96,122.18 139.32,122.54 PU5001.6 ; v1(95.76,13.07) 95.61,12.92 95.61,12.76 95.48,12.62 DM1.196 ; VRAM1.M9 v1(161.19,110.1) ; DM2.184 v1(169.47,13.43) ; CPU1.F42 108.73,83.62 109.16,83.36 CPU1.F40 v1(109.61,82.94) CPU1.F38 110.49,83.69 ; ED3202.8 v1(33.66,95.87) ; DM1.15 48.22,18.59 48.41,18.41 48.41,16.99 47.48,16.06 v1(46.96,16.06) ; VRAM4.B9 v1(183.63,102.1) ; v1(184.48,13.19) DM2.244 ; CPU1.J42 v1(107.79,82.92) ; CPU1.AD13 124.65,74.56 CPU1.AB15 CPU1.AB16 ; v1(180.67,17) 180.64,17 180.22,17.43 180.22,19.59 DM2.227 ; CPU1.AL2 CPU1.AL4 ; VRAM3.D1 183.99,103.7 v1(183.59,104.1) 183.99,104.5 VRAM3.E1 ; DM2.19 126.23,16.17 126.51,15.89 v1(126.82,15.89) 127.02,15.89 127.98,14.93 DM2.26 ; WLAN1.1 29.12,69.08 WLAN1.76 ; DM1.189 93.72,17.76 92.96,17 v1(92.84,17) ; GPU1.F18 175.72,88.63 v1(175.75,88.59) ; v1(45.35,15.2) 45.18,15.02 45.13,15.02 44.69,14.58 44.69,12.76 44.98,12.47 DM1.2 ; CPU1.AG21 119.89,72.89 119.8,72.8 119.11,72.8 118.86,72.55 118.86,71.75 119.22,71.4 CPU1.AK22 119.73,71.39 CPU1.AK21 120.13,70.99 CPU1.AM21 ; ED5701.3 ED5701.8 ; VRAM4.E8 v1(184.62,104.1) ; WLAN1.69 v1(27.94,51.75) ; CPU1.T18 121.72,78.06 121.72,78.15 121.21,78.66 CPU1.P19 CPU1.N19 ; GPU1.AH28 v1(167.32,71.2) ; VRAM1.G1 168.36,106.1 v1(168.73,105.73) 168.31,105.3 VRAM2.F9 v1(167.72,104.9) VRAM1.E2 ; VRAM2.D1 161.49,103.7 v1(161.09,104.1) 161.49,104.5 VRAM2.E1 ; v1(61.42,14.84) 61.24,14.84 60.47,14.08 DM1.64 ; v1(187.58,51.67) 187.58,52.31 188.17,52.9 IOBD4.4 ; CPU1.AB16 CPU1.AD16 122.76,74.97 122.53,74.97 122.52,74.98 122.11,74.98 121.86,75.23 ; DM1.26 v1(50.98,9.9) ; v1(142.6,13.95) 141.98,13.33 DM2.82 ; DM2.30 v1(128.98,13.07) ; VRAM1.E8 v1(162.12,104.1) ; DM2.230 180.98,12.99 v1(181.06,13.08) ; v1(58.04,10.15) 58.22,10.15 58.47,10.4 DM1.56 ; X7901.2 159.35,68.02 159.39,68.02 159.68,68.31 v1(159.77,68.31) ; HDD1.1 270.15,19.43 v1(270.76,18.81) ; 143.51,62.47 139.72,62.47 HCPU4.1 ; WLAN1.24 37.77,63 v1(38,63.23) ; WWAN1.71 102.84,121.75 102.77,121.68 v1(102.64,121.68) 102.64,121.88 103.01,122.25 WWAN1.73 ; CPU1.J28 115.1,83.01 115.1,83.02 v1(115.1,83.04) 115.12,83.04 115.42,83.34 CPU1.F28 115.77,83.55 116.26,83.55 CPU1.F27 ; v1(168.71,113.3) VRAM1.T1 ; 121.86,75.23 CPU1.AB18 ; v1(53.92,13.7) 54.02,13.7 54.12,13.6 54.14,13.6 54.45,13.29 54.45,13.27 54.47,13.24 DM1.40 ; v1(172.56,13.17) 172.56,13.01 172.48,12.92 DM2.196 ; v1(189.48,48.37) 191.51,48.37 191.54,48.4 IOBD4.13 ; CPU1.AR8 127.21,68.5 v1(126.99,68.73) ; DM2.234 181.97,13.57 181.18,14.36 v1(181.06,14.36) ; VRAM1.P1 v1(168.71,111.7) ; v1(53.31,80.54) 53.65,80.19 LCD1.13 ; CPU1.G63 96.1,82.75 95.84,82.49 CPU1.K64 ; VRAM3.D8 v1(189.42,103.3) ; v1(150.27,85.1) 149.77,85.6 C4034.2 ; v1(191.26,49.9) 191.27,49.9 IOBD4.10 ; DM1.90 v1(66.97,10.15) ; CPU1.AH63 96.51,72.49 v1(96.2,72.8) 96.51,73.11 CPU1.AF63 ; v1(165.93,13.83) 166.47,13.29 DM2.172 ; WLAN1.33 28.13,60.75 27.94,60.56 v1(27.91,60.56) ; DM2.168 165.47,12.51 165.17,12.81 165.17,14.59 165.81,15.23 v1(165.93,15.23) ; CPU1.AA65 v1(94.87,75.54) ; v1(65.57,13.75) 65.47,13.75 64.97,13.26 DM1.82 ; CPU1.L8 127.45,81.2 CPU1.J8 127.13,81.71 127.06,81.71 v1(127.04,81.73) ; CPU1.AN37 111.03,69.8 v1(111.43,69.4) 111.68,69.15 CPU1.AP35 ; v1(278.51,37.58) 278,37.07 ED3701.2 ; WLAN1.57 30.13,54.75 30.73,55.36 30.73,55.52 30.78,55.57 v1(30.78,55.51) ; v1(191.21,113.3) VRAM4.T1 ; CPU1.AP32 113.61,69.15 113.45,69.31 113.45,69.31 v1(113.26,69.5) 112.96,69.8 CPU1.AN33 ; v1(168.47,15.1) 167.47,14.1 DM2.176 ; DM2.77 140.73,16.81 140.03,16.11 v1(139.77,16.11) 139.65,16.11 138.88,16.88 138.88,18.53 138.72,18.69 DM2.69 ; v1(191.26,110.35) 191.01,110.1 VRAM4.M1 ; VRAM3.G8 v1(190.22,105.7) ; v1(186.13,16.62) 185.95,16.8 185.91,16.8 185.22,17.48 DM2.247 ; DM1.252 109.48,12.5 109.59,12.62 109.59,14.77 109.27,15.1 v1(109.07,15.1) ; VRAM2.B3 163.73,101.69 v1(163.73,101.69) ; v1(59.47,10.15) DM1.60 ; VRAM3.B3 186.23,101.69 186.23,101.5 186.25,101.48 186.25,101.12 186.23,101.1 v1(186.23,100.67) ; DM1.68 v1(61.47,13.47) ; v1(88.89,16.54) 88.81,16.62 88.81,16.66 88.38,17.09 88.38,17.31 87.88,17.8 87.88,18.32 88.22,18.66 DM1.167 ; DM2.235 v1(182.22,17.64) ; LCD1.29 v1(45.65,77) ; CPU1.J25 v1(116.93,81.29) ; VRAM4.J8 v1(185.42,108.1) ; VRAM2.A9 v1(168.12,100.75)
  BOTTOM w0.356: v1(167.97,84.95) 168.27,84.95 GPU1.L27 ; GPU1.C1 188.26,90.8 v1(188.36,90.9) ; GPU1.H6 184.91,88.01 v1(184.91,88.04) ; GPU1.F16 177.34,89.22 v1(177.34,89.76) ; GPU1.H17 176.55,87.83 v1(176.97,87.83) ; GPU1.AG27 168.57,72.4 168.89,72.08 v1(168.89,71.94) ; GPU1.F22 172.5,89.2 v1(172.13,89.57) ; GPU1.F8 183.72,89.2 v1(184.12,88.8) GPU1.G8 ; v1(165.68,86.79) 165.7,86.8 166.15,86.8 GPU1.J31 ; GPU1.F24 170.75,89.37 v1(170.75,89.82) ; v1(184.16,84.53) 185.19,84.53 GPU1.M6 ; v1(173.98,77.89) 174.49,78.4 GPU1.Y20 ; GPU1.F6 185.45,89.33 185.57,89.33 185.74,89.5 v1(185.76,89.5) ; PQ8604.4 179.31,65.43 v1(179.78,65.9) ; v1(183.36,83.24) 183.36,83.23 182.92,82.8 GPU1.P9 ; GPU1.F10 GPU1.G10 182.13,88.4 v1(182.51,88.01) ; C3107.2 47.42,92.44 v1(47.07,92.44) ; v1(181.57,71.82) 181.78,71.6 GPU1.AH10 ; GPU1.AG12 180.12,72 180.12,71.93 v1(179.93,71.74) ; GPU1.T6 185.32,81.16 184.99,80.83 v1(184.91,80.83) ; GPU1.M12 180.13,84.39 v1(179.82,84.39) ; GPU1.G27 168.53,88.4 v1(168.93,88.8) 169.32,89.19 GPU1.F26 ; GPU1.K28 167.72,86.15 v1(168.02,86.44) 168.37,86.8 GPU1.J27 ; v1(165.53,88.5) 165.77,88.5 165.81,88.46 166.46,88.46 GPU1.G31 ; GPU1.H14 178.75,87.6 179.27,88.12 v1(179.32,88.12) ; v1(178.55,89.62) 178.55,89.59 178.92,89.22 GPU1.F14 ; GPU1.K6 184.92,86.4 v1(184.92,86.41) 184.53,86.8 GPU1.J7 ; v1(201.8,110.73) 201.81,110.73 THM263.5 ; v1(168.12,74.38) 168.36,74.14 168.38,74.14 GPU1.AE27 ; GPU1.K32 165.91,85.79 165.61,85.79 v1(165.35,85.53)
  BOTTOM w0.381: C2601.2 79.71,98.03 78.52,98.03 C2602.2 ; EC2506.2 170.75,47.74 170.29,48.21 169.46,48.21 168.99,47.74 SPI252.4 ; v1(114.14,56.83) 114.11,56.86 114.02,56.86 112.87,58.01 112.87,58.72 ; v1(115.32,116.83) 115.89,116.25 PR4656.1
  BOTTOM w0.406: v1(15.95,51.81) 15.96,51.8 ED3601.3 ED3601.8 ; v1(24.64,63.23) 24.64,63.1 23.01,61.48 C3404.2 ; ED5701.8 v1(18.16,64.76) ; ED3201.8 v1(40.13,85.2) ; ED5702.8 v1(18.16,69.07) ; v1(156.84,69.58) 156.61,69.34 Q1701.4 ; v1(18.34,74.41) 18.29,74.46 ED5703.8 ; v1(42.17,25.39) 44.28,27.5 DM1.262 ; v1(52.21,87.76) 52.12,87.76 FC9738.2 ; EC1901.1 113.41,48.54 v1(113.41,49.57) FC1901.2 ; v1(181.23,62.93) 181.1,62.8 PQ8604.1 ; v1(103.76,4.63) C6701.2 ; v1(161.54,63.11) U4002.5
  BOTTOM w0.457: v1(184.44,57.76) 184.44,58.19 PC8605.2
  BOTTOM w0.508: v1(240.66,38.34) 240.09,37.77 ED4304.1 ; EC9736.2 142.38,83.94 v1(142.62,84.19) 143,84.19 144.07,83.12 PC1039.2 PC1038.2 ; C4016.2 162.66,58.66 v1(161.42,58.66) ; 115.26,91.7 116.92,93.36 116.92,96.81 v1(116.84,96.89) 116.84,98.79 116.05,99.58 111,99.58 110.62,99.2 v1(110.62,98.28) 110.62,93.33 111.12,92.82 111.12,90.28 ; v1(163.75,83.65) 163.74,83.64 R7814.2 C7801.1 ; v1(199.44,25.03) 199.53,24.94 C2405.2 ; C4012.2 134.9,97.78 135.48,97.78 138.27,94.99 HCPU2.1 136.86,91.8 136.54,92.12 EC1805.2 ; PC8607.2 174.94,60.68 v1(175.16,60.46) ; v1(168.71,113.3) 168.71,115.89 167.96,116.63 C8139.2 ; FC9707.2 111.82,4.39 v1(111.79,4.35) ; v1(67.56,72.88) 67.37,72.69 C9603.2 ; EC6502.2 126.96,9.19 v1(127.1,9.33) ; PC1037.2 161.01,62.57 v1(161.54,63.11) ; C716.2 128.47,94.85 129.92,93.41 v1(129.92,93.05) 129.44,92.57 R1904.1 EC1903.2 ; v1(77.57,6.17) 77.57,5.86 78.55,4.87 C9111.2 ; C1224.2 C1327.2 C1223.2 ; PC4808.2 117.42,114.29 117.49,114.35 v1(117.67,114.35) ; v1(190.65,81.75) 190.68,81.77 R7820.2 ; EC6001.2 266.16,26.21 266.6,25.77 266.6,25.66 v1(266.67,25.59) ; v1(84.66,5.9) 85.62,4.94 C9109.2 ; v1(200.34,21.12) 200.28,21.19 C2406.2 200.32,21.93 200.51,21.93 200.66,22.08 C2413.2 ; EC3101.1 27.11,82.6 v1(26.54,83.17) ; C5536.1 C5538.2 63.44,81.33 62.87,80.76 v1(62.87,80.62) 62.86,80.1 62.05,79.28 LCD1.41 ; C1223.2 C1227.2 187.9,6.14 186.94,5.19 186.03,5.19 C1324.2 185.95,4.71 v1(186.46,4.2) ; C1223.2 189.62,7.3 R1307.2 ; v1(70.64,85.7) 70.61,85.74 70.56,85.74 70.28,86.02 70.28,86.18 C2610.2 70.07,87.18 EC1704.2 ; v1(173.63,111.6) 173.58,111.6 173.06,112.11 C8153.2 173.01,112.56 C8149.2 C8151.2 ; PC5001.2 144.81,122.57 v1(145.24,123) ; RTC1.2 228.82,43 v1(229.36,43.55) ; FC6001.2 183.73,56.21 v1(183.48,55.95) ; EC2505.2 158.18,48.31 158.98,47.51 v1(159.46,47.51) ; 146.44,69.76 R2019.2 ; 146.44,69.76 148.39,69.76 148.72,70.09 v1(149.48,70.09) ; 146.44,69.76 145.21,69.76 C1183.2 ; HDMI1.20 10.55,62.89 ; HDMI1.20 10.55,60.91 ; HDMI1.20 11.99,61.9 ; PR8676.2 205.16,116.09 v1(205.69,115.56) 206.12,115.99 PR8671.2 ; R3105.2 49.78,94.85 v1(50.22,94.42) 50.28,94.49 FC9706.2 ; EC3103.1 EC3102.1 v1(28.13,85.27) ; C2620.2 201.17,112.63 v1(200.79,113.02) ; C2725.2 36.82,2.16 v1(36.8,2.14) ; v1(101.65,103.28) 101.78,103.15 WWAN1.76 ; R1825.2 v1(133.85,66.7) ; v1(27.99,8.47) 27.1,7.58 SPK1.6 ; R7943.1 149.54,61.62 v1(147.6,59.68) ; EC9734.2 v1(159.78,58.67) ; v1(58.61,74.09) 57.59,73.07 FC9727.2 ; C6501.2 v1(184.21,50.34) ; R1209.2 89.92,9.41 90.53,10.02 92.43,10.02 v1(92.48,10.07) ; Q5701.S 27.11,77.5 R5709.1 27.11,78.28 v1(27.3,78.47) ; EC1802.2 132.58,55.05 EC1801.2 132.77,54.89 v1(132.77,54.37) ; C2104.2 109.16,95.63 v1(108.2,96.58) ; SKT25.4 154.85,53.49 v1(154.18,52.82) ; EC2002.2 142.18,79.61 143.26,79.61 v1(143.56,79.92) 143.64,80 C1175.2 ; v1(178.82,103.87) 178.94,103.74 179.77,103.74 C8220.2 ; v1(133.02,93.1) 133.01,93.09 EC1702.2 R1717.2 131.32,93.56 131.8,94.04 EC1706.2 ; v1(139.34,48.04) 138.91,47.61 C1805.2 EC1807.2 ; v1(248.37,24.43) C6010.2 ; v1(17.27,80.63) 17,80.36 D5702.1 ; 13.62,57.39 USB1.10 13.62,55.61 ; v1(155.4,87.56) 155.38,87.55 C4014.2 ; 37.67,77.5 36.99,76.82 v1(36.58,76.82) ; 37.67,77.5 LCD1.45 39.7,79.45 LCD1.44 ; 37.67,77.5 v1(36.73,78.45) ; 5.49,78.3 HDMI1.23 4.05,79.29 ; PWSW2.5 217.93,50.1 v1(218.47,50.63) ; HDD1.31 274.47,21.5 274.67,21.7 v1(274.7,21.7) ; IOBD3.19 283.9,44.68 v1(282.35,46.24) ; v1(270.46,27.82) 270.68,27.61 EC9201.1 ; PC8604.2 PC8605.2 ; v1(201.7,92.14) 201.27,91.7 C8053.2 200.35,91.7 199.81,91.01 C8054.2 ; 13.62,42.81 USB1.11 13.62,44.59 ; v1(238.76,30.59) 239.2,31.04 EC9735.2 ; HDMI1.21 11.99,76.4 ; HDMI1.21 10.55,77.39 ; HDMI1.21 10.55,75.41 ; R605.2 v1(84.38,84.69) ; v1(209.8,33.26) EC2401.2 208.97,33.96 R2499.2 ; 247.97,13 H4.1 251.4,16.43 ; v1(151.64,83.77) 151.86,83.77 152.34,84.25 EC4001.2 ; C1319.2 111.29,55.21 v1(110.37,56.13) ; C8204.2 179.81,116.04 179.13,115.36 C8201.2 178.56,114.48 v1(178.56,113.65) ; C2622.2 v1(208.41,106.79) 208.41,106.36 C2621.2 ; 14.02,76.31 15.49,76.31 16.08,76.9 R5705.2 ; R9148.2 248.92,27.19 v1(249.68,27.95) ; R2447.2 v1(24.13,60.31) ; C5507.2 C5506.2 49.86,82.04 49.86,82.51 v1(49.99,82.64) ; v1(153.4,70.47) 153.26,70.47 153.01,70.22 EC1712.2 ; C9110.2 84.99,8.18 84.96,8.18 v1(84.96,8.77) ; 176.15,66.18 176.2,66.13 176.2,65.9 176.48,65.62 176.62,65.62 R7934.1 ; 176.15,66.18 176.15,66.08 175.69,65.62 175.55,65.62 R7939.1 ; 176.15,66.18 v1(176.15,66.22) ; PR8516.2 PC8511.2 210.79,54.53 211.43,55.17 v1(211.43,55.4) ; v1(130.07,118.4) PC4708.2 ; v1(282.17,22.9) 282.42,23.15 IOBD3.20 ; PR4430.2 R4301.1 238.76,32.69 238.89,32.81 238.89,32.85 v1(239.4,33.36) ; R7925.1 173.61,64.25 173.23,63.87 v1(173.1,63.87) ; v1(203.5,92.06) 203.96,91.6 C8002.2 ; C9108.2 83.12,4.44 v1(83.85,5.17) ; v1(13.59,58.79) 14.1,58.28 14.73,58.28 15.72,57.29 ED3602.2 ; ED3604.2 17.4,37.45 v1(16.76,38.09) ; v3(215.01,79.87) 215.26,79.61 215.26,76.05 PC8530.1 ; v3(190.04,30.41) 190.02,30.41 188.9,29.3 DM2.261 ; v1(173.58,109.21) 173.35,109.43 172.55,109.43 C8219.2 ; v1(191.21,113.3) 191.21,115.23 189.87,116.57 189.87,117.02 C8202.2 ; v1(70.42,6.79) 70.96,7.33 R9131.2 ; v1(152.93,48.42) 153.26,48.09 154.79,48.09 155.26,48.56 EC2502.2 ; C9902.2 C9904.2 58.55,82.53 58.8,82.28 v1(58.8,82.1) ; C2724.2 44.19,5.45 v1(44.5,5.76) ; v1(279.8,20.83) 279.46,20.5 C9202.2 C9201.2 ; EC2707.2 15.94,21.13 v1(15.88,21.19) ; v1(51.06,78.04) 51.06,78.19 50.84,78.41 50.84,78.51 LCD1.43 ; R2008.2 142.68,75.41 143.54,74.55 v1(144.04,74.55) ; v1(57.26,79.49) 58.12,79.49 58.15,79.45 LCD1.42 ; EC6504.2 125.79,6.53 v1(126.36,7.1) ; v1(45.23,103.4) 46.23,104.4 DCIN1.8 ; v1(196.32,25.53) 197.53,25.53 R2436.2 ; C1122.2 158.27,61.8 C2108.2 159.13,61.73 v1(159.31,61.55) ; v1(253.24,23.35) 253.25,23.34 HDD1.35 ; C5504.2 52.39,81.45 v1(52.83,81.01) 53.28,81.46 C5503.2 ; PC8503.1 205.55,57.14 205.35,57.14 204.98,56.76 204.98,56.63 v1(204.85,56.5) ; IOBD3.18 279.94,25.3 v1(279.86,25.39) U3503.2 ; v1(76.83,98.09) C2602.2 ; v1(142.39,108.44) 142.44,108.44 142.8,108.09 PR4661.2 ; PC4709.2 119.44,116.94 ; C2619.2 v1(205.36,112.63) ; EC5312.2 R2417.2 201.42,26.66 200.97,27.11 199.84,27.11 199.13,27.82 v1(199.13,28.29) ; v1(29.59,94.98) 29.34,94.98 29.02,94.66 EC3107.1 EC3106.1 ; v1(119.13,6.79) 119.52,6.4 EC6505.2 ; v1(71.12,89.14) 71.51,89.14 71.82,89.45 71.88,89.45 EC5504.2 ; EC2506.2 v1(171.45,47.61) ; C5502.2 R5528.2 v1(55.94,83.59) ; Q2702.S 40.79,6.91 v1(41.44,6.91) ; PC4707.2 130.05,115.83 v1(130.05,115.56) ; v1(257.68,31.58) 258.36,30.91 C6001.2 ; v1(93.22,95.74) 93.34,95.62 93.34,95.04 ED401.2 ; C3110.2 42.05,90.74 R3108.2 41.78,90.47 v1(41.78,89.67) ; C3116.2 51.69,90.28 v1(52.07,90.66) 52.07,91.44 FC2402.2 ; R602.2 85.26,62.47 v1(84.72,63) ; v1(104.78,126.6) 105.03,126.86 FC9717.2 FC9722.2 ; v1(200.35,13.51) 200.35,12.89 200.28,12.82 200.28,12.29 200.41,12.17 R2445.1 ; C6502.2 183.31,55.17 R6507.2 182.59,54.7 182.59,55.71 v1(182.61,55.74) ; v1(127.18,122.08) 127.18,121.85 127.83,121.21 PR4653.1 ; C5509.2 46.16,81.46 v1(46.61,81.01) ; v1(15.49,61.52) C3403.2 C3401.2 20.49,61.48 C3405.2 C3404.2 ; v1(213.02,59.4) FAN1.3 ; 12.87,30.81 USB2.7 12.87,29.39 ; C2116.2 125.06,91.74 v1(124.71,91.4) ; v1(176.15,58.63) 176,58.48 176,57.2 PC8623.2 ; R2449.1 C2412.2 203.01,35.73 202.54,36.2 202.49,36.25 v1(202.06,36.69) ; C9106.2 249.91,27.07 C9113.2 250.51,28.67 v1(250.49,28.69) ; PC8654.2 v1(200.53,115.68) ; v1(207.85,115.99) 207.85,116.14 207.9,116.19 PR8672.2 ; v1(181.71,57.83) 180.33,57.83 PC8621.2 PC8622.2 ; v1(199.9,30.72) 200.69,29.93 Q2408.S ; ED2902.3 v1(17.27,19.92) ; C8130.2 162.31,116.89 162.31,116.44 161.19,115.32 v1(161.19,113.3) ; PR5404.2 62.17,2.56 v1(61.98,2.75) PU5402.8 ; FAN261.7 210.19,43.51 C2423.2 ; v1(68.4,94.32) 68.4,94.4 68.4,94.4 IRCCD1.8 68.64,95.3 70.07,96.72 C2609.2 C2608.2 ; v1(175.64,63.49) 176.15,63.49 176.23,63.41 PC8602.2 ; C3112.2 45.61,89.33 X3101.4 45.75,89.18 46.18,89.18 47.12,88.25 v1(47.24,88.25) ; USB2.10 13.62,37.39 ; USB2.10 13.62,35.61 ; USB2.10 15.3,36.5 ; v1(152.55,89.62) 152.27,89.34 150.89,89.34 EC1716.2 ; v1(178.58,110.07) 178.61,110.09 C8225.2 C8224.2 ; 58.65,116.68 WWAN2.1 61.83,113.5 ; C1804.2 135.13,59.32 v1(135.13,59.32) ; v1(142.88,51.55) 143.13,51.8 144.06,51.8 EC2503.2 FC2501.2 ; 4.05,59.01 HDMI1.22 5.49,60 ; HDD1.32 267.97,23.45 v1(267.74,23.23) ; v1(202.54,115.96) PC8655.2 ; WLAN1.76 29.9,69.96 29.77,70.09 v1(27.81,70.09) 27.81,71.23 28.45,71.87 EC9722.2 ; C717.2 v1(88.77,93.33) 88.71,93.39 EC1709.2 ; R5710.2 26.35,71.93 26.04,71.61 v1(26.04,71.05) ; C8056.2 v1(161.42,81.98) ; C5539.2 43.18,82.64 43.18,81.27 v1(43.31,81.14) ; R9124.2 v1(67.67,6.84) ; v1(161.29,57.77) 161.21,57.69 161.21,54.93 160.27,53.99 160.27,53.64 C2504.2 159.11,53.45 C2505.2 ; v1(212.6,41.13) 212.53,41.07 R9936.2 ; v1(21.21,14.72) 21.02,14.91 R2717.2 ; v1(183.69,113.3) 183.69,114.71 185.42,116.44 185.42,117.02 C8138.2 ; C7609.2 155.5,76.19 v1(155.83,75.85) 155.91,75.94 156.55,75.94 156.92,75.57 156.92,75.04 156.55,74.67 156.08,74.67 156.07,74.66 155.95,74.66 155.63,74.34 R1715.2 C1701.2 EC1703.2 ; v1(259.74,29.09) 259.87,29.09 259.97,29.2 C5621.2 ; v1(60.44,88.54) 60.13,88.54 59.63,89.04 R5506.1 ; C9114.2 C9105.2 249.76,32.52 v1(249.33,32.52) ; FAN1.6 v1(217.12,65.06) ; WWAN1.77 102.45,123.85 v1(100.46,125.84) ; R9609.1 R9607.1 66.92,76.31 66.66,76.57 66.66,77.57 v1(66.67,77.58) ; v1(225.43,40.47) 224.13,40.47 RTC1.3 RTC1.4 ; 12.87,50.81 USB1.7 12.87,49.39 ; PWSW2.2 215.28,50.59 214.58,51.29 214.22,51.29 v1(214.17,51.34) ; v1(16.57,30.59) 17.4,30.59 18.03,31.23 U3502.2 ; HDD1.34 256.41,23.54 256.41,24.27 v1(256.16,24.52) ; v1(178.69,111.62) 178.92,111.85 178.92,112.42 C8218.2 ; C8227.2 194.64,117.92 v3(195.07,118.35) ; C7901.2 v1(161.42,69.97) ; C6701.2 C6702.2 ; PR5407.2 PC5401.2 56.92,8.21 v1(57.28,7.86) 58.14,7 v1(58.14,4.66) ; EC6506.2 119.01,9.19 v1(118.77,8.95) ; PR4652.2 v1(139.38,111.25) ; THM26.5 v1(72.62,94.73) ; v1(31.11,51.17) 31.11,50.15 30.12,49.15 WLAN1.77 ; v1(208.23,54.98) 208.67,54.53 PC8502.2 208.88,54.49 C2605.2 208.94,53.59 C2611.2 207.43,52.54 R2605.1 ; IOBD3.8 v1(279.61,35.3) ; C1803.2 135.23,55.34 v1(135.23,54.65) ; v1(173.1,51.8) 171.86,50.56 EC2504.2 ; v1(33.78,5.81) 32.7,6.89 SPK1.5 ; C7903.2 161.35,67.38 v1(161.37,67.4) ; v1(120.46,52.8) EC1714.2 119.7,52.06 EC1713.1 R1732.1 ; EC3619.2 v1(22.58,58.2) ; v1(203.61,5.4) 203.87,5.66 EC9733.2 ; v1(194.06,88.63) 194.06,87.96 R7922.2 ; PC5402.2 64.44,8.77 v1(64.77,8.44) 64.77,7.86 64.41,7.5 PC5404.2 ; C2418.2 218.5,27.07 217.25,28.33 215.75,28.33 v1(215.14,28.94) ; FC9731.2 218.06,45.64 C4102.2 216.9,45.64 v1(216.61,45.35) ; DCIN1.7 48.04,120.24 48.04,119.63 v1(47.78,119.37) ; Q6505.S v1(194.74,15.8) ; C8229.2 173.01,116.86 v1(172.9,116.98) 172.87,116.95 C8155.2 ; C2429.2 218.25,34.85 v1(218.77,34.33) ; v1(190.91,43.8) 192.06,44.95 IOBD4.18 ; EC3105.1 v1(29.4,91.11) 29.4,90.47 28.83,89.9 EC3104.1 ; PR8623.2 178.56,62.01 178.69,62.14 v1(178.69,62.37) ; R2504.2 v1(228.41,45.32) ; IOBD3.5 v1(279.79,38.3) ; v1(22.4,76.67) 22.4,76.64 22.07,76.31 R5706.1 ; EC1711.2 v1(152.89,64.63)
  BOTTOM w0.635: C4013.2 145.03,90.43 145.03,91.53 v4(144.73,91.83) ; v1(143.56,79.92) 144.86,79.92 C1176.2 ; PT4801.2 107.19,107.66 v3(106.02,108.82)
  vias: v1(2.74,40.17) v1(4.95,20.94) v1(6.81,60.26) v1(6.86,20.94) v1(6.99,78.04) v1(8.53,59.78) v1(9.27,20.94) v1(9.43,38.99) v1(9.98,75.07) v1(9.98,63.46) v1(10.46,58.99) v1(11.23,41.21) v1(11.25,38.97) v1(12.32,21.19) v1(12.43,99.26) v1(12.65,35.27) v1(12.65,25.03) v1(13.99,99.26) v1(14.35,22.34) v1(16.03,81.54) v1(16.46,53.5) v1(16.69,81.54) v1(17.24,53.51) v1(17.32,81.52) v1(17.51,99.26) v1(17.98,81.52) v1(18.9,53.43) v1(18.92,50.15) v1(19.07,99.26) v1(19.11,75.58) v1(19.15,55.38) v1(22.35,11.8) v1(22.59,99.26) v1(23.11,22.46) v1(23.11,11.8) v1(23.62,28.52) v1(23.6,26.58) v1(23.75,23.89) v1(23.93,13.24) v1(23.93,12.53) v1(23.93,11.82) v1(23.93,11.08) v1(23.93,10.35) v1(24.15,99.26) v1(24.74,11.82) v1(25.02,22.34) v1(25.27,23.48) v1(25.53,11.82) v1(25.65,56.37) v1(25.91,69.07) v1(26.29,57.01) v1(26.29,56.37) v1(27.12,67.36) v1(27.43,66.03) v1(27.43,65.14) v1(27.43,64.25) v1(27.67,99.26) v1(28.7,98.03) v1(29.23,99.26) v1(31.75,60.44) v1(32.75,99.26) v1(33.66,4.94) v1(33.66,3.03) v1(33.66,2.14) v1(34.16,67.8) v1(34.31,99.26) v1(35.41,6.12) v1(41.53,21.96) v1(41.83,22.57) v1(41.96,87.26) v1(42.44,22.74) v1(43.31,94.98) v1(43.31,22.64) v1(43.9,120.11) v1(43.9,103.91) v1(43.9,102.35) v1(44.2,95.87) v1(44.2,94.98) v1(44.2,94.09) v1(44.32,77.96) v1(44.68,57.06) v1(45.09,94.98) v1(45.4,112.12) v1(45.69,56.93) v1(45.85,114.29) v1(46.33,109.08) v1(46.61,125.08) v1(46.74,77.96) v1(47.07,99.71) v1(47.52,105.85) v1(47.5,89.75) v1(47.88,125.08) v1(48.13,74.03) v1(48.39,66.47) v1(48.54,83.86) v1(48.9,7.61) v1(49.66,7.61) v1(50.42,7.61) v1(50.93,2.22) v1(51.64,43.37) v1(51.66,42.4) v1(52.63,42.33) v1(52.65,43.37) v1(53.91,128.46) v1(53.9,126.68) v1(53.9,123.39) v1(54.91,91.68) v1(55.42,54.19) v1(55.46,89.88) v1(55.78,48.65) v1(56.74,85.02) v1(57.2,128.46) v1(58.6,127.47) v1(58.78,4.66) v1(62.07,51.59) v1(62.48,74.15) v1(62.83,51.59) v1(62.83,50.83) v1(63.37,74.15) v1(63.5,77.58) v1(63.5,76.44) v1(63.6,51.59) v1(66.8,60.69) v1(66.8,59.8) v1(66.8,58.91) v1(67.11,128.48) v1(67.56,60.69) v1(67.56,59.8) v1(67.56,58.91) v1(68.39,128.46) v1(69.11,93.15) v1(70.04,126.29) v1(71.65,75.35) v1(72.41,76.11) v1(72.41,75.35) v1(72.41,74.58) v1(72.64,61.07) v1(72.64,60.18) v1(72.64,59.04) v1(72.74,126.7) v1(73.18,75.35) v1(73.41,61.07) v1(73.41,60.18) v1(73.53,56.37) v1(73.53,55.61) v1(74.3,77.71) v1(74.3,76.95) v1(83.03,5.88) v1(83.85,6.61) v1(83.85,5.9) v1(85.77,70.67) v1(87.07,67.65) v1(87.96,79.89) v1(87.96,78.83) v1(88.89,68.79) v1(89,67.68) v1(89.79,60.69) v1(89.79,58.69) v1(90.79,89.4) v1(91.9,59.98) v1(91.87,58) v1(92.33,128.48) v1(92.34,89.2) v1(93.84,59.43) v1(93.84,57.45) v1(95.62,60.15) v1(95.62,58.2) v1(95.81,56.25) v1(96.27,5.52) v1(97.04,98.25) v1(99.31,97.09) v1(100.08,120.18) v1(100.2,118.86) v1(100.41,128.46) v1(100.71,103.24) v1(101.98,105.52) v1(104.52,79.79) v1(104.5,3.95) v1(104.9,80.43) v1(104.85,76.41) v1(105.33,99.34) v1(105.31,79.82) v1(105.51,76.44) v1(105.61,128.46) v1(106.15,78.98) v1(106.15,78.34) v1(106.15,77.71) v1(106.15,77.07) v1(106.15,76.44) v1(109.35,28.26) v1(109.52,115.91) v1(109.52,115.05) v1(109.52,114.18) v1(109.77,27.47) v1(110.39,115.91) v1(110.39,115.05) v1(110.39,114.18) v1(110.4,60.19) v1(110.4,59.54) v1(110.57,128.46) v1(111.25,115.91) v1(111.25,115.05) v1(111.25,114.18) v1(112.12,115.91) v1(112.12,115.05) v1(112.12,61.4) v1(112.12,59.45) v1(112.12,57.5) v1(112.98,115.91) v1(112.98,115.05) v1(112.98,114.18) v1(114.14,58.81) v1(114.49,77.95) v1(114.94,21.19) v1(114.94,20.31) v1(114.94,19.54) v1(115.19,25.26) v1(115.65,128.46) v1(115.77,122.31) v1(115.78,59.97) v1(115.78,58.02) v1(116.48,21.09) v1(116.46,20.31) v1(116.46,19.54) v1(117.35,15.23) v1(117.35,14.46) v1(117.35,13.7) v1(118.36,28.56) v1(119,27.8) v1(119.23,118.58) v1(119.25,117.94) v1(119.25,117.31) v1(119.94,118.65) v1(119.96,117.99) v1(119.96,117.33) v1(119.95,58.98) v1(119.95,57.03) v1(119.95,55.07) v1(120.98,118.6) v1(120.98,117.74) v1(121.84,118.6) v1(121.84,117.74) v1(122.68,119.49) v1(122.71,118.6) v1(122.71,117.74) v1(123.57,119.49) v1(123.57,118.6) v1(123.57,117.74) v1(124.43,119.47) v1(124.43,118.6) v1(125.3,119.47) v1(125.3,118.6) v1(125.3,117.74) v1(126.44,128.48) v1(131.57,110.86) v1(131.57,109.97) v1(131.57,109.08) v1(131.57,108.19) v1(132.46,3.54) v1(139.83,105.01) v1(140.59,103.24) v1(140.72,123.12) v1(140.72,122.46) v1(146.43,74.89) v1(147.62,74.89) v1(149.67,128.46) v1(150.19,124.91) v1(150.24,10.17) v1(150.62,73.77) v1(151.31,128.46) v1(151.69,10.17) v1(152.7,10.17) v1(153.92,104.89) v1(153.92,103.87) v1(154.23,10.17) v1(154.69,105.27) v1(154.69,104.38) v1(154.69,103.49) v1(154.75,128.46) v1(156.23,112.23) v1(158.19,10.17) v1(159.08,10.17) v1(162.32,47.1) v1(162.99,73.42) v1(164.85,72.63) v1(166.12,27.54) v1(166.19,10.17) v1(167.9,81.87) v1(168.99,76.05) v1(169.04,53.96) v1(169.06,77.22) v1(169.16,64.93) v1(169.67,80.83) v1(169.7,77.22) v1(169.7,76.08) v1(169.93,53.96) v1(170.56,77.22) v1(170.56,68.08) v1(173.95,83.79) v1(173.97,80.89) v1(176.09,80.72) v1(176.17,59.52) v1(176.9,79.93) v1(177.85,80.79) v1(177.85,76.88) v1(177.93,21.45) v1(178,78.84) v1(178.44,20.94) v1(178.82,104.76) v1(178.82,102.86) v1(178.94,76.86) v1(178.99,81.62) v1(179.7,80.82) v1(179.76,82.83) v1(179.75,78.99) v1(180.85,81.56) v1(180.87,82.86) v1(182.81,2.54) v1(183.26,76.13) v1(183.31,75.16) v1(184.02,4.18) v1(184.11,76.09) v1(184.13,75.19) v1(187.58,49.39) v1(189.1,50.79) v1(190.75,70.34) v1(191.39,70.34) v1(192.15,70.34) v1(192.77,25.73) v1(194.94,82.41) v1(195.2,81.65) v1(195.58,82.41) v1(195.83,81.65) v1(196.22,82.41) v1(197.57,56.28) v1(199.63,128.46) v1(201.04,127.37) v1(201.04,126.1) v1(202.06,127.37) v1(202.06,126.1) v1(202.31,121.02) v1(203.2,1.76) v1(203.96,63.49) v1(204.6,63.49) v1(204.71,128.46) v1(204.85,121.02) v1(205.23,64.76) v1(205.23,64.12) v1(205.23,63.49) v1(205.23,62.85) v1(205.26,22.38) v1(205.87,63.49) v1(206.5,63.49) v1(207.34,121.17) v1(208.23,80.88) v1(208.28,1.76) v1(208.78,81.46) v1(209.3,128.46) v1(211.51,104.38) v1(211.76,115.19) v1(211.76,110.11) v1(211.84,47.1) v1(212.16,104.42) v1(212.72,42.97) v1(213.36,1.76) v1(216,16.27) v1(216.66,16.11) v1(218.44,1.76) v1(218.95,63.69) v1(221.34,48.02) v1(222.61,55.26) v1(223.01,46.16) v1(223.52,1.76) v1(228.6,1.76) v1(228.85,46.7) v1(231.9,42.91) v1(233.68,1.76) v1(238.38,3.67) v1(239.14,40.12) v1(239.65,24.29) v1(239.67,25.54) v1(243.33,38.59) v1(246.13,19.04) v1(246.15,19.7) v1(246.81,19.72) v1(248.54,37.32) v1(248.87,28.66) v1(249.68,28.69) v1(256.56,17.79) v1(258.83,18.45) v1(259.61,18.48) v1(261.19,36.19) v1(262.36,31.07) v1(263.14,31.81) v1(263.14,31.1) v1(263.14,30.36) v1(263.44,36.2) v1(263.93,31.1) v1(265.65,36.52) v1(266.7,38.72) v1(268.17,37.65) v1(269.37,31.35) v1(269.37,30.34) v1(269.49,35.93) v1(271.91,40.75) v1(273.61,27.95) v1(275.67,32.6) v1(276.33,28.84) v1(276.61,27.54) v1(277.14,17.66) v1(277.47,32.75) v1(282.45,42.66) v1(282.4,41.39) v1(288.48,16.79) v1(291.76,44.83) v1(291.76,39.75) v1(291.76,29.59) v2(18.31,62.61) v2(18.79,70.48) v2(21.59,24.88) v2(22.35,13.07) v2(22.86,8.37) v2(30.2,36.66) v2(32.64,21.19) v2(43.65,46.89) v2(43.69,10.91) v2(46.61,6.72) v2(48.26,101.2) v2(48.51,6.46) v2(52.07,33.77) v2(58.84,28.3) v2(63.12,7.73) v2(70.23,117.21) v2(95.12,3.41) v2(98.42,3.8) v2(102.9,102.07) v2(106.68,107.94) v2(108.36,114.32) v2(115.7,20.05) v2(115.96,102.26) v2(116.52,107.75) v2(117.25,117.79) v2(128.52,5.95) v2(137.16,120.89) v2(140.59,105.27) v2(142.11,6.21) v2(155.19,105.9) v2(155.57,103.49) v2(168.71,54.99) v2(177.29,4.68) v2(198.27,104.88) v2(198.59,113.73) v2(202.95,63.99) v2(205.23,126.35) v2(207.87,120.86) v2(208.91,110.48) v2(232.79,26.66) v2(248.79,20.81) v2(260.99,27.42) v2(263.14,32.88) v2(273.81,28.94) v2(280.8,20.05) v3(16.26,34.91) v3(17.58,27.65) v3(17.58,26.71) v3(27.43,36.82) v3(27.69,37.7) v3(28.73,37.58) v3(29.72,39.74) v3(29.72,38.72) v3(30.1,37.7) v3(30.23,40.5) v3(30.73,39.74) v3(30.73,38.72) v3(31.9,24.12) v3(31.88,22.97) v3(31.88,21.83) v3(32.92,24.6) v3(38.81,29.88) v3(39.57,29.47) v3(39.73,30.59) v3(39.88,28.61) v3(40.59,29.5) v3(40.67,45.08) v3(40.74,28.61) v3(40.79,30.39) v3(41.2,45.83) v3(41.55,32.57) v3(41.86,45.08) v3(42.02,46.11) v3(42.55,43.29) v3(42.58,44.18) v3(42.6,33.44) v3(42.57,32.52) v3(43.43,43.29) v3(43.51,44.18) v3(43.63,32.86) v3(44.3,33.5) v3(45.14,33.5) v3(51.13,32.55) v3(51.16,33.51) v3(51.18,31.66) v3(64.16,113.98) v3(67.44,114.01) v3(69.22,114.03) v3(97.54,46.34) v3(102.11,125.46) v3(103,125.46) v3(103.89,125.46) v3(104.55,79) v3(104.57,78.14) v3(104.56,77.28) v3(104.78,125.46) v3(105.41,78.98) v3(105.44,78.12) v3(105.42,77.25) v3(105.94,115.43) v3(105.92,114.44) v3(106.05,113.14) v3(106.6,116.01) v3(106.68,114.92) v3(106.68,114.03) v3(107.57,114.92) v3(107.57,114.03) v3(108.08,113.14) v3(113.61,77.96) v3(113.56,76.77) v3(114.27,123.43) v3(114.27,122.46) v3(114.4,121.37) v3(114.44,76.73) v3(115.01,122.97) v3(115.01,122.03) v3(115.29,120.79) v3(115.44,117.59) v3(115.57,106.16) v3(115.57,105.32) v3(115.57,104.43) v3(115.57,103.41) v3(115.72,121.52) v3(115.67,111.39) v3(115.67,110.55) v3(115.7,109.71) v3(115.67,108.88) v3(116.56,111.39) v3(116.56,110.55) v3(116.59,109.71) v3(116.56,108.88) v3(116.59,106.16) v3(116.59,105.32) v3(116.59,104.43) v3(116.59,103.41) v3(130.94,111.24) v3(130.94,110.35) v3(130.94,109.46) v3(130.94,108.57) v3(130.94,107.68) v3(131.06,104.25) v3(131.06,103.24) v3(132.21,111.24) v3(132.21,110.35) v3(132.21,109.46) v3(132.21,108.57) v3(132.21,107.68) v3(136.78,123.71) v3(136.83,118.3) v3(136.91,119.97) v3(136.86,119.14) v3(137.87,119.92) v3(138.81,119.95) v3(139.32,105.65) v3(139.93,103.64) v3(140.34,104.38) v3(156.59,81.65) v3(156.59,80.38) v3(167.11,66.59) v3(168.22,65.19) v3(168.45,64.25) v3(185.8,62.8) v3(185.8,61.96) v3(186.94,62.8) v3(186.94,61.96) v3(188.09,62.8) v3(188.09,61.96) v3(189.23,62.8) v3(189.23,61.96) v3(190.37,62.8) v3(190.37,61.96) v3(191.39,62.8) v3(191.39,61.96) v3(192.41,127.75) v3(192.41,62.8) v3(192.41,61.96) v3(193.55,127.75) v3(193.52,70.6) v3(193.52,69.45) v3(193.52,68.44) v3(194.41,70.6) v3(194.41,69.45) v3(194.41,68.44) v3(194.69,127.75) v3(195.56,58.13) v3(195.83,127.75) v3(196.22,118.35) v3(196.4,58.1) v3(197.23,58.02) v3(197.49,116.57) v3(197.49,115.3) v3(197.49,113.9) v3(197.49,112.63) v3(197.49,111.36) v3(197.49,110.09) v3(207.14,126.48) v3(208.28,126.48) v3(209.08,80.77) v3(209.16,94.22) v3(209.16,93.33) v3(209.16,92.44) v3(209.16,91.55) v3(209.18,82.11) v3(209.42,126.48) v3(209.6,68.74) v3(209.55,67.78) v3(209.72,81.45) v3(210.33,82.06) v3(210.33,80.79) v3(210.44,68.74) v3(210.41,67.75) v3(210.57,126.48) v3(210.96,81.43) v3(211.6,82.06) v3(211.6,80.79) v3(211.63,68.79) v3(211.63,67.83) v3(212.23,81.43) v3(212.77,82.08) v3(212.85,80.84) v3(213.49,81.4) v3(214.12,82.03) v3(214.12,80.78) v3(215.01,83.42) v3(215.01,82.54) v3(215.01,81.65) v3(215.01,80.76) v3(224.16,25.13) v3(224.16,24.24) v3(224.62,23.48) v3(225.46,23.71) v3(226.27,23.52) v3(233.45,31.96) v3(233.45,30.95) v3(233.45,29.96) v3(257.15,24.67) v3(258.17,23.96) v4(177.93,123.94) v4(179.83,123.94)
