# Allegro board 16852-1.brd (continued)
## Placement (name value [footprint] x y rotation side) (continued)
R4002  0R0402-PAD-2-GP  [0R0402-PAD-1]  194.16 9.76 90 bottom
R4004  100KR2J-1-GP  [R402H16]  48.26 52.11 90 top
R4005  1KR2J-1-GP  [R402H16]  194.16 8.88 270 bottom
R4006  20KR2J-L2-GP  [R402H16]  54.74 47.56 180 top
R4009  10KR2J-3-GP  [R402H16]  52.12 36.03 0 top
R4010  0R0402-PAD-2-GP  [0R0402-PAD-1]  49.91 57.14 270 top
R4011  0R0402-PAD-2-GP  [0R0402-PAD-1]  194.21 10.68 270 bottom
R4014  0R0402-PAD-2-GP  [0R0402-PAD-1]  160.4 61.58 270 bottom
R4018  0R2J-2-GP  [R402H16]  213.23 41.9 90 bottom
R4019  0R0402-PAD-2-GP  [0R0402-PAD-1]  217.04 42.53 0 bottom
R4020  0R0402-PAD-2-GP  [0R0402-PAD-1]  213.74 41.01 90 bottom
R4023  0R0402-PAD-2-GP  [0R0402-PAD-1]  154.69 86.22 180 bottom
R4024  0R0402-PAD-2-GP  [0R0402-PAD-1]  150.19 84.41 90 bottom
R4025  0R1206-PAD-1-GP  [0R1206-PAD-1]  143.15 90.71 0 bottom
R4026  10KR2J-3-GP  [R402H16]  149.73 87.74 180 bottom
R4029  0R0402-PAD-2-GP  [0R0402-PAD-1]  50.16 26.02 180 top
R4030  0R0402-PAD-2-GP  [0R0402-PAD-1]  160.78 39.99 90 top
R4031  100KR2J-1-GP  [R402H16]  193.73 12.02 180 bottom
R4032  100KR2J-1-GP  [R402H16]  194.64 12.02 180 bottom
R4033  0R2J-2-GP  [R402H16]  50.55 27.29 90 top
R4036  0R0402-PAD-2-GP  [0R0402-PAD-1]  128.91 97.52 90 bottom
R4045  0R2J-2-GP  [R402H16]  127.89 95.74 90 bottom
R4048  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  130.05 95.49 90 bottom
R4101  0R5J-5-GP  [R805H24]  153.42 45.96 270 top
R4102  0R0402-PAD-2-GP  [0R0402-PAD-1]  157.61 49.9 270 top
R4103  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  148.59 48.42 0 top
R4104  0R2J-2-GP  [R402H16]  157.61 50.79 270 top
R4301  0R0402-PAD-2-GP  [0R0402-PAD-1]  238.63 32.24 180 bottom
R5501  0R3J-0-U-GP  [R603H22]  72.97 87.72 0 top
R5506  100KR2J-1-GP  [R402H16]  60.07 89.27 270 bottom
R5518  100R2J-2-GP  [R402H14]  56.77 83.3 0 bottom
R5520  0R3J-0-U-GP  [R603H22]  38.1 76.31 90 top
R5521  10KR2J-3-GP  [R402H16]  46.1 83.17 180 bottom
R5522  0R3J-0-U-GP  [R603H22]  39.75 78.22 0 top
R5523  0R5J-5-GP  [R805H24]  61.09 83.17 0 bottom
R5524  0R2J-2-GP  [R402H16]  48.77 69.71 0 top
R5525  100R2J-2-GP  [R402H14]  49.53 78.6 90 top
R5526  0R2J-2-GP  [R402H16]  49.53 79.49 270 top
R5527  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  38.35 78.22 180 top
R5528  100KR2J-1-GP  [R402H16]  55.5 82.92 270 bottom
R5529  100KR2J-1-GP  [R402H16]  53.72 82.92 90 bottom
R5530  0R0402-PAD-2-GP  [0R0402-PAD-1]  49.15 71.11 90 bottom
R5531  0R0402-PAD-2-GP  [0R0402-PAD-1]  48.13 79.11 180 top
R5532  0R5J-5-GP  [R805H24]  45.34 85.58 90 bottom
R5535  0R0402-PAD-2-GP  [0R0402-PAD-1]  43.18 68.44 0 top
R5536  0R0402-PAD-2-GP  [0R0402-PAD-1]  42.16 68.44 0 top
R5539  0R0402-PAD-2-GP  [0R0402-PAD-1]  45.21 83.17 0 bottom
R5540  100R2F-L1-GP-U  [R402H14]  73.03 92.34 270 bottom
R5608  10KR2J-3-GP  [R402H16]  267.46 31.74 270 bottom
R5609  10KR2J-3-GP  [R402H16]  265.18 31.74 270 bottom
R5610  10KR2J-3-GP  [R402H16]  267.46 29.7 270 bottom
R5611  10KR2J-3-GP  [R402H16]  265.18 30.85 270 bottom
R5612  10KR2F-2-GP  [R402H16]  261.11 30.08 270 bottom
R5613  10KR2J-3-GP  [R402H16]  261.11 30.97 90 bottom
R5614  10KR2J-3-GP  [R402H16]  258.93 31.86 90 bottom
R5615  10KR2F-2-GP  [R402H16]  261.11 31.86 90 bottom
R5616  4K7R2J-2-GP  [R402H16]  261.11 32.75 270 bottom
R5617  4K7R2J-2-GP  [R402H16]  258.93 32.75 270 bottom
R5618  4K7R2J-2-GP  [R402H16]  265.18 29.96 90 bottom
R5619  4K7R2J-2-GP  [R402H16]  266.19 28.43 0 bottom
R5705  10KR2J-3-GP  [R402H16]  17.55 76.9 90 bottom
R5706  200KR2F-L-GP  [R402H16]  21.34 76.31 90 bottom
R5707  150KR2F-L-GP  [R402H16]  21.34 77.2 270 bottom
R5709  0R2J-2-GP  [R402H16]  27.56 77.71 270 bottom
R5710  100KR2J-1-GP  [R402H16]  26.8 72.12 90 bottom
R5711  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.07 65.26 90 bottom
R5712  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.07 68.57 90 bottom
R5713  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.07 66.15 90 bottom
R5714  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.07 67.68 90 bottom
R5715  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.07 70.34 90 bottom
R5716  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.07 69.45 90 bottom
R5717  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.07 64.37 90 bottom
R5718  0R0402-PAD-2-GP  [0R0402-PAD-1]  20.07 63.49 90 bottom
R5719  0R0402-PAD-2-GP  [0R0402-PAD-1]  18.87 76.69 0 bottom
R6006  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  260.35 25.77 0 top
R6007  0R0402-PAD-2-GP  [0R0402-PAD-1]  256.03 25.26 270 bottom
R6008  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  249.17 21.58 180 bottom
R6009  0R0805-PAD-2-GP-U  [0R0805-PAD-1-U]  251.08 21.58 180 bottom
R6101  100KR2J-1-GP  [R402H16]  47.17 65.9 270 top
R6102  100KR2J-1-GP  [R402H16]  49.56 66.76 90 top
R6103  330KR2J-L1-GP  [R402H16]  47.68 61.43 180 top
R6104  0R0402-PAD-2-GP  [0R0402-PAD-1]  47.17 65.01 90 top
R6108  0R2J-2-GP  [R402H16]  33.15 59.55 90 top
R6109  0R2J-2-GP  [R402H16]  36.45 58.91 270 top
R6110  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.88 68.06 90 top
R6111  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.88 68.95 90 top
R6112  0R0402-PAD-2-GP  [0R0402-PAD-1]  34.54 55.48 90 top
R6115  0R2J-2-GP  [R402H16]  36.45 58.02 270 top
R6116  0R0402-PAD-2-GP  [0R0402-PAD-1]  39.12 58.91 270 top
R6117  0R2J-2-GP  [R402H16]  37.72 55.74 270 top
R6118  0R2J-2-GP  [R402H16]  49.91 58.15 270 top
R6119  0R2J-2-GP  [R402H16]  36.45 59.8 270 top
R6121  0R0402-PAD-2-GP  [0R0402-PAD-1]  26.67 51.29 180 bottom
R6201  100KR2J-1-GP  [R402H16]  100.58 109.46 270 top
R6202  100KR2J-1-GP  [R402H16]  100.97 123.18 270 top
R6203  100KR2J-1-GP  [R402H16]  94.87 122.41 180 top
R6204  100KR2J-1-GP  [R402H16]  100.2 106.03 270 top
R6205  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.04 115.17 90 top
R6206  0R0402-PAD-2-GP  [0R0402-PAD-1]  91.19 112.68 270 top
R6207  0R0402-PAD-2-GP  [0R0402-PAD-1]  98.04 116.06 90 top
R6208  10KR2J-3-GP  [R402H16]  91.19 116.64 270 top
R6209  100KR2J-1-GP  [R402H16]  91.19 114.31 270 top
R6210  0R0402-PAD-2-GP  [0R0402-PAD-1]  100.33 107.3 90 top
R6211  100KR2J-1-GP  [R402H16]  87.25 107.55 0 top
R6212  0R0402-PAD-2-GP  [0R0402-PAD-1]  88.11 107.55 0 top
R6213  0R2J-2-GP  [R402H16]  92.84 121.52 270 top
R6215  0R2J-2-GP  [R402H16]  91.19 115.82 270 top
R6216  0R2J-2-GP  [R402H16]  91.19 113.5 270 top
R6217  0R0402-PAD-2-GP  [0R0402-PAD-1]  92.08 105.9 270 top
R6218  0R2J-2-GP  [R402H16]  91.19 117.46 270 top
R6219  0R2J-2-GP  [R402H16]  91.19 110.25 270 top
R6220  330KR2J-L1-GP  [R402H16]  90.68 105.27 0 top
R6221  0R0402-PAD-2-GP  [0R0402-PAD-1]  100.58 111.62 90 top
R6222  0R0402-PAD-2-GP  [0R0402-PAD-1]  100.33 108.32 90 top
R6223  0R0402-PAD-2-GP  [0R0402-PAD-1]  91.19 111.87 270 top
R6224  100KR2J-1-GP  [R402H16]  88.93 107.55 180 top
R6226  0R0402-PAD-2-GP  [0R0402-PAD-1]  100.58 110.73 90 top
R6227  10KR2J-3-GP  [R402H16]  77.22 107.94 270 top
R6228  0R0402-PAD-2-GP  [0R0402-PAD-1]  88.6 110.75 270 top
R6301  0R2J-2-GP  [R402H16]  86.33 107.55 180 top
R6302  10KR2J-3-GP  [R402H16]  77.6 110.86 0 top
R6303  100KR2J-1-GP  [R402H16]  76.83 105.9 180 top
R6304  0R0402-PAD-2-GP  [0R0402-PAD-1]  77.72 105.9 180 top
R6305  0R0402-PAD-2-GP  [0R0402-PAD-1]  75.95 105.9 0 top
R6401  10KR2J-3-GP  [R402H16]  199.01 11.8 270 bottom
R6403  100R2J-2-GP  [R402H14]  217.68 17.64 90 top
R6404  0R0402-PAD-2-GP  [0R0402-PAD-1]  203.58 4.68 270 bottom
R6405  0R0402-PAD-2-GP  [0R0402-PAD-1]  198.12 21.45 90 bottom
R6406  330R2J-3-GP  [R402H16]  219.84 5.45 0 bottom
R6407  470R2J-2-GP  [R402H16]  218.95 5.45 0 bottom
R6409  330R2J-3-GP  [R402H16]  274.45 34.28 90 bottom
R6503  51KR2J-1-GP  [R402H16]  183.08 53.45 270 bottom
R6504  0R3J-0-U-GP  [R603H22]  184.02 48.75 0 bottom
R6505  100KR2J-1-GP  [R402H16]  184.66 45.07 90 top
R6506  1KR2J-1-GP  [R402H16]  175.9 44.56 90 top
R6507  100KR2J-1-GP  [R402H16]  182.27 54.57 270 bottom
R6508  0R0402-PAD-2-GP  [0R0402-PAD-1]  170.05 46.87 90 top
R6511  0R2J-2-GP  [R402H16]  121.03 8.24 270 bottom
R6512  0R0402-PAD-2-GP  [0R0402-PAD-1]  128.42 8.62 90 bottom
R6513  4K7R2J-2-GP  [R402H16]  170.18 11.42 180 top
R6515  0R2J-2-GP  [R402H16]  121.03 7.35 270 bottom
R6516  1KR2J-1-GP  [R402H16]  193.8 17.51 270 bottom
R6517  0R3J-0-U-GP  [R603H22]  192.51 9.97 180 top
R6518  0R2J-2-GP  [R402H16]  124.08 7.35 90 bottom
R6519  0R2J-2-GP  [R402H16]  124.08 8.24 90 bottom
R6520  0R2J-2-GP  [R402H16]  196.98 17.13 180 bottom
R6521  0R0402-PAD-2-GP  [0R0402-PAD-1]  196.98 20.05 0 bottom
R6522  100R3J-4-GP  [R603H22]  193.88 9.97 180 top
R6701  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  104.19 6.51 270 bottom
R6702  100KR2J-1-GP  [R402H16]  106.63 8.39 0 top
R6703  100KR2J-1-GP  [R402H16]  113.79 3.92 0 bottom
R6704  100KR2J-1-GP  [R402H16]  107.52 8.39 0 top
R6705  100KR2J-1-GP  [R402H16]  110.74 8.75 270 top
R6706  0R2J-2-GP  [R402H16]  109.3 8.39 180 top
R6707  1MR2J-1-GP  [R402H16]  108.41 8.39 180 top
R6801  0R2J-2-GP  [R402H16]  202.69 43.04 270 bottom
R6802  0R2J-2-GP  [R402H16]  281.56 21.45 270 bottom
R7001  100KR2J-1-GP  [R402H16]  209.8 44.18 270 top
R7601  1KR2F-3-GP  [R402H16]  182.63 82.13 90 top
R7618  1KR2F-3-GP  [R402H16]  170.26 78.88 0 top
R7621  0R0402-PAD-2-GP  [0R0402-PAD-1]  152.96 76.19 270 bottom
R7622  1K69R2F-2-GP  [R402H16]  171.09 78.88 0 top
R7623  0R0402-PAD-2-GP  [0R0402-PAD-1]  151.56 76.69 0 bottom
R7625  10KR2J-3-GP  [R402H16]  152.96 77.07 90 bottom
R7704  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  182.88 74.28 90 top
R7705  0R0603-PAD-2-GP-U  [0R0603-PAD-1-U]  176.99 69.56 180 top
R7801  4K99R2F-L-GP  [R402H16]  156.97 110.73 90 bottom
R7802  2K2R2J-2-GP  [R402H16]  195.07 107.55 0 bottom
R7803  10R2J-2-GP  [R402H14]  196.85 107.55 0 bottom
R7804  49D9R2F-GP  [R402H16]  195.96 107.55 180 bottom
R7805  40D2R2F-GP  [R402H16]  172.34 107.81 90 top
R7806  40D2R2F-GP  [R402H16]  172.34 108.7 90 top
R7807  4K99R2F-L-GP  [R402H16]  157.35 112 180 bottom
R7808  243R2F-2-GP  [R402H16]  156.97 109.21 90 top
R7809  120R2F-GP  [R402H16]  167.87 83.05 180 top
R7810  40D2R2F-GP  [R402H16]  162.56 82.81 90 bottom
R7811  243R2F-2-GP  [R402H16]  172.34 109.59 270 top
R7814  100R2F-L1-GP-U  [R402H14]  162.99 84.08 180 bottom
R7817  40D2R2F-GP  [R402H16]  166.62 82.39 180 top
R7818  100R2F-L1-GP-U  [R402H14]  166.18 84.47 270 top
R7819  5K1R2F-2-GP  [R402H16]  198.12 108.06 270 bottom
R7820  51D1R2F-GP  [R402H16]  191.95 81.77 90 bottom
R7821  51D1R2F-GP  [R402H16]  185.01 84.26 180 top
R7901  1MR2J-1-GP  [R402H16]  161.34 68.67 180 bottom
R7902  1KR2F-3-GP  [R402H16]  191.01 90.16 180 bottom
R7903  5K1R2F-2-GP  [R402H16]  192.41 89.77 270 bottom
R7904  0R2J-2-GP  [R402H16]  174.47 65.47 180 top
R7911  0R2J-2-GP  [R402H16]  191.39 78.14 90 bottom
R7912  0R0402-PAD-2-GP  [0R0402-PAD-1]  185.67 76.67 180 top
R7914  0R0402-PAD-2-GP  [0R0402-PAD-1]  186.51 76.67 180 top
R7919  0R0402-PAD-2-GP  [0R0402-PAD-1]  184.33 82.64 270 top
R7920  0R0402-PAD-2-GP  [0R0402-PAD-1]  191.64 84.69 90 bottom
R7921  10KR2J-3-GP  [R402H16]  187.02 79.31 180 top
R7922  10KR2J-3-GP  [R402H16]  193.57 87.92 270 bottom
R7923  10KR2J-3-GP  [R402H16]  174.88 64.5 270 bottom
R7924  10KR2J-3-GP  [R402H16]  177.29 64.5 90 bottom
R7925  10KR2J-3-GP  [R402H16]  173.61 65.01 0 bottom
R7926  8K45R2F-2-GP  [R402H16]  173.99 75.93 270 top
R7927  2KR2F-3-GP  [R402H16]  170.69 74.53 180 top
R7928  8K45R2F-2-GP  [R402H16]  174.5 74.79 270 top
R7929  2KR2F-3-GP  [R402H16]  171.96 73.26 270 top
R7930  8K45R2F-2-GP  [R402H16]  183.77 78.58 180 top
R7931  4K75R2F-1-GP  [R402H16]  182.95 78.58 0 top
R7932  3K24R2F-GP  [R402H16]  174.62 73.9 270 top
R7933  5K62R2F-GP  [R402H16]  174.29 71.77 0 top
R7934  10KR2J-3-GP  [R402H16]  177.29 65.39 270 bottom
R7935  10KR2J-3-GP  [R402H16]  191.29 80.05 90 bottom
R7936  10KR2J-3-GP  [R402H16]  191.29 80.93 270 bottom
R7937  0R0402-PAD-2-GP  [0R0402-PAD-1]  187.91 79.11 180 top
R7938  16K2R2F-GP  [R402H16]  191.41 71.89 90 bottom
R7939  10KR2J-3-GP  [R402H16]  174.88 65.39 90 bottom
R7940  10KR2J-3-GP  [R402H16]  172.72 65.01 180 bottom
R7941  4K7R2J-2-GP  [R402H16]  169.04 66.28 0 bottom
R7942  10KR2J-3-GP  [R402H16]  175.34 65.47 180 top
R7943  0R2J-2-GP  [R402H16]  149.1 62.47 90 bottom
R7944  0R2J-2-GP  [R402H16]  173.1 66.28 270 bottom
R7945  0R2J-2-GP  [R402H16]  177.29 66.28 90 bottom
R7946  0R2J-2-GP  [R402H16]  174.88 66.28 270 bottom
R7947  0R2J-2-GP  [R402H16]  184.78 74.89 180 top
R7948  0R2J-2-GP  [R402H16]  185.62 74.89 180 top
R8201  40D2R2F-GP  [R402H16]  179.96 106.92 270 top
R8202  40D2R2F-GP  [R402H16]  179.96 107.81 270 top
R8203  243R2F-2-GP  [R402H16]  179.96 109.59 90 top
R8204  4K99R2F-L-GP  [R402H16]  195.28 112.08 270 bottom
R8205  243R2F-2-GP  [R402H16]  195.66 109.48 90 bottom
R8206  4K99R2F-L-GP  [R402H16]  195.66 110.32 270 bottom
R9101  0R2J-2-GP  [R402H16]  254.23 31.66 270 bottom
R9102  0R2J-2-GP  [R402H16]  254.13 33.51 270 bottom
R9103  0R0402-PAD-2-GP  [0R0402-PAD-1]  73.22 7.73 270 bottom
R9110  0R0402-PAD-2-GP  [0R0402-PAD-1]  239.52 29.7 0 bottom
R9113  0R2J-2-GP  [R402H16]  257.18 35.16 270 top
R9114  10KR2J-3-GP  [R402H16]  258.95 35.16 270 top
R9117  0R2J-2-GP  [R402H16]  249.43 33.39 90 top
R9119  10KR2J-3-GP  [R402H16]  247.52 33.39 90 top
R9120  10KR2J-3-GP  [R402H16]  254.38 28.18 270 bottom
R9121  0R2J-2-GP  [R402H16]  277.88 22.59 270 bottom
R9122  0R2J-2-GP  [R402H16]  89.15 7.35 90 top
R9123  0R2J-2-GP  [R402H16]  89.1 4.66 90 top
R9124  10KR2J-3-GP  [R402H16]  67.67 5.12 0 bottom
R9125  0R2J-2-GP  [R402H16]  68.81 5.12 180 bottom
R9126  22R2J-2-GP  [R402H16]  74.8 5.83 90 bottom
R9127  22R2J-2-GP  [R402H16]  284.86 31.18 90 top
R9129  100R2F-L1-GP-U  [R402H14]  257.86 30.92 90 top
R9130  0R0402-PAD-2-GP  [0R0402-PAD-1]  241.94 28.94 270 bottom
R9131  10KR2J-3-GP  [R402H16]  70.96 7.79 180 bottom
R9132  33R2J-2-GP  [R402H16]  243.08 30.21 90 top
R9133  2K2R2J-2-GP  [R402H16]  245.39 34.28 270 top
R9134  33R2J-2-GP  [R402H16]  246.89 26.91 180 bottom
R9135  0R2J-2-GP  [R402H16]  245.08 29.86 90 top
R9136  0R0402-PAD-2-GP  [0R0402-PAD-1]  246.51 32.5 270 bottom
R9137  0R2J-2-GP  [R402H16]  244.86 29.65 0 bottom
R9138  10KR2J-3-GP  [R402H16]  71.85 7.79 0 bottom
R9139  33R2J-2-GP  [R402H16]  245.36 27.93 180 bottom
R9140  10KR2J-3-GP  [R402H16]  242.32 30.34 180 bottom
R9141  10KR2J-3-GP  [R402H16]  250.01 24.06 180 bottom
R9142  0R2J-2-GP  [R402H16]  247.14 25.39 90 bottom
R9143  0R0402-PAD-2-GP  [0R0402-PAD-1]  251.21 24.62 0 bottom
R9144  0R0402-PAD-2-GP  [0R0402-PAD-1]  252.55 26.27 0 bottom
R9145  0R0402-PAD-2-GP  [0R0402-PAD-1]  254.36 29.07 90 bottom
R9146  0R2J-2-GP  [R402H16]  254.23 30.82 90 bottom
R9147  0R0402-PAD-2-GP  [0R0402-PAD-1]  244.47 33.01 270 bottom
R9148  10KR2J-3-GP  [R402H16]  248.92 26.66 0 bottom
R9149  0R0402-PAD-2-GP  [0R0402-PAD-1]  247.01 29.73 90 bottom
R9150  33R2J-2-GP  [R402H16]  245.72 29.63 0 bottom
R9151  33R2J-2-GP  [R402H16]  243.84 30.34 0 bottom
R9152  33R2J-2-GP  [R402H16]  247.78 26.91 0 bottom
R9153  0R2J-2-GP  [R402H16]  284.18 29.75 180 top
R9154  0R2J-2-GP  [R402H16]  197.99 39.23 270 bottom
R9155  0R2J-2-GP  [R402H16]  197.99 37.45 270 bottom
R9156  0R2J-2-GP  [R402H16]  197.99 38.34 270 bottom
R9157  0R2J-2-GP  [R402H16]  197.99 36.56 270 bottom
R9158  0R2J-2-GP  [R402H16]  197.99 35.67 270 bottom
R9201  0R2J-2-GP  [R402H16]  276.23 20.94 0 bottom
R9202  0R0402-PAD-2-GP  [0R0402-PAD-1]  277.11 20.94 180 bottom
R9203  0R0402-PAD-2-GP  [0R0402-PAD-1]  272.47 28.84 180 bottom
R9204  0R0402-PAD-2-GP  [0R0402-PAD-1]  271.45 28.84 180 bottom
R9601  0R0402-PAD-2-GP  [0R0402-PAD-1]  76.68 78.67 180 bottom
R9602  2K2R2J-2-GP  [R402H16]  75.41 79.16 90 bottom
R9603  2K2R2J-2-GP  [R402H16]  71.12 79.36 90 bottom
R9604  4K7R2J-2-GP  [R402H16]  67.82 78.09 90 bottom
R9605  4K7R2J-2-GP  [R402H16]  68.05 78.98 270 bottom
R9606  4K7R2J-2-GP  [R402H16]  67.82 77.2 90 bottom
R9607  4K7R2J-2-GP  [R402H16]  67.82 76.31 270 bottom
R9608  4K7R2J-2-GP  [R402H16]  67.82 74.53 90 bottom
R9609  4K7R2J-2-GP  [R402H16]  67.82 75.42 270 bottom
R9610  10KR2J-3-GP  [R402H16]  67.82 73.65 90 bottom
R9611  1KR2J-1-GP  [R402H16]  62.13 100.49 0 top
R9612  100KR2J-1-GP  [R402H16]  74.93 78.85 90 top
R9613  0R0402-PAD-2-GP  [0R0402-PAD-1]  74.04 71.11 90 top
R9801  0R2J-2-GP  [R402H16]  116.36 49.74 0 bottom
R9804  4K7R2F-GP  [R402H16]  208.33 113.4 180 bottom
R9805  1KR2J-1-GP  [R402H16]  206.76 111.11 0 bottom
R9902  1KR2J-1-GP  [R402H16]  66.93 99.15 90 top
R9904  1KR2J-1-GP  [R402H16]  65.05 100.62 90 top
R9906  150R2J-L1-GP-U  [R402H16]  60.68 100.01 0 top
R9909  3KR2J-2-GP  [R402H16]  54.28 99.71 180 top
R9910  0R2J-2-GP  [R402H16]  58.9 100.01 0 top
R9911  0R2J-2-GP  [R402H16]  58.01 100.01 0 top
R9912  0R2J-2-GP  [R402H16]  57.12 100.01 0 top
R9913  0R2J-2-GP  [R402H16]  60.96 91.17 0 bottom
R9914  0R2J-2-GP  [R402H16]  56.24 100.01 180 top
R9915  0R2J-2-GP  [R402H16]  55.35 100.59 180 top
R9916  0R2J-2-GP  [R402H16]  58.42 97.39 0 bottom
R9917  0R2J-2-GP  [R402H16]  59.31 97.39 0 bottom
R9919  0R2J-2-GP  [R402H16]  59.18 91.17 180 bottom
R9923  0R2J-2-GP  [R402H16]  60.07 91.17 0 bottom
R9925  0R2J-2-GP  [R402H16]  133.68 89.88 270 bottom
R9926  0R2J-2-GP  [R402H16]  62.97 100.47 0 top
R9927  0R2J-2-GP  [R402H16]  57.66 83.3 0 bottom
R9929  100KR2J-1-GP  [R402H16]  54.51 89.22 270 bottom
R9931  0R2J-2-GP  [R402H16]  55.88 91.3 0 bottom
R9932  1K5R2J-3-GP  [R402H16]  58.85 84.64 90 bottom
R9933  0R2J-2-GP  [R402H16]  59.31 87.62 90 top
R9936  100KR2J-1-GP  [R402H16]  211.84 41.51 180 bottom
R9937  100KR2J-1-GP  [R402H16]  215.01 42.53 0 bottom
RJ45  RJ45-8P-186-GP  [23-00980-2A03-A]  6.3 89.4 90 bottom
RN401  SRN49D9F-GP  [SMD-ARES4H18]  117.91 71 270 top
RN402  SRN49D9F-GP  [SMD-ARES4H18]  88.16 84.47 180 top
RN801  SRN2K2J-1-GP  [ARES2H16]  23.75 72.38 270 bottom
RN1201  SRN1KJ-7-GP  [SMD-ARES4H18]  84.33 11.54 270 top
RN1301  SRN1KJ-7-GP  [SMD-ARES4H18]  85.09 54.72 180 bottom
RN1602  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  127.64 91.3 0 bottom
RN1701  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  124.21 55.61 0 bottom
RN1703  SRN10KJ-5-GP  [ARES2H18]  120.8 51.13 90 top
RN1801  SRN20KJ-1-GP  [SMD-ARES4H20]  135.74 47.25 0 top
RN1802  SRN1KJ-7-GP  [SMD-ARES4H18]  146.94 67.17 270 bottom
RN1803  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  146.96 65.88 90 top
RN1804  SRN10KJ-5-GP  [ARES2H18]  146.18 63.46 270 top
RN1805  SRN10J-1-GP  [ARES8-CN24-UH18]  140.28 67.04 270 bottom
RN1806  0R8P4R-PAD-1-GP  [0R8P4R-PAD-1]  128.5 55.84 0 bottom
RN1807  SRN2K2J-4-GP  [ARES8-CN24-UH20]  145.67 79.18 90 top
RN1810  SRN10KJ-5-GP  [ARES2H18]  143.38 55.61 90 bottom
RN1811  SRN2K2J-1-GP  [ARES2H16]  132.21 84.95 180 top
RN1901  SRN33J-5-GP-U  [SMD-ARES4H18]  114.86 51.09 180 bottom
RN2001  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  136.66 50.52 180 top
RN2002  SRN10KJ-5-GP  [ARES2H18]  131.06 75.68 90 top
RN2007  SRN10KJ-5-GP  [ARES2H18]  139.32 83.17 90 bottom
RN2008  SRN2K2J-1-GP  [ARES2H16]  132.08 79.49 0 top
RN2009  SRN10KJ-5-GP  [ARES2H18]  138.81 78.98 270 bottom
RN2013  SRN10KJ-5-GP  [ARES2H18]  146.18 81.6 90 top
RN2401  SRN10J-1-GP  [ARES8-CN24-UH18]  217.17 37.2 0 bottom
RN2402  SRN4K7J-8-GP  [SMD-ARES4H18]  222.63 9.26 180 bottom
RN2403  SRN100KJ-5-GP  [ARES8-CN24H20]  173.74 38.34 270 top
RN2404  SRN100KJ-5-GP  [ARES8-CN24H20]  173.74 35.55 270 top
RN2405  SRN100KJ-5-GP  [ARES8-CN24H20]  201.35 6.46 180 top
RN2406  SRN100KJ-6-GP  [SMD-ARES4]  206.88 46.98 90 top
RN2407  SRN2K2J-1-GP  [ARES2H16]  222.66 7.99 180 top
RN2409  SRN100KJ-5-GP  [ARES8-CN24H20]  173.74 32.75 270 top
RN2410  SRN100KJ-5-GP  [ARES8-CN24H20]  173.74 29.96 270 top
RN2411  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  173.74 24.37 270 top
RN2412  SRN10KJ-6-GP  [ARES8-CN24-MUH20]  173.74 27.16 270 top
RN2501  SRN4K7J-8-GP  [SMD-ARES4H18]  152.53 61.78 90 bottom
RN2502  SRN4K7J-8-GP  [SMD-ARES4H18]  164.9 54.57 180 bottom
RN2503  SRN10J-1-GP  [ARES8-CN24-UH18]  147.45 48.88 180 bottom
RN2602  SRN2K2J-1-GP  [ARES2H16]  76.07 88.89 180 bottom
RN2701  SRN1KJ-7-GP  [SMD-ARES4H18]  26.29 17.13 270 bottom
RN2901  SRN2K2J-1-GP  [ARES2H16]  18.19 12.3 270 top
RN3201  SRN75J-1-GP  [ARES8-CN24H22]  20.75 90.28 270 top
RN4302  SRN100J-4-GP  [ARES8-CN24H20]  235.71 36.05 180 top
RN5501  SRN100J-3-GP  [SMD-ARES4H18]  42.9 84.9 180 bottom
RN5502  SRN100KJ-5-GP  [ARES8-CN24H20]  48.9 71.99 270 top
RN5503  SRN100J-4-GP  [ARES8-CN24H20]  51.44 72.38 180 top
RN5504  SRN33J-5-GP-U  [SMD-ARES4H18]  46.74 72.76 180 top
RN5701  SRN470J-3-GP  [ARES8-CN24H20]  22.73 69.07 90 top
RN5702  SRN2K2J-1-GP  [ARES2H16]  23.29 75.32 180 bottom
RN5703  SRN470J-3-GP  [ARES8-CN24H20]  22.58 64.78 90 top
RN6501  SRN10KJ-5-GP  [ARES2H18]  138.02 5.14 270 bottom
RN6502  SRN2K2J-1-GP  [ARES2H16]  134.77 7.99 270 bottom
RN6503  SRN33J-5-GP-U  [SMD-ARES4H18]  136.4 4.18 270 top
RN6504  SRN10KJ-5-GP  [ARES2H18]  134.87 4.18 270 bottom
RN6505  SRN2K2J-1-GP  [ARES2H16]  129.29 7.99 90 top
RN6801  SRN0J-7-GP-U  [ARES8-CN24H22]  201.17 40.75 0 top
RN7902  SRN4K7J-8-GP  [SMD-ARES4H18]  178.79 66.2 180 top
RN7904  SRN10KJ-5-GP  [ARES2H18]  168.41 79.82 0 top
RN7905  SRN10KJ-5-GP  [ARES2H18]  191.52 73.92 0 bottom
RN9601  SRN100KJ-15-GP  [SMD-ARES4H18]  75.95 68.57 0 bottom
RTC1  ACES-CON2-39-GP-U  [50224-0020N-W02]  223.9 42.5 90 bottom
SIM1  SKT-SIMM6-33-GP-U  [SF58S006VBBR2000-U]  81.33 112.66 180 top
SKT25  SKT-G6179HT0321-001-GP  [G6179HT0321-001]  151.38 55.61 90 bottom
SPI25  W25Q128FVSIQ-GP  [SOIC8-1H86]  151.38 55.61 270 bottom
SPI241  PM25LQ010B-SCE-GP  [SOIC8H69]  97.23 7.4 270 top
SPI252  W25Q64FVSSIQ-GP  [SOIC8-1H86]  164.59 49.64 270 bottom
SPK1  ACES-CON4-29-GP  [50224-0040N-001]  29.9 7 180 bottom
SPR1  SPRING-43-GP-U  [SPR4527H308]  99.9 50.5 0 bottom
SPR2  SPRING-24-GP-U  [SPR5230H134]  93.9 52.89 180 top
SPR3  SPRING-24-GP-U  [SPR5230H134]  130.48 52.63 180 top
TC3502  SC100U6D3V6MX-GP  [C1206H71]  19.05 28.31 180 bottom
TC6201  ST220U6D3VBM-3-GP  [CT3528H79]  101.85 100.32 270 bottom
TC6204  TPAD14-OP-GP  [TPAD14-OP]  101.73 120.76 0 top
THM26  NCT7718W-GP  [MSOP8-1H44]  74.68 96.38 270 bottom
THM263  NCT7718W-GP  [MSOP8-1H44]  203.79 108.67 180 bottom
TP401  TPAD14-OP-GP  [TPAD14-OP]  96.75 92.47 180 bottom
TP402  TPAD14-OP-GP  [TPAD14-OP]  88.27 90.51 180 bottom
TP403  TPAD14-OP-GP  [TPAD14-OP]  130.3 90.03 180 bottom
TP404  TPAD14-OP-GP  [TPAD14-OP]  130.43 66.03 0 top
TP601  TPAD14-OP-GP  [TPAD14-OP]  87.4 62.98 180 bottom
TP602  TPAD14-OP-GP  [TPAD14-OP]  84.76 61.38 180 bottom
TP603  TPAD14-OP-GP  [TPAD14-OP]  88.09 60.06 180 bottom
TP604  TPAD14-OP-GP  [TPAD14-OP]  86.03 60.13 180 bottom
TP605  TPAD14-OP-GP  [TPAD14-OP]  125.09 72.5 0 top
TP606  TPAD14-OP-GP  [TPAD14-OP]  126.52 70.55 0 top
TP607  TPAD14-OP-GP  [TPAD14-OP]  128.78 66.63 270 top
TP608  TPAD14-OP-GP  [TPAD14-OP]  129.54 67.63 270 top
TP609  TPAD14-OP-GP  [TPAD14-OP]  130.81 60.31 180 bottom
TP610  TPAD14-OP-GP  [TPAD14-OP]  131.98 60.72 180 bottom
TP611  TPAD14-OP-GP  [TPAD14-OP]  133.58 60.73 180 bottom
TP614  TPAD14-OP-GP  [TPAD14-OP]  84.71 65.52 180 bottom
TP615  TPAD14-OP-GP  [TPAD14-OP]  85.22 64.37 180 bottom
TP616  TPAD14-OP-GP  [TPAD14-OP]  99.01 67.4 0 top
TP617  TPAD14-OP-GP  [TPAD14-OP]  99.87 70.27 0 top
TP704  TPAD14-OP-GP  [TPAD14-OP]  96.77 81.01 0 top
TP801  TPAD14-OP-GP  [TPAD14-OP]  102.34 86.45 0 top
TP802  TPAD14-OP-GP  [TPAD14-OP]  125.58 80.83 0 top
TP1601  TPAD14-OP-GP  [TPAD14-OP]  135.25 87.49 180 bottom
TP1603  TPAD14-OP-GP  [TPAD14-OP]  129.54 85.2 0 top
TP1703  TPAD14-OP-GP  [TPAD14-OP]  124.08 58.96 180 bottom
TP1704  TPAD14-OP-GP  [TPAD14-OP]  123.41 66.08 0 top
TP1706  TPAD14-OP-GP  [TPAD14-OP]  122.43 68.87 0 top
TP1708  TPAD14-OP-GP  [TPAD14-OP]  125.48 71.31 0 top
TP1709  TPAD14-OP-GP  [TPAD14-OP]  87.12 87.74 180 bottom
TP1801  TPAD14-OP-GP  [TPAD14-OP]  135.79 82.84 180 bottom
TP1804  TPAD14-OP-GP  [TPAD14-OP]  135.25 76.69 180 bottom
TP1805  TPAD14-OP-GP  [TPAD14-OP]  130.18 76.95 0 top
TP1806  TPAD14-OP-GP  [TPAD14-OP]  136.98 83.14 180 bottom
TP1807  TPAD14-OP-GP  [TPAD14-OP]  135.43 84.14 180 bottom
TP1902  TPAD14-OP-GP  [TPAD14-OP]  129.08 60.74 180 bottom
TP1903  TPAD14-OP-GP  [TPAD14-OP]  120.22 67.96 0 top
TP2006  TPAD14-OP-GP  [TPAD14-OP]  135.48 79.47 180 bottom
TP2009  TPAD14-OP-GP  [TPAD14-OP]  130.05 74.03 0 top
TP2012  TPAD14-OP-GP  [TPAD14-OP]  135.23 78.27 180 bottom
TP2013  TPAD14-OP-GP  [TPAD14-OP]  136.65 78.65 180 bottom
TP2014  TPAD14-OP-GP  [TPAD14-OP]  136.4 77.46 180 bottom
TP2015  TPAD14-OP-GP  [TPAD14-OP]  137.16 74.41 180 bottom
TP2016  TPAD14-OP-GP  [TPAD14-OP]  135.25 73.77 180 bottom
TP2017  TPAD14-OP-GP  [TPAD14-OP]  132.92 75.35 0 top
TP2101  TPAD14-OP-GP  [TPAD14-OP]  124.21 70.98 0 top
TP2301  TPAD14-OP-GP  [TPAD14-OP]  84.79 60.11 180 bottom
TP2302  TPAD14-OP-GP  [TPAD14-OP]  92.18 65.36 0 top
TP2303  TPAD14-OP-GP  [TPAD14-OP]  86 61.38 180 bottom
TP2304  TPAD14-OP-GP  [TPAD14-OP]  86.11 65.26 180 bottom
TP2305  TPAD14-OP-GP  [TPAD14-OP]  135.28 63.82 180 bottom
TP2306  TPAD14-OP-GP  [TPAD14-OP]  134.67 60.13 180 bottom
TP2307  TPAD14-OP-GP  [TPAD14-OP]  131.9 66.66 0 top
TP2309  TPAD14-OP-GP  [TPAD14-OP]  131.57 90.03 180 bottom
TP2310  TPAD14-OP-GP  [TPAD14-OP]  89.84 87.41 0 top
TP2311  TPAD14-OP-GP  [TPAD14-OP]  92.58 87.87 0 top
TP2312  TPAD14-OP-GP  [TPAD14-OP]  90.93 88 0 top
TP2314  TPAD14-OP-GP  [TPAD14-OP]  90.09 85.15 0 top
TP3101  TPAD14-OP-GP  [TPAD14-OP]  47.85 91.25 180 bottom
TP3103  TPAD14-OP-GP  [TPAD14-OP]  46.61 90.92 180 bottom
TP4404  TPAD14-OP-GP  [TPAD14-OP]  236.55 18.78 270 top
TP4405  TPAD14-OP-GP  [TPAD14-OP]  235.36 20.61 90 top
TP6102  TPAD14-OP-GP  [TPAD14-OP]  35.43 56.63 270 top
TP6103  TPAD14-OP-GP  [TPAD14-OP]  36.83 54.47 270 top
TP7701  TPAD14-OP-GP  [TPAD14-OP]  162.03 91.14 180 bottom
TP7702  TPAD14-OP-GP  [TPAD14-OP]  184.02 71.11 0 top
TP7703  TPAD14-OP-GP  [TPAD14-OP]  162.71 70.37 180 bottom
TP7801  TPAD14-OP-GP  [TPAD14-OP]  178.08 83.29 0 top
TP7901  TPAD14-OP-GP  [TPAD14-OP]  191.03 83.65 0 top
TP7902  TPAD14-OP-GP  [TPAD14-OP]  191.34 76.06 180 bottom
TP7903  TPAD14-OP-GP  [TPAD14-OP]  193.45 86.88 180 bottom
TP7904  TPAD14-OP-GP  [TPAD14-OP]  176.4 74.79 0 top
TP7905  TPAD14-OP-GP  [TPAD14-OP]  182.35 83.04 0 top
TP7906  TPAD14-OP-GP  [TPAD14-OP]  189.89 81.65 0 top
TP7907  TPAD14-OP-GP  [TPAD14-OP]  192.28 86.47 180 bottom
TP7908  TPAD14-OP-GP  [TPAD14-OP]  191.01 86.09 180 bottom
TP7910  TPAD14-OP-GP  [TPAD14-OP]  189.87 84.06 0 top
TP7911  TPAD14-OP-GP  [TPAD14-OP]  192.48 88.76 180 bottom
TP7912  TPAD14-OP-GP  [TPAD14-OP]  191.26 88.63 180 bottom
TP7913  TPAD14-OP-GP  [TPAD14-OP]  188.34 85.58 0 top
TP7918  TPAD14-OP-GP  [TPAD14-OP]  191.97 77.1 180 bottom
TP7919  TPAD14-OP-GP  [TPAD14-OP]  182.37 70.34 0 top
TP7920  TPAD14-OP-GP  [TPAD14-OP]  180.47 67.17 0 top
TP7922  TPAD14-OP-GP  [TPAD14-OP]  168.02 66.66 180 bottom
TP7923  TPAD14-OP-GP  [TPAD14-OP]  188.87 80.17 0 top
TP8501  TPAD14-OP-GP  [TPAD14-OP]  214.38 63.61 270 top
TP8502  TPAD14-OP-GP  [TPAD14-OP]  214.38 60.69 270 top
TP9901  TPAD14-OP-GP  [TPAD14-OP]  103.25 87.31 0 top
TP9902  TPAD14-OP-GP  [TPAD14-OP]  100.43 90.18 180 bottom
TPAD1  STAR-CON8-2-GP  [106H08-011001-A2-R]  178.9 8.5 0 top
U3401  TPS2544RTER-GP  [QFN16-G1D8-UH32]  26.29 56.37 270 top
U3502  SY6288DAAC-GP  [SOT-23-5H56]  18.03 33.13 180 bottom
U3503  SY6288DAAC-GP  [SOT-23-5H56]  277.5 25.39 270 bottom
U4001  G5016KD1U-GP  [DFN14J3020-G255D85H32]  54.71 54.16 0 top
U4002  APE8939GN3-GP  [DFN8F3-G245165H34]  163.32 62.22 0 bottom
U4003  U74LVC1G08G-AL5-R-GP-U  [SC70-5-1H44]  215.26 45.45 180 bottom
U4005  74LVC1G07GW-GP  [SC70-5H44]  152.15 86.73 90 bottom
U4006  APE8939GN3-GP  [DFN8F3-G245165H34]  146.74 87.41 90 bottom
U4101  SY6288C10CAC-GP  [MSOP8-1H44]  153.37 48.92 90 top
U5501  RT9724GB-GP  [SOT-23-5H51]  59.69 86.85 270 bottom
U5601  SN75LVCP601RTJR-GP  [QFN20-G2D25H32]  263.14 31.1 0 top
U6101  AO6402A-GP  [SOT-6-1H50]  50.22 60.67 180 top
U6201  AO6402A-GP  [SOT-6-1H50]  92.2 101.71 90 top
U6701  LNG2DMTR-GP  [LGA12G2H40]  107.77 5.73 90 top
U9101  ATTPM-DG1MV1-MS-GP  [DFN8G2030-G1614-1H24]  253.11 34.53 270 top
U9102  Z32H320TC-LPC-Q32-401-GP  [LFCSP32G5-G2D6H32]  83.85 5.8 90 top
U9103  NB3N2304NZDTR2G-1-GP  [TSOIC8H44]  75.92 4.91 270 top
U9104  NPCT650JB2YX-GP  [QFN32G5-G3D6H32]  249.68 28.69 270 top
U9601  IT8010FN-BX-GP  [QFN20-G2D75-UH32]  72.41 75.35 90 top
USB1  SKT-USB13-18-GP-U  [SKT-USB13-160166-2]  5.17 50.1 90 bottom
USB2  SKT-USB13-18-GP-U  [SKT-USB13-160166-2]  5.17 30.1 90 bottom
VRAM1  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  164.92 107.3 180 top
VRAM2  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  164.92 107.3 0 bottom
VRAM3  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  187.42 107.3 0 bottom
VRAM4  MT41K256M16HA-107G-E-GP  [BGA96D0914H48]  187.42 107.3 180 top
WLAN1  SKT-MINI67P-12-GP-U  [NFSA0-S6705-TP40]  34.4 59.5 90 bottom
WLAN2  STF237R128H128-3-GP  [STF237R128H128]  62.65 59.5 0 bottom
WWAN1  SKT-MINI67P-GP-U1  [APCI0018-P002A]  98.9 113.5 270 bottom
WWAN2  STF236R128H93-GP  [STF236R128H93]  58.65 113.5 180 bottom
X1801  XTAL-24MHZ-81-GP  [OSC-3225-4P-4H36]  113.54 97.23 0 bottom
X1802  XTAL-32D768KHZ-89-GP  [SMD49-12H36]  137.67 55.43 180 bottom
X2401  XTAL-32D768KHZ-89-GP  [SMD49-12H36]  208.03 12.99 90 top
X3101  XTAL-25MHZ-181-GP  [OSC-3225-4P-4H36]  44.5 88.5 180 bottom
X7901  XTAL-27MHZ-159-GP  [SMD-OSC38H20]  158.46 68.39 270 bottom
XDP1  STC-CONN60A-GP-U1  [QSH-030-01-FDAK]  63.25 93.71 180 top
XF3103  XFORM-24P-19-GP  [XFORM24C1510H168]  21.92 89.5 270 bottom

## Library data of the parts
AFTP2501 AFTP2502 AFTP2801-AFTP2803 AFTP2901-AFTP2904 AFTP4301-AFTP4316 AFTP5601 AFTP5801-AFTP5807 AFTP6101 AFTP6102 AFTP6105 AFTP6201-AFTP6204 AFTP6206-AFTP6209 AFTP6213-AFTP6249 AFTP6252-AFTP6260 AFTP6266 AFTP6301-AFTP6304 AFTP6307-AFTP6315 AFTP6317 AFTP6318 AFTP7001 AFTP8902-AFTP8904 = AFTE14P-75: tolerance: ZZ.AFT14.101
BATT1 = 50299-01001-002-U: tolerance: 20.F1878.010
C715 C1123 C1176 C1183 C1202-C1206 C1208-C1210 C1303-C1310 C1324 C1325 C1704 C2401 C2501 C2505 C2506 C2601 C2621 C2706 C2708 C2712 C2713 C2907 C2908 C3406 C4004 C4012 C4013 C4016 C6002 C6011 C6112 C6703 C7713 C8001 C8002 C8010 C8016 C8038-C8041 C8043 C8044 C8053 C8063 C8064 C8133 C8134 C8140 C8141 C8205 C8206 C8213 C8214 C9107 EC1059 EC1060 EC1062 EC1063 PC1055-PC1058 PC1061 PC5122 PC5402-PC5404 PC5408 PC5409 PC5412 PC8621 PC8622 = C603H38: tolerance: 78.10610.5BL
C716 C717 C719 C722 C1101-C1103 C1116 C1117 C1136 C1138 C1147-C1154 C1172-C1175 C1180 C1207 C1214-C1219 C1221 C1225 C1226 C1313 C1315-C1322 C1326 C1327 C1805 C1806 C2101-C2109 C2116 C2117 C2120 C2121 C2124 C2418 C2426 C2703 C2704 C3114 C3122 C3401 C3511 C3516 C3518 C4033 C4034 C4101 C4102 C5536 C5621-C5623 C7711 C7715 C7801 C7805 C7904 C8003-C8006 C8008 C8009 C8013 C8015 C8017-C8037 C8042 C8045 C8048-C8050 C8054 C8055 C8057-C8062 C8065 C8129-C8132 C8135-C8139 C8142-C8145 C8148 C8153 C8158 C8201-C8204 C8207-C8212 C8215-C8220 C9202 C9603 EC1001 EC1004 EC5701 EC6302 EC9203 EC9718-EC9720 EC9722 EC9725 EC9732-EC9734 EC9736 EC9737 PC4631 PC4708 PC4808 PC5121 PC8508 PC8509 PC8623 PC8634 = C402H22: tolerance: 78.10523.5FL
C718 C720 C721 C1229 C1301 C2110-C2112 C2118 C2119 C2406-C2408 C2410-C2414 C2416 C2420-C2423 C2428 C2429 C2502 C2504 C2507 C2602 C2605 C2608-C2610 C2619 C2620 C2622 C2707 C2709 C2710 C2714 C2717 C2719-C2721 C2724 C2725 C3101 C3102 C3105-C3107 C3111 C3113 C3115 C3117 C3120 C3121 C3402 C3403 C3504 C3509 C3517 C3604 C3605 C4014 C4103 C5501 C5538 C5702 C5710 C6001 C6007 C6010 C6012 C6107 C6109 C6201-C6203 C6207 C6208 C6501-C6504 C6701 C6702 C7002 C7710 C7714 C7821 C7822 C8007 C8011 C8012 C8046 C8047 C8056 C8147 C8149-C8152 C8154-C8157 C8222-C8230 C9102 C9108-C9113 C9115-C9117 C9201 C9601 C9901-C9905 EC1707 EC1711 EC1712 EC1805-EC1808 EC2401 EC2601 EC2708 EC2709 EC3618 EC3619 EC3701 EC4001 EC6406 EC6507 EC7001 PC5118-PC5120 PC5123 PC8502 PC8601 PC8603 PC8607 PC8635 PC8636 = C402H22: tolerance: 78.10421.2FL
C1113 C1122 C1181 C2113-C2115 C2122 C2123 C3404 C3405 C8066 PC1001-PC1037 PC1041-PC1044 PC1046-PC1054 PC1065-PC1098 PC8534 PC8535 PC8625 PC8626 = C603H40: tolerance: 78.22610.5BL
C1182 C3514 C3515 C3519 PC1038 PC1039 PC1064 PC5124 PC8604 PC8605 = C805H58: tolerance: 78.22610.51L
C1211 C1212 C1223 C1224 C1227 C1230-C1232 C1311 C1312 C1330 C1331 = C402H22: tolerance: 078.47510.05FD
C1213 C1314 PC5110 PC8655 = C402H22: tolerance: 78.10523.L2L
C1222 C1323 PC4634 PC8522 = C402H22: tolerance: 78.22321.2FL
C1228 C1328 PC4504 PC4508 PC4516 = C402H22: tolerance: 78.10421.L0L
C1329 PC4707 PC4807 PC5112 PC5406 PC5407 PC8654 R1216 = C603H36: tolerance: 78.22523.L1L
C1601 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C1601
C1602 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C1602
C1603 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C1603
C1604 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C1604
C1605 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1605
C1606 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1606
C1607 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1607
C1608 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1608
C1609 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1609
C1610 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1610
C1611 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1611
C1612 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C1612
C1701 C2402 PC4609 PC5310 = C402H22: tolerance: 78.22124.2FL
C1801 C1802 C3110 C3112 = C402H22: tolerance: 78.15034.1FL
C1803 C1804 = C402H22: tolerance: 78.6R864.1FL
C2403 C7609 = C402H22: tolerance: 78.47034.1FL
C2405 C7802 EC2905-EC2908 PC8512 = C402H22: tolerance: 78.10134.1FL
C2415 C2417 C2705 PC4401 PC5001 = C603H36: tolerance: 78.22523.5BL
C2424 C2425 C5540 C5541 EC1801 EC1802 EC1901 EC2503 EC2505 EC2508 EC2602 EC2701 EC3101-EC3108 EC5504 PC4617 = C402H22: tolerance: 78.10034.1FL
C2427 C2435 C2441 C2607 C2623 C6113 C6206 C9101 C9104 EC2603 PC4410 PC4612 PC4618 PC4709 PC4810 PC5031 = C402H22: tolerance: 78.22224.2FL
C2503 C2722 PC8517 PC8518 PC8612 = C402H22: tolerance: 78.22423.5FL
C2604 C2611 C2701 C2702 C2711 C2715 C2716 C2718 C3103 C3109 C3116 C3118 C4009 C5505 C5539 C6008 C6009 C6013 C6014 C6108 C8051 C8052 C9105 C9106 C9114 = C603H36: tolerance: 78.47520.5BL
C2606 C4001 C4002 C6110 C6111 PC4613-PC4615 = C402H22: tolerance: 78.47124.2FL
C3104 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C3104
C3108 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C3108
C3119 C7921 C8014 C8146 C8221 PC4303-PC4305 PC4413 PC4626 PC4629 PC8501 = C402H22: tolerance: 78.10324.2FL
C3201 = C1808H40: tolerance: 078.5603N.014D
C3601 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C3601
C3602 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C3602
C4005 EC4301 PC4306 PC4405 PC4407 PC4415-PC4418 PC4802-PC4806 PC5027 PC5029 PC8519 PC8528 PC8529 PC8552 = C805H56: tolerance: 78.10622.51L
C4007 EC1002 EC1220 EC2703 EC2705 EC4302-EC4304 EC4314 EC5505 EC6402 EC6403 EC8536 EC8537 EC9701-EC9705 EC9707 EC9710 EC9712 EC9714-EC9717 EC9721 EC9724 EC9735 EC9739 EC9743 EC9744 FC701-FC704 FC706-FC708 FC1001-FC1004 FC1301 FC1901 FC2401 FC2402 FC2501 FC2701 FC4301 FC4701 FC4702 FC4801 FC5001 FC5301 FC5401 FC5402 FC5502 FC6001 FC6002 FC6101 FC6201 FC9702 FC9704 FC9706-FC9709 PC4402-PC4404 PC4411 PC4420-PC4422 PC4610 PC4628 PC4630 PC4710 PC4811 PC5002 PC8521 PC8523 PC8525 PC8530 = C402H22: tolerance: 78.10422.5FL
C5502-C5504 C5506 C5507 C5509 EC1803 EC2501 EC2502 EC2504 EC2506 EC2507 EC2509 = C402H22: tolerance: 78.4R7B4.1FL
C5508 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5508
C5515 C5516 EC1706 EC1903 EC2002 EC2704 EC2706 EC2707 EC2901-EC2904 EC5702 EC6001 EC6401 EC6404 EC9745 PC4603 PC4605 PC4608 PC4611 PC4622 PC4625 PC4627 PC4632 PC4633 PC8503 PC8511 PC8513 = C402H22: tolerance: 78.10224.2FL
C5531 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5531
C5532 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5532
C5533 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5533
C5534 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5534
C5535 C5542 PC4302 PC4409 PC4419 = C603H36: tolerance: 78.10424.2BL
C5537 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5537
C5617 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C5617
C5618 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C5618
C5619 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C5619
C5620 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C5620
C5701 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5701
C5703 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5703
C5704 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5704
C5705 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5705
C5706 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5706
C5707 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5707
C5708 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5708
C5709 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C5709
C6003 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C6003
C6004 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C6004
C6005 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C6005
C6006 = C402H22: tolerance: 78.10324.2FL; signal model: Graser_C6006
C6204 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C6204
C6205 = C402H22: tolerance: 78.10421.2FL; signal model: Graser_C6205
C6306 EC1710 EC1713 EC2723 EC9201 EC9202 PC8624 = C402H22: tolerance: 78.22034.1FL
C7001 = C402H22: tolerance: 78.47321.2FL
C7301 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7301
C7302 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7302
C7303 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7303
C7304 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7304
C7305 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7305
C7306 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7306
C7307 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7307
C7308 = C402H22: tolerance: 78.22423.5FL; signal model: Graser_C7308
C7901 C7903 = C402H22: tolerance: 78.5R674.1FL
C7918 = C402H22: tolerance: 78.82321.2FL
C7919 C7920 = C603H36: tolerance: 78.68421.5BL
C9103 = C402H22: tolerance: 78.33321.2FL
CPU1 = BGA1356M4224-U2H52: tolerance: 071.SKYLA.000U
D401 D1703 D2402 D2403 D2405 D4001 D6101 D6102 D6201 D6202 = SOD323AKH38: tolerance: 83.R2004.G8F
D1702 D5701 = SOT-23-10H44: tolerance: 75.00056.07D
D2501 = SOT-23-9H44: tolerance: 75.00040.07D
D2601 D5501 = SOD323AKH38: tolerance: 83.R5003.H8H
D2701 D5502 D5503 D8601 D8602 = SOT23-2D4-312H48: tolerance: 75.00054.E7D
D4002 = SOT23-2D4-312H44: tolerance: 83.00016.K11
D5702 = SOT23-2D4-312H48: tolerance: 074.02331.009B
D7601 = SOT-23-9H44: tolerance: 83.00056.Q11
DB1 = HS81100: tolerance: 20.D0075.110
DB2 = 88459-047N: tolerance: 20.F1897.004
DB3 = 50696-00601-001: tolerance: 20.K0691.006
DCIN1 = 50458-00601-W01: tolerance: 20.F2132.006
DM1 DM2 = 80886-1021-U: tolerance: 062.10011.00J1
EC1701-EC1705 EC1709 EC1714 EC1715 ED401 ED502 ED1217 ED1302 ED6401 = SOD882-10D6-1H20: tolerance: 83.05725.0A0
EC1708 PC5311 = C402H22: tolerance: 78.10324.L0L
EC1716 = C402H22: tolerance: 78.22523.5FL
EC2001 PC4601 = C402H22: tolerance: 78.15224.2FL
EC2909-EC2912 EC6102 EC6103 EC6301 EC6303-EC6305 EC6501-EC6506 = C402H22: tolerance: 78.33034.1FL
EC5312 = C402H22: tolerance: 78.10224.L1L
EC5501 EC5502 = C402H22: tolerance: 78.6R074.1FL
EC9726-EC9728 PC4301 PC4412 PC4426 = C603H32: tolerance: 78.10524.5BL
ED2901-ED2903 = SOT23-2D4-312H46: tolerance: 75.05125.07D
ED3201 ED3202 ED3601 ED3603 = DFN10G2510H22: tolerance: 075.01043.0073
ED3602 ED3604 ED3701 ED9201 = SOT-6H58: tolerance: 075.09904.0A7C
ED4304-ED4306 PD4302 = SOT23-2D4-312H44: tolerance: 75.00099.O7D
ED5701-ED5703 = SLP2510P8-1H24: tolerance: 75.08808.073
ED6001 ED6201 = DFN10G2510H26: tolerance: 75.01045.073
ED6301 = SOT-6H44: tolerance: 75.04223.07C
EL2901-EL2904 = L1608-UH38: tolerance: 68.00206.021
EL3301 = L125100-4P-4H28: tolerance: 68.01012.20B; signal model: Graser_EL3301
EL3601 = L125100-4P-4H28: tolerance: 68.01012.20B; signal model: Graser_EL3601
EL3602 = L125100-4P-4H28: tolerance: 68.01012.20B; signal model: Graser_EL3602
EL3701 = L125100-4P-4H28: tolerance: 68.01012.20B; signal model: Graser_EL3701
EL4301-EL4304 R1106 R1724 R1735 R2702 R2704 R6006 R6008 R6009 = 0R0805-PAD-1-U: tolerance: ZZ.00PAD.M31
EL5501 = L125100-4P-4H28: tolerance: 68.01012.20B; signal model: Graser_EL5501
EL5503 = SOT-6-1H58: tolerance: 75.00199.07C
ER5701-ER5704 R9906 = R402H16: tolerance: 63.15134.1DL
F5502 = POLYSW-2114H30: tolerance: 69.48001.081
F5503 = POLYSW-4633-UH43: tolerance: 69.50007.A31
FAN1 = 88631-00401-W01: tolerance: 20.F1621.004
FAN261 = SOIC8H69: tolerance: 74.02113.0E1
FC705 FC1005 FC1006 FC2403 FC5501 FC5503 FC6003-FC6005 FC9701 FC9703 FC9705 FC9717-FC9738 PC5113 PC8662 = C402H22: tolerance: 78.47124.L0L
FC9710-FC9716 PC4423 PC4424 PC4620 = C402H22: tolerance: 78.10134.L1L
FPR1 LEDBD1 = 196415-06031-3: tolerance: 020.K0002.0006
G1801 G6401 G6402 = CON2O-U: tolerance: ZZ.CON2O.XXX
GPU1 = BGA631M23H82: tolerance: 071.00JET.M001
H1-H3 H5 = HOLE335R115: tolerance: ZZ.00PAD.D01
H4 = HOLE256R115: tolerance: ZZ.00PAD.D11
H6 = HT85BE95R46-D-5: tolerance: ZZ.PAD01.U11
HCPU1-HCPU4 = HOLE197R166: tolerance: ZZ.00PAD.V71
HDA27 = QFN48J6-G465H40: tolerance: 071.03246.0003
HDD1 = 111H30-100000-G4-R: tolerance: 020.F0500.0030
HDMI1 = SKT-HDMI23-188137: tolerance: 22.10296.981
HGPU1-HGPU3 = STF237R128H44: tolerance: 34.4UV28.201
HPMIC1 = AJ3R2D-Y150-412: tolerance: 022.10002.01B1
IOBD3 = 51653-0180N-001: tolerance: 020.K0150.0018
IOBD4 = TF31-16S-0D5SH-800: tolerance: 020.K0032.0016
IRCCD1 = 50208-0060N-001: tolerance: 20.F1550.006
KB1 = FL4S030HT6R300-DT: tolerance: 20.K0592.030
KBC24 = TQFP128-2H48: tolerance: 071.01404.000E
KBLIT1 = 196503-04031-3: tolerance: 20.K0841.004
L3101 = L3030-3009-2H40: tolerance: 68.4R71G.10G
L8001 = L402H22: tolerance: 68.00109.081
L8002 L8003 = L402H22: tolerance: 68.00084.B21
LCD1 = LVD-A40SFYG: tolerance: 20.F2248.040
LCD2 = STF236R128H101: tolerance: 34.4YG18.201
LIDSW1 = SOT23-2D8-123H52: tolerance: 74.05712.0BB
LOM31 = QFN32J4-G2D85H36: tolerance: 071.8111H.M001
MESW1 = JSD1210-0111FC: tolerance: 62.40018.691
PC4414 PC4623 = C402H22: tolerance: 78.47322.2FL
PC4501 PC4502 PC4510 PC4511 PC5302 = C805H58: tolerance: 78.47522.L4L
PC4503 PC4509 PC4512 PC4515 PC4518 = C603H36: tolerance: 78.10424.L0L
PC4505 PC5410 = C402H22: tolerance: 78.68034.1FL
PC4506 PC4517 = C402H22: tolerance: 78.18034.1FL
PC4507 PC4513 PC4514 PC5111 PC5115 PC5308 PC5309 PC8652 = C805H56: tolerance: 78.10622.LAL
PC4602 PC4606 = C402H22: tolerance: 78.15322.2FL
PC4604 PC4619 = C402H22: tolerance: 78.15034.L1L
PC4607 = C402H22: tolerance: 78.68222.2FLDL
PC4616 = C402H22: tolerance: 078.47222.02FD
PC4621 = C402H22: tolerance: 78.82124.2FLDL
PC4702-PC4705 = C805H58: tolerance: 078.10622.0811
PC4706 PC4809 PC5008 PC8507 PC8510 = C603H40: tolerance: 78.22422.2BL
PC5104 PC5105 PC5107 PC5109 PC5301 PC5303 PC5305 PC5306 PC8657-PC8661 = C805H58: tolerance: 78.22610.L2L
PC5114 PC5116 PC5304 PC5307 PC8651 PC8656 = C402H22: tolerance: 78.10422.L1L
PC5401 PC5405 = C402H22: tolerance: 078.10134.01FY
PC5411 = C402H22: tolerance: 78.47224.2FL
PC8506 PC8515 PC8516 PC8524 PC8533 = C402H22: tolerance: 78.33124.2FL
PC8514 = C402H22: tolerance: 78.18134.1FL
PC8520 PC8526 PC8527 PC8551 = C805H54: tolerance: 78.47522.51L
PC8602 = C603H36: tolerance: 78.47422.5BL
PC8653 = C603H40: tolerance: 78.10612.5BL
PD4301 = DO214AAAKH97: tolerance: 83.P6SMB.JAG
PD4303 = SOT-23-10H44: tolerance: 83.0024V.0A1
PD4304 = SOD123FLAKH40: tolerance: 83.SMF18.0AH
PD4402 PD4405 = SOD323AKH38: tolerance: 83.2R004.08F
PD4404 = SOD323AKH42: tolerance: 83.04148.D1H
PD8501 = SOD323-2513AKH36: tolerance: 83.R5003.N8F
PG4401-PG4407 PG4409-PG4417 PG4501-PG4507 PG4509-PG4512 PG4516-PG4523 PG4526 PG4601 PG4701-PG4705 PG4707 PG4708 PG4801-PG4805 PG4808 PG4809 PG5021 PG5022 PG5105-PG5114 PG5120 PG5121 PG5301-PG5312 PG8507-PG8510 PG8651-PG8653 PG8655-PG8658 PG8660 = GAP-CLOSE-PWR-3: tolerance: ZZ.CLOSE.001
PG5001 PG5002 PG5401 PG5402 PG5404 PG5405 PG8501-PG8506 PG8511-PG8516 PG8601-PG8604 = GAP-CLOSE-PWR: tolerance: ZZ.CON2D.XXX
PL4401 = L7066-1830-UH119: tolerance: 68.4R71A.20H
PL4501 PL4502 = L7066-1830-UH119: tolerance: 68.2R210.20B
PL4701 PL4801 = L7366-1930H158: tolerance: 68.R1510.20A
PL5001 = L7066-1830-UH119: tolerance: 68.R4710.10M
PL5101 PL5301 PL8651 = L7066-1830-UH119: tolerance: 68.1R01A.20B
PL8501 PL8502 = L7066-1830-UH119: tolerance: 68.R3310.201
PL8601 = L2520-D620H48: tolerance: 068.1R010.1281
PQ4301 Q501 = SOT23DGS2D4H48: tolerance: 84.05067.031
PQ4302 Q2603 Q5703 = SOT23CBE2D4H44: tolerance: 84.T3904.H11
PQ4304 = SOT323CBE2D2H40: tolerance: 84.05212.B11
PQ4305 = SC70-2D2-312H44: tolerance: 084.00024.001K
PQ4306 PQ4402 PQ4405 PQ8501 PQ8604 Q1701 Q1702 Q1801 Q2417 Q2418 Q4001 Q5702 Q6101 Q6201 Q6406 Q6503 Q6701 = SOT-363H44: tolerance: 84.2N702.A3F
PQ4403 PQ8608 Q502 Q1802 Q2401 Q2408 Q2505 Q2602 Q2606 Q2702 Q3101 Q5701 Q6301 Q6401 Q6407 Q6505 Q7902 Q7903 Q9101 Q9103 Q9104 = SOT23DGS2D4H44: tolerance: 84.2N702.J31
PQ4408 = SOT23CBE2D4H44: tolerance: 84.T3906.E11
PQ8607 Q2701 Q3104 Q6504 Q9102 = SOT23DGS2D4H48: tolerance: 84.02130.031
PQ8609 = SOT23DGS2D4H44: tolerance: 084.03419.0031
PR4302 PR4514 = R402H16: tolerance: 64.15025.6DL
PR4303 PR5415 PR8501 PR8502 PR8522 PR8543 PR8624 PR8625 PR8650 PR8661 R405 R507 R802 R1504 R1608-R1610 R1701 R1707 R1714 R1717 R1726 R1814 R1837 R1838 R2002 R2005 R2008 R2017 R2018 R2023 R2024 R2039 R2050-R2052 R2415 R2429 R2430 R2438 R2447 R2453 R2607 R2715 R2919 R2920 R3106 R3109 R3405 R4009 R4026 R5521 R5608-R5611 R5613 R5614 R5705 R6208 R6227 R6302 R6401 R7625 R7921-R7925 R7934-R7936 R7939 R7940 R7942 R9114 R9119 R9120 R9124 R9131 R9138 R9140 R9141 R9148 R9610 = R402H16: tolerance: 63.10334.1DL
PR4304 PR8651 R803 R804 R1821 R2717 R7802 R9133 R9602 R9603 = R402H16: tolerance: 63.22234.1DL
PR4305 PR4306 = R402H16: tolerance: 63.33034.1DL
PR4307 = R603H22: tolerance: 63.24434.15L
PR4308 = R603H22: tolerance: 63.47333.15L
PR4309 PR4312 PR4313 PR4403 PR4420 PR4431 PR4435 PR4508 PR5104 PR5307 PR8539 PR8606 PR8619 PR8673 R411 R414 R603 R806 R1715 R1727 R1737 R1904 R2413 R2417 R2434 R2436 R2449-R2452 R2454 R2461 R2478 R2496 R2499 R2711 R2722 R3111 R3401 R3501 R3502 R4004 R4031 R4032 R5506 R5528 R5529 R5710 R6101 R6102 R6201-R6204 R6209 R6211 R6224 R6303 R6505 R6507 R6702-R6705 R7001 R9612 R9929 R9936 R9937 = R402H16: tolerance: 63.10434.1DL
PR4314 = R1206H28: tolerance: 63.33232.11L
PR4317 PR5102 PR8674 = 0R0603-PAD-U: tolerance: ZZ.R0603.001
PR4402 PR4415 = R3720H40: tolerance: 64.R0105.7FL
PR4404 PR4463 PR4506 PR4512 PR5103 PR5106 PR5126 PR5308 PR5412 PR8546 PR8601 PR8677 R410 R1704 R1708-R1710 R1718 R1720 R1721 R1728 R1813 R1817 R1828 R2402 R2418-R2420 R2422 R2426 R2428 R2440 R2457 R2459 R2460 R2463-R2466 R2472 R2476 R2480 R2482 R2483 R2492 R2497 R2602 R2605 R2612 R2721 R2724 R2729 R4018 R4033 R4045 R4104 R5524 R5526 R5709 R6115 R6117 R6118 R6213 R6215 R6216 R6218 R6219 R6301 R6511 R6515 R6518-R6520 R6706 R6801 R6802 R7904 R7911 R7943-R7948 R9101 R9102 R9113 R9117 R9121-R9123 R9125 R9135 R9137 R9142 R9146 R9153-R9158 R9201 R9801 R9910-R9912 R9914-R9917 R9919 R9925-R9927 R9931 R9933 = R402H16: tolerance: 63.R0034.1DL
PR4405 = R805H24: tolerance: 63.30231.16L
PR4406 PR4424 PR4450 PR4515 PR4517 PR4614 PR4663 PR5304 PR5404 PR5407 PR8503 PR8519 PR8538 R1732 R2401 R2443 R5612 R5615 = R402H16: tolerance: 64.10025.6DL
PR4407 PR8531 PR8535 R7803 = R402H14: tolerance: 63.10034.1DL
PR4408 = R402H16: tolerance: 64.30935.6DL
PR4409 R1719 = R402H16: tolerance: 64.47025.6DL
PR4410 = R402H16: tolerance: 64.40215.6DL
PR4411 PR4412 = R402H16: tolerance: 63.33234.1DL
PR4413 PR4658 PR5409 PR8506 PR8508 PR8524 R1716 R2441 R2444 = R402H16: tolerance: 64.10035.6DL
PR4414 PR4417 PR4419 PR4646 R1811 R2503 R2509 R2514 R2519 R2521 R2522 = R402H14: tolerance: 64.10R05.6DL
PR4416 PR4418 PR4455 PR4458 PR4462 PR4604 PR4607 PR4617 PR4618 PR4630 PR4645 PR4648 PR4650 PR4655 PR4670 PR4671 PR4704 PR4808 PR5414 R404 R504 R602 R805 R1205 R1210 R1212 R1303 R1311 R1503 R1601 R1602 R1703 R1705 R1706 R1712 R1713 R1729 R1736 R1801 R1816 R1819 R2101 R2410-R2412 R2416 R2427 R2431 R2435 R2439 R2445 R2458 R2462 R2469 R2473 R2479 R2481 R2491 R2498 R2601 R2606 R2618 R2708 R2712-R2714 R2723 R2726 R2728 R2901 R3104 R3112 R3113 R3605-R3612 R4002 R4010 R4011 R4014 R4019 R4020 R4023 R4024 R4029 R4030 R4036 R4102 R4301 R5530 R5531 R5535 R5536 R5539 R5719 R6007 R6104 R6110-R6112 R6116 R6121 R6206 R6212 R6217 R6223 R6228 R6304 R6305 R6404 R6405 R6508 R6512 R6521 R7621 R7623 R7912 R7914 R7919 R7920 R7937 R9103 R9110 R9130 R9136 R9143-R9145 R9147 R9149 R9202-R9204 R9601 R9613 = 0R0402-PAD-1: tolerance: ZZ.00PAD.M11
PR4421 PR4423 = R402H16: tolerance: 64.59025.6DL
PR4422 = R603H22: tolerance: 63.20333.15L
PR4425 = R402H16: tolerance: 64.30025.6DL
PR4430 = R402H16: tolerance: 64.47035.6DL
PR4432 = R402H16: tolerance: 63.12434.1DL
PR4433 PR5105 PR8672 R1730 R1802 R6707 R7901 = R402H16: tolerance: 63.10534.1DL
PR4451 = R402H16: tolerance: 64.68035.6DL
PR4502 PR4507 PR5305 PR5306 PR5405 PR5413 PR8505 PR8509 PR8511-PR8514 PR8520 PR8530 PR8534 PR8544 PR8621 PR8671 = 0R0402-PAD: tolerance: ZZ.R0402.001
PR4503 PR4509 = R603H22: tolerance: 64.1R505.55L
PR4505 = R402H16: tolerance: 64.16535.L0L
PR4510 = R402H16: tolerance: 64.13035.L1L
PR4516 = R402H16: tolerance: 64.66515.6DL
PR4601 PR4603 PR4619 PR4624 PR4626 PR8525 R7601 R7618 R7902 = R402H16: tolerance: 64.10015.6DL
PR4602 = R402H16: tolerance: 64.15015.6DL
PR4605 = R402H16: tolerance: 64.82505.6DL
PR4606 PR4633 PR4653 PR4656 = NTC-402H24-U: tolerance: 69.60013.201
PR4608 = R402H16: tolerance: 64.29415.6DL
PR4609 = R402H16: tolerance: 64.14325.6DL
PR4611 = R402H16: tolerance: 64.34025.6DL
PR4612 PR4627 = R603H22: tolerance: 64.80615.55L
PR4613 = R402H16: tolerance: 64.11535.6DL
PR4616 PR4636 PR4649 R3108 = R402H16: tolerance: 64.24915.6DL
PR4621 = R402H16: tolerance: 64.45R35.6DL
PR4622 PR4669 PR8609 = R402H16: tolerance: 64.75R05.6DL
PR4623 PR4668 R503 R719-R722 R726 R734 R735 R1501 R1604 R5540 R7814 R7818 R9129 = R402H14: tolerance: 64.10005.6DL
PR4625 = R402H16: tolerance: 64.37R45.6DL
