# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_A_DQS_DN6: length 70.1
  TOP w0.14: v2(102.62,16.37) 102.42,16.56 v1(102.01,16.56)
  L6 w0.114: v1(94.07,68.13) 94.3,67.91 94.3,67.08 94.01,66.79 93.88,66.79 93.14,66.06 93.14,65.32 92.71,64.89 92.23,64.89 90.72,63.38 90.05,63.38 88.32,61.64 88.32,55.05 89,54.36 89,36.6 101.78,23.82 101.78,20.45 101.66,20.34 100.74,20.34 100.48,20.08 100.48,19.68 100.74,19.42 101.98,19.42 102.11,19.3 102.11,19.09 101.98,18.97 101,18.97 100.75,18.72 100.75,16.86 101.05,16.56 v1(102.01,16.56)
  BOTTOM w0.14: DM1.219 101.22,16.92 101.5,16.65 101.93,16.65 v1(102.01,16.56) ; CPU1.AR66 94.44,68.5 v1(94.07,68.13)
M_A_DQS_DN7: length 73.2
  TOP w0.14: v2(97.84,68.23) 97.77,68.3 v1(97.77,68.8)
  L6 w0.114: v1(97.77,68.8) 97.99,68.58 97.99,67.89 98.16,67.73 98.16,66.64 97.52,66 97.52,65.76 97.52,65.62 97.52,65.53 97.14,65.15 96.58,65.15 94.91,63.47 94.91,63.14 93.17,61.4 93.17,54.48 93.1,54.41 93.1,39.13 107.44,24.78 107.44,24.48 108.31,23.62 108.31,22.85 108.18,22.72 107.47,22.72 107.21,22.46 107.21,22.07 107.47,21.81 108.2,21.81 108.31,21.71 108.31,21.45 107.68,20.82 107.68,20.38 107.56,20.26 107.32,20.26 107.06,20 107.06,19.61 107.32,19.35 108.1,19.35 108.23,19.22 108.23,19.02 108.1,18.89 107.32,18.89 107.06,18.63 107.06,18.24 107.32,17.98 107.56,17.98 107.68,17.86 107.68,16.26 108,15.94 108,15.02 107.75,14.77 v1(107.39,14.77)
  BOTTOM w0.14: v1(97.77,68.8) 97.47,68.5 CPU1.AR61 ; v1(107.39,14.77) 107.31,14.77 106.59,14.04 106.59,12.47 106.48,12.35 DM1.240
M_A_DQS_DP0: length 87.5
  L4 w0.114: v1(86.4,70.65) 86.38,70.65 86.18,70.44 86.16,70.44 85.96,70.24 85.95,70.24 85.59,70.24 85.59,70.24 85.3,70.24 85,70.24 84.51,69.75 82.67,69.75 82.23,69.31 82.23,68.93 82.34,68.82 82.47,68.7 82.47,68.51 82.34,68.38 82.16,68.38 81.92,68.61 81.58,68.61 81.29,68.32 81.29,67.98 81.52,67.76 81.52,67.58 81.37,67.44 81.19,67.44 80.97,67.66 80.5,67.66 76.23,63.39 76.23,58.37 75.9,58.04 75.9,49.2 54.06,27.37 54.06,24.97 49.82,20.73 49.82,20.51 48.35,19.05 46.89,19.05 46.3,18.46 46.3,17.18 46.74,16.75 v1(46.94,16.75)
  BOTTOM w0.089: CPU1.AM69 92.93,70.34 92.93,70.15 92.81,70.02 92.46,70.02 92.4,69.96 92.26,69.86 91.93,69.86 91.9,69.85 91.73,69.8 91.53,69.8 91.39,69.85 90.84,69.85 90.83,69.84 89.71,69.84 89.65,69.78 88.94,69.78 88.78,69.62 87.3,69.62 87.19,69.51 86.69,69.51 86.46,69.74 86.46,70.6 v1(86.4,70.65)
  BOTTOM w0.102: v2(86.91,69.3) 86.91,69.51
  BOTTOM w0.14: v1(46.94,16.75) 47.04,16.85 47.81,16.85 48.08,17.13 48.08,18.27 47.73,18.63 47.73,19.6 DM1.13
M_A_DQS_DP1: length 79
  TOP w0.14: v1(52.21,14.39) v2(52.85,14.39)
  L4 w0.114: v1(52.21,14.39) 52.21,14.26 51.88,13.93 51.59,13.93 51.28,14.24 51.28,17.3 57.46,23.48 57.46,25.84 79.3,47.68 79.3,51.13 79.72,51.55 79.73,51.55 80.25,52.08 80.25,52.09 80.44,52.27 80.44,52.27 81.12,52.94 81.12,54.27 85.64,58.79 85.64,60.74 86.75,61.85 86.75,65.85 87.03,66.13 87.03,66.14 87.94,67.04 87.94,67.23 v1(88.36,67.65)
  BOTTOM w0.089: 92.28,67.78 92.19,67.69 91.91,67.69 91.7,67.62 91.56,67.62 91.46,67.66 91.42,67.67 90.92,67.67
  BOTTOM w0.102: 92.28,67.78 92.28,67.78 CPU1.AT70 ; v1(88.36,67.65) 88.29,67.58 88.29,67.35 88.42,67.22 90.45,67.22 90.77,67.54 90.79,67.54 90.92,67.67
  BOTTOM w0.14: DM1.34 52.98,12.39 52.88,12.48 52.88,14.11 52.6,14.39 v1(52.21,14.39)
M_A_DQS_DP2: length 72.2
  TOP w0.14: v2(57.76,15.61) 57.76,15.63 57.35,16.04 v1(57.35,16.09)
  L4 w0.114: v1(57.35,16.09) 58.02,16.09 58.28,16.35 58.28,18.09 58.34,18.16 60.07,19.89 60.08,19.89 63.05,22.86 63.05,26.04 83.15,46.14 83.15,49.24 89.57,55.66 89.57,56.03 v1(89.79,56.25)
  BOTTOM w0.089: v1(89.79,56.25) 89.39,56.64 89.39,57.12 89.62,57.35 89.62,57.36 89.76,57.36 91.09,58.69 91.09,58.77 91.09,60.81 91.71,61.43 93.74,61.43 95.16,62.85 95.16,63.68 95.17,63.68 95.32,63.84 95.32,64.17 95.29,64.29 95.29,64.51 95.32,64.66 95.45,65.15 95.45,65.53 CPU1.AY64
  BOTTOM w0.14: v1(57.35,16.09) 57.35,16.09 57.48,16.22 57.95,16.22 58.22,16.5 DM1.55
M_A_DQS_DP3: length 70.6
  L4 w0.114: v1(95.62,59.5) 95.2,59.08 95.18,59.08 94.28,58.18 94.28,57.17 94.28,57.17 94.28,56.44 93.28,55.45 93.28,54.82 86.51,48.04 86.51,44.93 66.48,24.9 66.48,19.67 64.66,17.85 64.66,15.67 63.05,14.07 62.92,14.07 v1(62.58,14.41)
  BOTTOM w0.089: CPU1.BA60 98.28,64.86 98.28,64.68 98.35,64.48 98.35,64.34 98.3,64.19 98.3,63.13 98.31,63.12 98.31,63.03 96.18,60.9 96.18,60.74 ; v1(95.62,59.5) 95.92,59.2 96.1,59.2 96.18,59.29 96.18,60.74 ; 96.18,60.74 v2(95.99,60.74)
  BOTTOM w0.14: DM1.76 63.48,11.4 63.48,12.46 63.36,12.57 63.36,13.43 63,13.8 63,13.99 v1(62.58,14.41)
M_A_DQS_DP4: length 76.3
  TOP w0.14: v2(96.39,16.11) 96.16,15.89 v1(95.86,15.89)
  L6 w0.114: v1(95.86,15.89) 95.37,16.38 95.37,18.1 95.49,18.21 95.78,18.21 96.04,18.47 96.04,18.87 95.78,19.13 95.43,19.13 95.3,19.25 95.3,19.68 95.43,19.81 95.66,19.81 95.91,20.06 95.91,20.47 95.66,20.72 95.49,20.72 94.99,21.22 94.99,25.12 85.12,35 85.12,62.25 85.39,62.52 85.39,66.94 85.64,67.2 85.65,67.2 86.6,68.16 90.49,68.16 91.06,68.72 91.06,69.42 93.75,72.12 93.8,72.12 93.97,72.3 95.01,72.3 95.48,72.76 v1(95.48,72.78)
  BOTTOM w0.14: v1(95.86,15.89) 96.65,15.1 96.65,12.76 96.48,12.58 DM1.200 ; v1(95.48,72.78) 95.48,72.76 95.39,72.68 95.39,72.67 95.21,72.49 CPU1.AH65
M_A_DQS_DP5: length 82.8
  L6 w0.114: v1(83.06,72.35) 83.06,72.18 76.4,65.52 76.4,55.87 78.97,53.3 78.97,35.07 89.81,24.22 89.81,19.62 89.93,19.51 90.62,19.51 90.88,19.24 90.88,18.85 90.62,18.59 89.93,18.59 89.81,18.48 89.81,17.54 90.51,16.85 90.92,16.85 91.25,17.17 v1(91.25,17.28)
  BOTTOM w0.089: CPU1.AG70 92.28,72.9 92.08,73.1 91.91,73.1 91.7,73.16 91.56,73.16 91.42,73.12 91.07,73.12 90.46,73.73 90.45,73.73 90.39,73.79 89.32,73.79 89.06,73.53 88.48,73.53 88.45,73.5
  BOTTOM w0.102: 88.45,73.5 88.45,73.5
  BOTTOM w0.14: DM1.179 91.22,18.82 90.98,18.57 90.98,18.32 90.96,18.29 90.96,18.29 90.7,18.03 90.7,17.18 90.87,17 91.12,17 91.25,17.13 v1(91.25,17.28) ; 84.12,73.24 86.9,73.24 87.15,73.5 88.45,73.5 ; 84.12,73.24 82.8,73.24 82.7,73.14 82.7,72.96 82.83,72.83 83.52,72.83 83.64,72.71 83.64,72.48 83.52,72.35 v1(83.06,72.35) ; 84.12,73.24 v2(84.12,73.01)
M_A_DQS_DP6: length 70
  TOP w0.14: v1(102.01,17.28) 101.71,17.28 v2(101.47,17.51)
  L6 w0.114: v1(102.01,17.28) 102.01,17.21 101.59,16.79 101.14,16.79 100.98,16.96 100.98,18.62 101.09,18.74 102.08,18.74 102.34,19 102.34,19.39 102.08,19.65 100.84,19.65 100.71,19.78 100.71,19.98 100.84,20.11 101.76,20.11 102.01,20.36 102.01,23.92 89.23,36.69 89.23,54.46 88.54,55.14 88.54,61.55 90.15,63.15 90.81,63.15 92.32,64.66 92.81,64.66 93.37,65.22 93.37,65.96 93.97,66.56 94.1,66.56 94.53,66.99 94.53,67.84 94.84,68.16 v1(94.93,68.16)
  BOTTOM w0.14: v1(94.93,68.16) 95.15,68.16 95.44,68.45 CPU1.AR65 ; v1(102.01,17.28) 102.01,17.17 101.75,16.9 101.61,16.9 101.48,17.03 101.48,18.51 101.72,18.75 DM1.221
M_A_DQS_DP7: length 73.3
  TOP w0.14: v1(107.42,14.11) 106.95,14.11 v2(106.77,13.93)
  L6 w0.114: v1(107.42,14.11) 108.23,14.92 108.23,16.03 107.91,16.35 107.91,17.96 107.66,18.21 107.42,18.21 107.29,18.33 107.29,18.54 107.42,18.66 108.2,18.66 108.46,18.93 108.46,19.32 108.2,19.58 107.42,19.58 107.29,19.71 107.29,19.91 107.42,20.04 107.66,20.04 107.91,20.28 107.91,20.73 108.53,21.36 108.53,21.8 108.3,22.04 107.57,22.04 107.44,22.16 107.44,22.37 107.57,22.5 108.27,22.5 108.53,22.76 108.53,23.72 107.67,24.58 107.67,24.88 93.33,39.22 93.33,54.31 93.4,54.39 93.4,61.31 95.13,63.04 95.13,63.38 96.68,64.92 97.24,64.92 97.75,65.43 97.75,65.53 97.75,65.62 97.75,65.76 97.75,65.91 98.39,66.54 98.39,67.82 98.22,67.99 98.22,68.4 v1(98.61,68.79)
  BOTTOM w0.14: v1(107.42,14.11) 107.34,14.18 107.09,14.18 106.85,13.94 106.85,12.46 106.97,12.33 DM1.242 ; v1(98.61,68.79) 98.32,68.5 CPU1.AR60
M_A_PARITY: length 67.9
  TOP w0.216: v1(80.92,19.6) v2(80.92,18.93)
  L4 w0.102: 103.37,66.04 102.82,66.58 102.82,67.37 102.06,68.13 102.06,68.73 102.17,68.85 102.59,68.85 103.22,68.22 v1(103.22,68.15)
  L4 w0.178: 103.37,66.04 103.49,65.91 103.49,46.93 103.48,46.92 103.48,42.15 88.69,27.37 88.69,27.37 v1(80.92,19.6)
  BOTTOM w0.216: CPU1.AT52 102.92,67.85 v1(103.22,68.15) ; v1(80.92,19.6) 81.29,19.6 81.97,20.28 81.97,21.24 81.6,21.61 80.42,21.61 80.22,21.42 DM1.143
M_B_A0: length 100
  TOP w0.216: v1(154.91,16.42) 155.19,16.42 155.42,16.65 v2(155.45,16.65)
  L6 w0.089: 103.63,54.09 103.76,54.21 103.76,55 103.91,55.15 v1(104.19,55.15)
  L6 w0.178: 103.63,54.09 103.31,53.77 103.31,50.42 103.76,49.97 103.76,46.56 114.85,35.47 114.85,35.22 114.7,35.07 114.7,34.82 114.95,34.57 115.2,34.57 115.35,34.72 115.6,34.72 116.05,34.27 116.05,34.02 115.88,33.84 115.88,33.59 116.13,33.34 116.38,33.34 116.55,33.51 116.81,33.51 117.06,33.26 117.06,33.01 116.88,32.83 116.88,32.58 117.13,32.33 117.38,32.33 117.56,32.51 117.81,32.51 118.06,32.26 118.06,32.01 117.89,31.83 117.89,31.58 118.14,31.33 118.39,31.33 118.57,31.5 118.82,31.5 122.02,28.3 122.02,28.05 121.87,27.9 121.87,27.65 122.12,27.4 122.37,27.4 122.52,27.55 122.77,27.55 123.02,27.3 123.02,27.05 122.87,26.89 122.87,26.64 123.12,26.39 123.37,26.39 123.53,26.54 123.78,26.54 124.76,25.56 148.62,25.56 153.84,20.34 154.64,20.34 155.52,19.46 155.52,16.9 155.04,16.42 v1(154.91,16.42)
  BOTTOM w0.089: CPU1.BA46 105.98,64.5 105.98,64.5 105.9,64.17 105.9,63.21 105.9,63.21 105.9,62.72 105.34,62.16 105.34,58.4 105.38,58.36
  BOTTOM w0.152: 105.38,58.36 105.38,56.32 105.77,55.94 105.77,55.46 105.64,55.33 104.37,55.33 v1(104.19,55.15)
  BOTTOM w0.216: DM2.144 157.48,11.4 157.48,12.91 157.69,13.12 157.95,13.12 158.17,13.34 158.17,13.77 157.95,13.99 157.69,13.99 157.48,14.2 157.48,15.2 157.14,15.54 155.79,15.54 v1(154.91,16.42)
M_B_A1: length 100.6
  TOP w0.216: v2(154.94,18.32) 154.96,18.3 v1(154.96,17.77)
  L6 w0.089: 102.74,53.07 102.74,53.76 103.57,54.59 103.57,55.97 103.7,56.09 103.93,56.09 v1(104.21,55.82)
  L6 w0.178: v1(154.96,17.77) 155.19,18 155.19,19.31 154.64,19.87 153.63,19.87 148.42,25.08 123.69,25.08 120.92,27.85 120.92,28.72 119.16,30.48 118.29,30.48 113.8,34.96 113.8,35.22 113.98,35.39 113.98,35.64 113.73,35.89 113.47,35.89 112.87,35.29 112.59,35.29 112.37,35.51 112.37,35.79 112.97,36.39 112.97,36.64 112.72,36.9 112.47,36.9 111.85,36.28 111.6,36.28 111.35,36.53 111.35,36.78 111.97,37.4 111.97,37.65 111.71,37.9 111.46,37.9 110.91,37.35 110.62,37.35 110.41,37.56 110.41,37.85 110.96,38.41 110.96,38.66 110.71,38.91 110.46,38.91 109.9,38.36 109.61,38.36 109.4,38.56 109.4,38.86 109.95,39.41 109.95,39.66 109.7,39.91 109.45,39.91 108.89,39.35 108.59,39.35 108.38,39.56 108.38,39.85 108.95,40.42 108.95,40.69 107.94,41.69 103.28,46.36 103.28,49.57 102.74,50.1 102.74,53.07
  BOTTOM w0.089: 105.08,57.72 105.08,62.15 105.72,62.8 105.72,63.13 105.72,63.14 105.72,64.19 105.77,64.38 105.77,65.01 105.85,65.18 CPU1.AY46
  BOTTOM w0.152: 105.08,57.72 105.08,57.26 104.83,57.01 104.83,56.53 105.08,56.27 105.08,55.74 104.95,55.61 104.41,55.61 v1(104.21,55.82)
  BOTTOM w0.216: v1(154.96,17.77) 154.81,17.77 154.56,18.02 154.56,18.4 154.73,18.57 DM2.133
M_B_A2: length 100.2
  TOP w0.216: v1(153.84,15.38) 153.84,15.91 v2(153.82,15.94)
  L6 w0.089: v1(104.16,57.72) 103.96,57.72 103.69,58 103.69,58.89 103.56,59.01 103.31,59.01 103.19,58.89 103.19,54.74 102.29,53.85 102.26,53.85 101.78,53.36 101.78,52.89
  L6 w0.178: v1(153.84,15.38) 153.84,18.04 154.2,18.4 154.2,18.73 153.94,19 153.14,19 148.06,24.08 123.32,24.08 119.95,27.45 119.95,28.32 118.76,29.51 117.74,29.51 116.69,30.57 115.94,30.57 115.57,30.94 115.57,31.19 115.74,31.36 115.74,31.62 115.49,31.87 115.24,31.87 115.07,31.7 114.81,31.7 114.56,31.95 114.56,32.2 114.73,32.37 114.73,32.62 114.48,32.87 114.23,32.87 114.06,32.7 113.81,32.7 113.56,32.95 113.56,33.2 113.73,33.38 113.73,33.63 113.48,33.88 113.23,33.88 113.05,33.71 112.8,33.71 105.89,40.62 105.89,42.38 102.31,45.96 102.31,49.13 101.78,49.67 101.78,52.89
  BOTTOM w0.089: CPU1.AY47 105.33,65.71 105.13,65.44 105.13,64.83 105.06,64.51 105.06,64.3 105.09,64.17 105.09,63.7 104.72,63.33 104.72,58.86 104.57,58.71
  BOTTOM w0.152: 104.57,58.71 104.56,58.7 104.56,58.07 104.21,57.72 v1(104.16,57.72)
  BOTTOM w0.216: v1(153.84,15.38) 153.92,15.38 154.48,14.82 154.48,14.7 154.86,14.31 154.86,13.52 154.51,13.17 154.51,13.17 154.48,13.13 154.48,11.4 DM2.132
M_B_A3: length 99
  TOP w0.216: v1(154.96,14.87) 155.55,14.87 v2(155.57,14.84)
  L6 w0.178: v1(154.96,14.87) 155.16,14.67 155.16,13.42 155.54,13.04 156.03,13.04 156.16,13.17 156.16,15 155.47,15.68 155.47,16.19 155.98,16.7 155.98,19.68 154.84,20.83 154.04,20.83 148.82,26.05 124.99,26.05 104.24,46.79 104.24,50.28 103.79,50.73 103.79,53.61 104.17,53.99 v1(104.17,54.49)
  BOTTOM w0.089: 105.63,58.54 105.52,58.64 105.52,62 106.14,62.62 106.14,63.77 106.16,63.79 CPU1.BB46
  BOTTOM w0.152: 105.63,58.54 105.63,56.56 106.15,56.04 106.15,54.62 106.02,54.49 105.58,54.49 105.43,54.65 105.43,54.87 105.3,55 104.95,55 104.44,54.49 v1(104.17,54.49)
  BOTTOM w0.216: v1(154.96,14.87) 154.96,14.92 154.23,15.65 154.23,19.6 DM2.131
M_B_A4: length 99.9
  TOP w0.216: v2(153.42,13.57) 153.92,14.08 v1(153.92,14.08)
  L6 w0.089: 102.26,53.05 102.26,53.27 102.26,53.27 102.26,53.55 103.38,54.67 103.38,56.2 103.5,56.32 103.68,56.32 103.81,56.45 103.81,56.63 103.68,56.75 103.5,56.75 103.38,56.88 103.38,57.44 103.5,57.57 103.71,57.57 103.9,57.37 103.9,57.19 104.01,57.09 v1(104.18,57.09)
  L6 w0.178: v1(153.92,14.08) 154.19,13.81 154.59,13.81 154.76,13.98 154.76,14.39 154.34,14.81 154.34,17.94 154.76,18.37 154.76,19.25 154.64,19.38 153.44,19.38 152.21,20.61 148.24,24.57 123.51,24.57 120.43,27.65 120.43,28.52 118.96,30 118.09,30 113.58,34.5 112.69,34.5 107.38,39.82 107.38,40.07 107.98,40.68 107.98,40.97 107.77,41.18 107.48,41.18 106.87,40.57 106.62,40.57 106.37,40.82 106.37,41.07 106.96,41.67 106.96,41.99 102.79,46.16 102.79,49.37 102.26,49.9 102.26,53.05
  BOTTOM w0.089: CPU1.BA47 105.31,64.78 105.23,64.49 105.23,64.33 105.27,64.2 105.27,63.63 104.9,63.26 104.9,58.7 104.8,58.6
  BOTTOM w0.152: 104.8,58.6 104.8,57.39 104.5,57.09 104.18,57.09 v1(104.18,57.09)
  BOTTOM w0.216: v1(153.92,14.08) 153.73,14.08 153.48,13.83 153.48,11.4 DM2.128
M_B_A5: length 99.9
  TOP w0.216: v1(152.83,13.88) 152.7,13.88 152.32,14.26 v2(152.3,14.26)
  L6 w0.089: 101.22,53.3 101.96,54.04 102.21,54.04 103,54.82 103,60.34 103.12,60.46 103.3,60.46 103.43,60.34 103.43,59.57 103.96,59.04 v1(104.09,59.04)
  L6 w0.178: v1(152.83,13.88) 153.39,14.44 153.39,18.06 147.86,23.59 123.12,23.59 119.47,27.25 119.47,28.12 118.56,29.03 117.54,29.03 116.49,30.08 115.74,30.08 104.73,41.1 104.73,41.35 105.36,41.98 105.36,42.23 105.11,42.48 104.86,42.48 104.23,41.85 103.98,41.85 103.73,42.1 103.73,42.35 104.35,42.98 104.35,43.24 101.83,45.76 101.83,48.88 101.22,49.49 101.22,53.3
  BOTTOM w0.089: CPU1.AY48 104.59,65.11 104.38,64.26 104.38,63.82 104.13,63.57 104.13,61.77 103.34,60.99 103.34,60.61
  BOTTOM w0.152: 103.34,60.61 103.43,60.52 103.43,59.69 v1(104.09,59.04)
  BOTTOM w0.216: v1(152.83,13.88) 152.98,13.74 DM2.126
M_B_A6: length 98.2
  TOP w0.216: v1(152.6,16.22) 152.32,16.22 v2(152.07,15.96)
  L6 w0.089: v1(104,60.97) 104.06,61.03 104.06,61.61 103.63,62.04 102.79,62.04 102.2,61.44 102.2,59.62 102.34,59.48 102.34,56.46 102.62,56.18 102.62,54.98 102.23,54.6 101.37,54.6 100.23,53.45 100.23,53.4
  L6 w0.178: 100.23,53.4 100.23,48.37 100.74,47.86 100.74,43.72 115.34,29.12 116.09,29.12 122.58,22.63 147.46,22.63 149.17,20.91 149.17,20.47 148.95,20.24 148.95,20.05 149.23,19.77 149.48,19.77 149.76,20.05 150.04,20.05 150.47,19.62 150.47,19.52 150.07,19.13 150.07,18.95 150.4,18.62 150.58,18.62 150.97,19.02 151.22,19.02 152.18,18.06 152.18,16.36 152.32,16.22 v1(152.6,16.22)
  BOTTOM w0.089: 104.25,61.24 104.31,61.31 104.31,63.5 104.56,63.74 104.56,64.19 104.6,64.38 CPU1.BA48
  BOTTOM w0.152: v1(104,60.97) 104.01,60.97 104.01,61 104.25,61.24
  BOTTOM w0.216: v1(152.6,16.22) 152.78,16.04 153.21,16.04 153.36,16.19 153.36,18.45 153.23,18.59 153.23,19.6 DM2.127
M_B_A7: length 101.2
  TOP w0.216: v1(105.04,68.74) 105.05,68.72 v2(105.05,68.11)
  L6 w0.114: v1(105.04,68.74) 105.04,68.4 104.74,68.11 104.74,65 104.37,64.63
  L6 w0.178: 104.37,64.63 104.1,64.36 104.1,62.84 103.76,62.49 102.72,62.49 101.31,61.09 101.31,60.54 101.34,60.51 101.34,55.05 99.75,53.45 99.75,48.11 100,47.85 100.26,47.59 100.26,43.52 115.14,28.64 115.89,28.64 122.38,22.15 147.26,22.15 148.03,21.37 148.03,20.44 150.29,18.17 150.8,18.17 151.03,18.4 151.45,18.4 151.83,18.02 151.83,15.64 152.27,15.2 152.27,14.46 152.15,14.34 151.62,14.34 150.93,13.64 150.93,13.12 151.1,12.94 151.83,12.94 v1(151.97,13.07)
  BOTTOM w0.216: DM2.122 151.98,12.85 151.97,12.86 v1(151.97,13.07) ; CPU1.AP48 104.62,69.15 v1(105.04,68.74)
M_B_A8: length 96.9
  TOP w0.216: v2(152.65,18.32) 152.65,18.32 v1(152.65,17.71)
  L6 w0.089: 102.16,54.36 102.26,54.36 102.81,54.9 102.81,56.81 102.72,56.9 102.63,56.9 102.54,56.99 102.54,57.17 102.63,57.26 102.72,57.26 102.81,57.35 102.81,57.52 102.72,57.61 102.63,57.61 102.54,57.7 102.54,57.88 102.63,57.97 102.72,57.97 102.81,58.06 102.81,58.23 102.72,58.32 102.63,58.32 102.54,58.41 102.54,58.59 102.63,58.68 102.72,58.68 102.81,58.77 102.81,58.95 102.72,59.03 102.63,59.03 102.54,59.12 102.54,59.3 102.63,59.39 102.72,59.39 102.81,59.48 102.81,59.66 102.72,59.75 102.63,59.75 102.54,59.83 102.54,60.01 102.63,60.1 102.72,60.1 102.81,60.19 102.81,60.39 102.68,60.51 102.59,60.51 102.46,60.64 102.46,61.28 102.57,61.38 102.75,61.38 102.84,61.29 102.84,61.11 102.93,61.02 103.11,61.02 103.2,61.11 103.2,61.29 103.28,61.38 103.49,61.38 103.62,61.25 103.62,60.02 103.94,59.7 v1(104.06,59.7)
  L6 w0.178: v1(152.65,17.71) 152.65,18.12 147.66,23.11 122.78,23.11 116.29,29.6 115.54,29.6 102.84,42.3 102.84,42.55 103.46,43.17 103.46,43.42 103.05,43.82 102.8,43.82 102.16,43.19 101.98,43.19 101.66,43.51 101.66,43.69 102.3,44.33 102.3,44.58 101.89,44.98 101.42,44.98 101.23,45.18 101.23,48.57 100.97,48.83 100.71,49.08 100.71,53.43 101.64,54.36 102.16,54.36
  BOTTOM w0.089: CPU1.BB48 104.83,63.73 104.52,63.42 104.52,60.85 104.49,60.82
  BOTTOM w0.152: v1(104.06,59.7) 104.29,59.7 104.49,59.9 104.49,60.82
  BOTTOM w0.216: v1(152.65,17.71) 152.73,17.79 DM2.125
M_B_A9: length 98.5
  TOP w0.216: v1(151.08,15.91) v2(150.47,15.91)
  L6 w0.114: 102.8,64.78 102.8,68.35 v1(103.27,68.82)
  L6 w0.178: 102.8,64.78 99.49,61.46 99.49,54.67 98.3,53.48 98.3,47.36 98.81,46.84 98.81,43.32 98.81,42.92 114.54,27.19 115.29,27.19 121.78,20.7 146.29,20.7 149.72,17.27 149.72,16.46 150.27,15.91 v1(151.08,15.91)
  BOTTOM w0.216: v1(103.27,68.82) 103.6,69.15 CPU1.AP50 ; v1(151.08,15.91) 151.43,15.56 151.92,15.56 152.04,15.68 152.04,16.97 151.63,17.38 151.63,18.25 151.73,18.34 DM2.121
M_B_A10: length 99.5
  TOP w0.216: v2(161.01,13.65) 160.66,14.01 v1(160.5,14.01)
  L6 w0.089: 106.55,55.48 107.05,55.98 107.05,57.34 106.92,57.47 106.59,57.47 106.47,57.34 v1(106.47,57.32)
  L6 w0.178: 106.55,55.48 106.21,55.14 106.21,52.03 106.66,51.58 106.66,47.79 125.98,28.47 151.36,28.47 158.21,21.62 158.21,14.97 158.37,14.81 158.37,13.82 158.13,13.59 158.13,13.18 158.37,12.94 159.88,12.94 160.01,13.07 160.01,13.56 160.45,14.01 v1(160.5,14.01)
  BOTTOM w0.089: CPU1.AW46 106.26,65.74 106.37,65.4 106.37,64.98 106.42,64.89 106.42,63.78 106.33,63.7 106.33,63.69 106.33,63.69 106.33,62.48 105.73,61.88
  BOTTOM w0.152: v1(106.47,57.32) 106.29,57.32 106.01,57.6 106.01,58.56 105.73,58.84 105.73,61.88
  BOTTOM w0.216: DM2.146 159.98,11.92 159.98,11.92 159.98,12.3 159.16,13.11 159.16,13.86 159.49,14.18 160.32,14.18 v1(160.5,14.01)
M_B_A11: length 103.5
  TOP w0.216: v2(104.11,69.58) 104.11,70.15 v1(104.15,70.18)
  L6 w0.114: 104.24,64.88 104.54,65.18 104.54,69.79 v1(104.15,70.18)
  L6 w0.178: 104.24,64.88 103.84,64.47 103.84,64.02 101.05,61.23 101.05,60.43 101.06,60.42 101.06,55.27 99.26,53.48 99.26,47.9 99.52,47.65 99.78,47.39 99.78,43.32 114.94,28.15 115.69,28.15 122.18,21.66 146.98,21.66 147.55,21.1 147.55,20.38 150.28,17.65 151.26,17.65 151.55,17.36 151.55,14.81 151.18,14.44 v1(150.37,14.44)
  BOTTOM w0.216: DM2.120 151.48,11.4 151.48,13.91 151.48,13.91 151.48,13.94 151.75,14.22 152,14.22 152.23,14.44 152.23,14.79 151.98,15.04 150.97,15.04 v1(150.37,14.44) ; v1(104.15,70.18) 104.52,69.8 CPU1.AN48
M_B_A12: length 100.7
  TOP w0.216: v1(151.08,17.21) 150.6,17.21 150.47,17.33 v2(150.44,17.33)
  L6 w0.114: 103.68,65.11 103.68,65.76 103.57,65.87 103.15,65.87 103.02,66 103.02,66.2 103.15,66.33 103.57,66.33 103.68,66.44 103.68,69.86 103.37,70.18 v1(103.24,70.18)
  L6 w0.178: v1(151.08,17.21) 150.7,16.83 150.7,16.8 150.5,16.6 150.2,16.6 150,16.8 150,17.38 147.06,20.32 147.06,20.87 146.75,21.18 121.98,21.18 115.49,27.67 114.74,27.67 99.29,43.12 99.29,47.04 98.78,47.56 98.78,53.56 100.2,54.99 100.34,54.99 100.78,55.43 100.78,60.16 100.55,60.38 100.18,60.38 99.95,60.61 99.95,61.38 100.3,61.73 100.55,61.73 100.63,61.65 100.88,61.65 101.13,61.9 101.13,62.15 101.05,62.23 101.05,62.48 101.31,62.73 101.56,62.73 101.64,62.66 101.89,62.66 102.14,62.91 102.14,63.16 102.06,63.24 102.06,63.49 102.31,63.74 102.56,63.74 102.64,63.66 102.89,63.66 103.15,63.91 103.15,64.16 103.07,64.24 103.07,64.49 103.68,65.11
  BOTTOM w0.216: v1(103.24,70.18) 103.61,69.8 CPU1.AN50 ; v1(151.08,17.21) 150.95,17.33 150.95,17.7 151.23,17.97 151.23,19.6 DM2.119
M_B_A13: length 96.9
  TOP w0.216: v1(161.92,15.05) 161.54,15.05 v2(161.37,14.87)
  L6 w0.114: 108.67,53.12 108.67,54.84 108.67,54.84 108.67,56.46 108.32,56.81 v1(108.04,56.81)
  L6 w0.178: v1(161.92,15.05) 161.65,15.05 161.36,15.33 161.36,16.12 160.53,16.95 160.53,17.5 160.83,17.8 161.24,17.8 161.42,17.98 161.42,18.34 161.24,18.51 160.76,18.51 160.55,18.72 160.55,19.02 160.76,19.23 161.24,19.23 161.42,19.4 161.42,19.76 161.24,19.94 160.88,19.94 160.71,20.12 160.71,22.54 152.36,30.88 129.48,30.88 125.5,34.86 125.22,34.86 124.34,33.97 123.9,33.97 118.46,39.42 118.46,39.98 109.07,49.37 109.07,52.72 108.67,53.12
  BOTTOM w0.089: CPU1.BA43 107.73,64.91 107.63,64.66 107.59,64.49 107.59,64.32 107.62,64.19 107.62,63.67 107.29,63.33 107.29,63.3 107.29,63.3 107.29,62.97 107.33,62.92 107.33,59.53 107.33,59.53 107.33,59.35
  BOTTOM w0.152: v1(108.04,56.81) 107.93,56.7 107.47,56.7 107.28,56.89 107.28,59.3 107.33,59.35
  BOTTOM w0.216: DM2.158 162.98,14.64 162.47,15.15 162.02,15.15 v1(161.92,15.05)
M_B_A14: length 100.4
  TOP w0.216: v2(161.82,18.27) 161.82,18.27 v1(161.82,17.69)
  L6 w0.114: 109.55,53.35 108.9,54.01 108.9,57.69 108.47,58.11 v1(108.04,58.11)
  L6 w0.178: 109.55,53.35 109.55,49.57 119.03,40.08 119.03,39.71 120.78,37.96 121.41,37.96 122.22,38.77 122.48,38.77 122.73,38.52 122.73,38.27 121.73,37.27 121.73,36.98 121.94,36.77 122.23,36.77 123.23,37.77 123.48,37.77 123.73,37.52 123.73,37.27 122.7,36.23 122.7,35.94 122.91,35.73 123.2,35.73 124.24,36.76 124.49,36.76 124.74,36.51 124.74,36.26 123.92,35.44 123.92,35.19 124.1,35.01 124.35,35.01 125.11,35.76 125.36,35.76 126.36,34.76 126.38,34.76 129.77,31.37 152.64,31.37 161.7,22.31 161.7,21.85 161.21,21.37 161.21,20.79 161.82,20.18 v1(161.82,17.69)
  BOTTOM w0.089: 107.62,62.06 107.62,62.48 108.08,62.94 108.08,62.96 108.09,62.97 108.09,63.3 108.07,63.31 108.07,64.23 108.11,64.31 108.11,64.49 108.07,64.62 108.07,64.84 108.11,64.98 108.11,65.43 108.23,65.55 108.23,65.83 108.04,66.03 107.75,66.03 107.57,65.85 107.57,65.67 CPU1.AY44
  BOTTOM w0.152: 107.62,62.06 107.56,62 107.56,59.46 107.57,59.45 107.57,58.37 107.84,58.11 v1(108.04,58.11)
  BOTTOM w0.216: v1(161.82,17.69) 161.47,17.69 161.22,17.93 DM2.151
M_B_A15: length 100.3
  L6 w0.114: 108.15,53.73 108.15,54.72 108.45,55.02 108.45,55.94 108.24,56.16 v1(108.04,56.16)
  L6 w0.178: 108.15,53.73 108.15,52.92 108.59,52.49 108.59,49.17 113.68,44.07 113.68,43.66 113.97,43.37 114.39,43.37 114.68,43.07 114.68,42.66 114.98,42.36 115.39,42.36 115.69,42.06 115.69,41.65 115.98,41.35 116.4,41.35 116.69,41.06 116.69,40.64 116.99,40.35 117.4,40.35 117.9,39.85 117.9,39.3 123.88,33.31 124.41,33.31 125.04,33.94 125.62,33.94 125.79,33.77 125.79,33.52 125,32.72 125,32.47 125.25,32.22 125.5,32.22 126.3,33.01 126.55,33.01 129.16,30.4 152.16,30.4 160.22,22.34 160.22,16.72 161.08,15.86 161.08,14.06 161.39,13.75 v1(161.95,13.75)
  BOTTOM w0.089: CPU1.AY43 107.57,65.33 107.57,65.15 107.45,64.66 107.41,64.51 107.41,64.29 107.45,64.17 107.45,63.74 107.11,63.41 107.11,63.37 107.11,63.37 107.11,62.89 107.11,62.89 107.11,59.49 106.92,59.3
  BOTTOM w0.152: v1(108.04,56.16) 107.89,56.16 107.09,55.36 106.91,55.36 v2(106.66,55.61) 106.43,55.83 106.43,56.01 106.76,56.34 106.8,56.34 106.92,56.46 106.92,59.3
  BOTTOM w0.216: DM2.156 162.48,11.4 162.48,12.37 162.66,12.55 162.66,13.83 162.5,13.98 162.18,13.98 v1(161.95,13.75)
M_B_A16: length 99.4
  TOP w0.216: v1(160.52,15.1) 160.12,15.1 v2(159.94,14.92)
  L6 w0.089: v1(106.47,58.62) 106.47,58.69 106.84,59.07 107.11,59.07 107.24,58.94 107.24,58.5 106.87,58.13 106.87,57.86 107.24,57.49 107.24,55.35 106.81,54.92 106.81,54.85
  L6 w0.178: 106.81,54.85 106.69,54.73 106.69,52.23 107.14,51.78 107.14,47.99 126.18,28.95 151.56,28.95 158.7,21.82 158.7,16.52 159.11,16.11 159.11,15.3 158.7,14.89 158.7,14.15 158.92,13.93 159.59,13.93 159.72,14.06 159.72,14.97 159.84,15.1 v1(160.52,15.1)
  BOTTOM w0.089: CPU1.AW44 107.21,65.97 107.21,65.72 106.98,65.49 106.98,65.03 106.62,64.61 106.62,63.74 106.51,63.62 106.51,63.62 106.51,63.61 106.51,62.24 106.41,62.14
  BOTTOM w0.152: 106.41,62.14 106.01,61.74 106.01,58.95 106.34,58.62 v1(106.47,58.62)
  BOTTOM w0.216: v1(160.52,15.1) 161.14,15.1 161.48,14.76 161.48,11.4 DM2.152
M_B_ACT_N: length 100.7
  TOP w0.216: v1(148.7,13.96) 148.7,14.09 149.05,14.44 v2(149.07,14.44)
  L6 w0.114: v1(102.3,70.14) 102.73,69.72 102.73,69.21 102.28,68.76 102.28,65.36 102.12,65.2
  L6 w0.178: 102.12,65.2 98.04,61.12 98.04,54.19 97.33,53.48 97.33,53.25 96.94,52.86 96.94,43.43 114.14,26.22 114.89,26.22 116.03,25.08 116.03,24.34 120.51,19.86 121.38,19.86 121.51,19.73 146.32,19.73 148.18,17.87 148.18,16.3 149.35,15.12 149.35,14.61 v1(148.7,13.96)
  BOTTOM w0.216: CPU1.AN53 102.18,70.14 v1(102.3,70.14) ; v1(148.7,13.96) 148.94,13.96 149.98,12.93 DM2.114
M_B_ALERT_N: length 86.9
  TOP w0.216: v1(144.3,15.61) v2(144.3,16.22)
  L4 w0.178: v1(144.3,15.61) 144.3,18.58 144.48,18.76 144.48,20.59 144.48,20.6 144.48,26.88 129.25,42.11 129.25,48.41 128.72,48.94 128.72,51.89 127.5,53.1 127.2,53.1 125.16,55.14 125.16,55.54 120.12,60.59 120.12,65.24 119.15,66.21 118.77,66.21 118.76,66.2 118.19,66.2 117.09,67.3 116.42,67.3 116.19,67.07 115.85,67.07 115.55,67.37 114.66,67.37 114.35,67.07 114.02,67.07 113.84,67.24 112.7,67.24 111.96,67.98 111.18,67.98 110.16,66.96 109.51,66.96 109.19,67.29 109.19,67.65 108.86,67.99 108.71,67.99 107.4,69.29 107.4,69.71 v1(107.8,70.11)
  BOTTOM w0.216: v1(144.3,15.61) 147.07,15.61 147.76,14.91 148.49,14.91 150.47,12.93 DM2.116 ; v1(107.8,70.11) 107.5,69.8 CPU1.AN43
M_B_BA0: length 99.1
  TOP w0.216: v2(159.08,16.04) 159.36,16.32 v1(159.58,16.32)
  L6 w0.089: v1(106.47,59.26) 106.48,59.24 106.68,59.24 106.91,59.47 106.91,60.95 107.04,61.07 107.3,61.07 107.43,60.95 107.43,55.27 107.19,55.04 107.19,54.6 107.19,54.6
  L6 w0.178: v1(159.58,16.32) 159.18,16.72 159.18,22.02 151.76,29.44 126.38,29.44 107.62,48.19 107.62,51.98 107.17,52.43 107.17,54.58 107.19,54.6
  BOTTOM w0.089: CPU1.BB44 107.19,63.77 106.89,63.47 106.89,63.47 106.88,63.46 106.88,60.74 106.9,60.72 106.9,60.06
  BOTTOM w0.152: v1(106.47,59.26) 106.9,59.69 106.9,60.06
  BOTTOM w0.216: v1(159.58,16.32) 159.58,16.35 159.03,16.9 158.5,16.9 158.19,16.6 158.19,15.93 158.19,15.93 158.19,15.54 158.19,15.54 158.19,14.97 158.62,14.54 160.73,14.54 160.98,14.29 DM2.150
M_B_BA1: length 99.2
  TOP w0.216: v1(159.66,17.64) 159.66,18.19 v2(159.66,18.2)
  L6 w0.089: 107.65,54.6 107.64,54.61 107.64,60.5 107.61,60.54 107.61,60.86 107.83,61.08 107.83,61.08 108.24,61.5 108.24,61.84 108,62.09 107.64,62.09 107.56,62 107.56,61.43 107.45,61.33 107.3,61.33 107.2,61.43 107.2,62 107.11,62.09 106.79,62.09 106.35,61.66 106.35,60.69 106.48,60.57 v1(106.49,60.57)
  L6 w0.178: 107.65,54.6 107.65,52.63 108.1,52.18 108.1,48.41 109.11,47.4 109.36,47.4 109.37,47.41 109.62,47.41 109.87,47.16 109.87,46.91 109.86,46.9 109.86,46.65 110.11,46.4 110.36,46.4 110.37,46.41 110.63,46.41 110.88,46.16 110.88,45.9 110.87,45.9 110.87,45.64 111.12,45.39 111.37,45.39 111.38,45.4 111.63,45.4 111.88,45.15 111.88,44.9 111.87,44.89 111.87,44.64 112.12,44.39 112.38,44.39 112.39,44.4 112.64,44.4 112.89,44.14 112.89,43.89 112.88,43.88 112.88,43.63 125.19,31.32 125.44,31.32 126.34,32.22 126.59,32.22 126.84,31.97 126.84,31.72 125.94,30.82 125.94,30.57 126.29,30.23 126.77,30.23 127.54,30.99 127.83,30.99 128.91,29.92 151.96,29.92 159.66,22.22 v1(159.66,17.64)
  BOTTOM w0.089: CPU1.BA44 106.84,64.39 106.84,63.7 106.69,63.55 106.69,63.54 106.69,63.54 106.69,61.95 106.6,61.86
  BOTTOM w0.152: 106.6,61.86 106.49,61.74 v1(106.49,60.57)
  BOTTOM w0.216: v1(159.66,17.64) 158.78,17.64 158.47,17.94 158.47,18.25 158.78,18.55 159.42,18.55 159.73,18.86 DM2.145
M_B_BG0: length 100
  TOP w0.216: v1(148.44,15.38) 147.8,15.38 v2(147.78,15.35)
  L6 w0.114: v1(102.28,69.51) 102.02,69.24 102.02,65.63 101.89,65.5
  L6 w0.178: v1(148.44,15.38) 148.33,15.38 147.9,15.8 147.9,17.76 146.28,19.38 120.31,19.38 96.46,43.23 96.46,53.06 97.66,54.27 97.66,61.28 101.89,65.5
  BOTTOM w0.216: v1(148.44,15.38) 148.49,15.38 148.54,15.33 148.94,15.33 149.63,16.02 149.63,17.59 150.23,18.18 150.23,19.6 DM2.115 ; CPU1.AP52 102.63,69.15 v1(102.28,69.51)
M_B_BG1: length 100.3
  TOP w0.216: v1(149.17,16.9) v2(148.49,16.9)
  L6 w0.114: v1(103.22,69.49) 103.22,69.35 102.6,68.74 102.6,65.12 102.46,64.98
  L6 w0.178: 102.46,64.98 99.19,61.71 99.19,54.82 97.82,53.45 97.82,51.47 97.64,51.29 97.61,51.29 97.43,51.11 97.43,50.75 97.61,50.58 97.64,50.58 97.82,50.4 97.82,50.04 97.64,49.87 97.61,49.87 97.43,49.69 97.43,49.33 97.61,49.15 97.64,49.15 97.82,48.98 97.82,48.62 97.64,48.44 97.61,48.44 97.43,48.27 97.43,47.91 97.61,47.73 97.64,47.73 97.82,47.55 97.82,47 98.33,46.49 98.33,45.97 98.07,45.71 97.56,45.71 97.43,45.58 97.43,45.03 97.61,44.85 98.22,44.85 98.33,44.74 98.33,44.25 98.22,44.14 97.61,44.14 97.43,43.96 97.43,43.61 114.34,26.71 115.09,26.71 116.53,25.27 116.53,24.53 116.79,24.26 117.26,24.26 117.53,24 117.53,23.53 117.8,23.26 118.27,23.26 118.54,22.99 118.54,22.52 118.8,22.25 119.27,22.25 119.54,21.98 119.54,21.51 119.81,21.25 120.28,21.25 121.31,20.22 146.29,20.22 148.54,17.97 148.54,17.18 148.82,16.9 v1(149.17,16.9)
  BOTTOM w0.216: v1(149.17,16.9) 149.12,16.95 149.12,17.64 149.73,18.24 DM2.113 ; v1(103.22,69.49) 102.91,69.8 CPU1.AN52
M_B_CKE0: length 96.6
  TOP w0.216: v1(147.11,17.13) v2(146.46,17.13)
  L6 w0.114: 101.63,65.77 101.81,65.96 101.81,68.96 100.65,70.12 v1(100.49,70.12)
  L6 w0.178: 101.63,65.77 97.28,61.43 97.28,54.57 95.97,53.26 95.97,43.03 109.49,29.51 120.11,18.9 145.35,18.9 v1(147.11,17.13)
  BOTTOM w0.216: CPU1.AN56 100.17,69.8 v1(100.49,70.12) ; v1(147.11,17.13) 147.39,17.13 148.73,18.46 DM2.109
M_B_CKE1: length 97.9
  TOP w0.216: v1(101.36,68.85) 101.35,68.83 v2(101.35,68.23)
  L6 w0.114: 100.58,65.19 100.94,65.54 100.94,68.42 v1(101.36,68.85)
  L6 w0.178: v1(146.99,14.76) 146.96,14.79 146.96,15.77 146.67,16.06 146.67,16.64 144.84,18.46 121.43,18.46 121.38,18.41 120.31,18.41 119.91,18.41 109,29.31 96.08,42.24 95.49,42.83 95.49,53.46 96.9,54.87 96.9,61.5 100.58,65.19
  BOTTOM w0.216: DM2.110 148.98,12.38 148.3,13.05 148.3,13.45 v1(146.99,14.76) ; CPU1.AP55 101.06,69.15 v1(101.36,68.85)
M_B_CLK0: length 100.3
  TOP w0.127: v2(106.07,68.82) 106.07,69.32 v1(105.97,69.43)
  L6 w0.089: 105.37,66.56 105.37,66.57 105.38,66.58 105.38,66.64 105.38,66.65 105.38,67.77 106.17,68.56 106.17,69.22 v1(105.97,69.43)
  L6 w0.102: 105.37,66.56 105.37,65.91 105.97,65.31 105.97,64.53 104.74,63.3 104.74,62.22 105.23,61.73 105.23,53.81 105,53.58 105,51.44 105.45,50.99 105.45,47.29 125.48,27.26 150.73,27.26 151.66,26.33 151.66,26.12 151.35,25.81 151.35,25.46 151.65,25.17 151.99,25.17 152.28,25.45 152.46,25.45 152.64,25.27 152.64,25.09 152.47,24.93 152.47,24.55 152.74,24.28 153.12,24.28 153.26,24.42 153.44,24.42 153.62,24.24 153.62,24.06 153.39,23.82 153.39,23.48 153.69,23.18 154.03,23.18 154.27,23.41 154.45,23.41 154.63,23.23 154.63,23.05 154.51,22.93 154.51,22.58 154.81,22.28 155.16,22.28 155.33,22.46 155.54,22.46 156.79,21.2 156.79,16.97 157.33,16.43 v1(157.48,16.43)
  BOTTOM w0.127: DM2.137 155.73,18.66 156.26,18.13 156.26,16.76 156.59,16.43 v1(157.48,16.43) ; CPU1.AP45 106.24,69.15 v1(105.97,69.43)
M_B_CLK1: length 99.3
  TOP w0.127: v1(156.71,14.44) 156.95,14.44 v2(157.23,14.72)
  L6 w0.102: v1(105.06,69.44) 105.09,69.44 105.43,69.1 105.43,68.36 104.94,67.87 104.94,64.28 104.34,63.69 104.34,62.01 104.82,61.54 104.82,54.09 104.31,53.58 104.31,51.14 104.76,50.69 104.76,47.01 125.21,26.57 149.03,26.57 154.19,21.41 155.53,21.41 156.11,20.84 156.11,20.12 156.23,20 156.23,16.23 157.81,14.65 157.81,14.09 157.7,13.98 157.12,13.98 156.71,14.39 v1(156.71,14.44)
  BOTTOM w0.127: CPU1.AP46 105.5,69.26 105.32,69.44 v1(105.06,69.44) ; v1(156.71,14.44) 156.59,14.44 156.1,13.95 156.1,12.47 155.98,12.34 DM2.138
M_B_CLK#0: length 100.4
  TOP w0.127: v1(157.48,17.09) 157.01,17.09 v2(156.84,17.26)
  L6 w0.089: 105.57,66.56 105.57,67.69 106.36,68.48 106.36,69.7 v1(105.97,70.09)
  L6 w0.102: v1(157.48,17.09) 157.31,16.93 157.12,16.93 156.99,17.05 156.99,21.29 155.62,22.66 155.24,22.66 155.07,22.49 154.89,22.49 154.71,22.67 154.71,22.85 154.83,22.97 154.83,23.32 154.53,23.61 154.19,23.61 153.95,23.38 153.77,23.38 153.59,23.56 153.59,23.74 153.83,23.98 153.83,24.32 153.53,24.62 153.18,24.62 153.04,24.48 152.83,24.48 152.68,24.63 152.68,24.84 152.84,25.01 152.84,25.36 152.55,25.65 152.2,25.65 151.91,25.37 151.73,25.37 151.55,25.55 151.55,25.73 151.86,26.04 151.86,26.42 150.81,27.47 125.56,27.47 105.65,47.38 105.65,51.08 105.2,51.53 105.2,53.5 105.43,53.72 105.43,61.82 104.94,62.3 104.94,63.22 106.17,64.45 106.17,65.39 105.57,65.99 105.57,66.56
  BOTTOM w0.127: CPU1.AN45 106.26,69.8 v1(105.97,70.09) ; v1(157.48,17.09) 157.48,17.06 157.09,16.67 156.69,16.67 156.5,16.86 156.5,18.23 156.23,18.5 156.23,19.6 DM2.139
M_B_CLK#1: length 99.4
  TOP w0.127: v2(157.3,13.5) 157.02,13.78 v1(156.66,13.78)
  L6 w0.102: v1(156.66,13.78) 157.78,13.78 158.01,14.01 158.01,14.74 156.44,16.32 156.44,20.08 156.31,20.21 156.31,20.92 155.62,21.61 154.28,21.61 149.12,26.77 125.29,26.77 104.97,47.09 104.97,50.77 104.52,51.22 104.52,53.5 105.02,54 105.02,61.62 104.55,62.1 104.55,63.6 105.14,64.2 105.14,67.79 105.63,68.28 105.63,69.19 105.51,69.31 105.51,69.72 v1(105.09,70.15)
  BOTTOM w0.127: v1(156.66,13.78) 156.34,13.46 156.34,12.57 156.47,12.44 DM2.140 ; v1(105.09,70.15) 105.43,69.8 CPU1.AN46
M_B_CS#0: length 97.7
  TOP w0.216: v1(161.87,16.39) 161.29,16.39 v2(161.26,16.37)
  L6 w0.114: 110.03,53.02 110.03,53.45 109.11,54.37 109.11,58.34 v1(108.04,59.41)
  L6 w0.178: v1(161.87,16.39) 162.32,16.84 162.32,20.17 162.28,20.21 162.28,22.41 152.84,31.85 130.19,31.85 122.33,39.71 121.97,39.71 120.99,38.73 120.69,38.73 120.48,38.94 120.48,39.23 121.52,40.27 121.52,40.52 121.27,40.77 121.02,40.77 120.02,39.77 119.72,39.77 119.51,39.98 119.51,40.28 120.51,41.28 120.51,41.53 120.36,41.68 119.48,41.68 119.04,41.23 118.57,41.23 110.03,49.77 110.03,53.02
  BOTTOM w0.089: 108.49,60.77 108.26,61.01 108.26,62.47 108.51,62.72 CPU1.BB42
  BOTTOM w0.152: v1(108.04,59.41) 108.49,59.86 108.49,60.77
  BOTTOM w0.216: DM2.149 160.73,17.35 160.26,16.89 160.26,16.55 160.57,16.24 161.72,16.24 v1(161.87,16.39)
M_B_CS#1: length 98.3
  TOP w0.216: v1(164,15.83) v2(163.4,15.83)
  L6 w0.114: 110.52,53.23 110.52,53.45 109.33,54.64 109.33,59.36 v1(107.99,60.7)
  L6 w0.178: 110.52,53.23 110.52,52.52 111.8,51.24 111.8,50.98 111.62,50.8 110.77,50.8 110.59,50.62 110.59,50.26 110.77,50.09 111.62,50.09 111.8,49.91 111.8,48.74 118.33,42.21 120.51,42.21 130.39,32.33 153.04,32.33 162.76,22.61 162.76,16.69 162.36,16.29 162.36,15.24 162.37,15.23 162.37,14.83 162.61,14.59 163.07,14.59 163.42,14.95 163.42,15.5 163.75,15.83 v1(164,15.83)
  BOTTOM w0.089: 108.04,61.4 108.04,62.52 108.27,62.75 108.27,63.47 108.25,63.49 108.25,64.19 108.29,64.27 108.29,64.52 108.25,64.64 108.25,64.82 108.3,64.99 CPU1.AY42
  BOTTOM w0.152: v1(107.99,60.7) 108.04,60.75 108.04,61.4
  BOTTOM w0.216: DM2.157 162.73,18.15 162.89,17.98 162.89,15.94 163.14,15.68 163.85,15.68 v1(164,15.83)
M_B_DIMB_ODT0: length 98.3
  L6 w0.178: v1(164,15.15) 164.5,15.64 164.5,22.24 153.44,33.3 130.9,33.3 117.86,46.34 115.65,46.34 115.29,46.7 115.29,46.95 115.98,47.64 115.98,47.94 115.77,48.14 115.48,48.14 114.79,47.45 114.53,47.45 114.28,47.7 114.28,47.95 115,48.67 115,48.97 114.79,49.18 114.5,49.18 113.78,48.46 113.53,48.46 112.85,49.13 112.85,51.55 111.51,52.89 111.51,53.43 110.27,54.66 v1(110.27,55.15)
  BOTTOM w0.102: CPU1.BA42 108.51,64.74 108.78,64.47 108.78,63.27 108.7,63.19 108.7,62.64 108.44,62.39 108.44,61.39 108.81,61.02
  BOTTOM w0.152: 108.81,61.02 108.81,56.53 v2(109.42,55.91) 110.18,55.15 v1(110.27,55.15)
  BOTTOM w0.216: DM2.155 162.22,18.17 162.56,17.84 162.56,15.51 162.92,15.15 v1(164,15.15)
M_B_DIMB_ODT1: length 98.3
  TOP w0.216: v1(164.06,17.35) 164.06,17.49 v2(163.7,17.84)
  L6 w0.114: 110.52,53.9 109.55,54.87 109.55,61.92 108.94,62.53 v1(108.94,65.7)
  L6 w0.178: v1(164.06,17.35) 164.02,17.38 163.55,17.38 163.25,17.69 163.25,18.49 163.42,18.66 163.93,18.66 164.13,18.87 164.13,19.17 163.93,19.37 163.42,19.37 163.25,19.55 163.25,19.91 163.42,20.09 163.84,20.09 164.02,20.26 164.02,20.62 163.84,20.8 163.42,20.8 163.25,20.97 163.25,21.33 163.42,21.51 163.84,21.51 164.02,21.69 164.02,22.04 153.24,32.81 130.59,32.81 119.8,43.6 119.55,43.6 118.71,42.76 118.46,42.76 118.21,43.01 118.21,43.27 119.05,44.11 119.05,44.36 118.8,44.61 118.55,44.61 117.71,43.77 117.46,43.77 117.2,44.02 117.2,44.27 118.04,45.11 118.04,45.36 117.55,45.86 115.37,45.86 112.37,48.85 112.37,51.35 111,52.72 111,53.43 110.52,53.9
  BOTTOM w0.152: v1(108.94,65.7) 108.93,65.71 108.84,65.71 CPU1.AW42
  BOTTOM w0.216: v1(164.06,17.35) 164.06,17.94 163.73,18.27 DM2.161
M_B_DQ0: length 63.6
  TOP w0.14: v2(122.35,12.46) 122.35,12.56 122.35,12.56 v1(122.35,13.07)
  L4 w0.114: v1(122.35,13.07) 120.75,13.07 119.43,14.39 119.43,22.03 115.85,25.61 115.85,25.79 116.42,26.36 116.42,26.54 116.24,26.72 116.06,26.72 115.55,26.22 115.37,26.22 115.2,26.39 115.2,26.57 115.7,27.08 115.7,27.26 110.11,32.85 110.11,47.81 109.78,48.14 109.78,54.13 109.41,54.5 109.41,57.27 109.47,57.33 109.47,60.99 v1(109.01,61.44)
  BOTTOM w0.089: CPU1.AY39 109.79,65.16 109.47,64.85 109.47,64.49 109.34,64.22 109.34,62.98 109.24,62.88 109.24,61.69 109.01,61.46 v1(109.01,61.44)
  BOTTOM w0.14: DM2.4 122.48,11.4 122.48,12.95 v1(122.35,13.07)
M_B_DQ1: length 62.4
  TOP w0.14: v2(121.79,14.16) 122.05,14.42 v1(122.35,14.42)
  L4 w0.114: v1(110.4,61.49) 109.86,60.96 109.86,57.4 109.64,57.17 109.64,54.59 110.13,54.09 110.13,48.3 110.46,47.97 110.46,33.36 116.92,26.91 116.92,25.16 119.79,22.29 119.79,18.19 121.87,16.11 121.87,14.9 v1(122.35,14.42)
  BOTTOM w0.089: v1(110.4,61.49) 110.81,61.9 110.81,63.57 110.67,63.7 110.67,64.23 110.71,64.31 110.71,64.51 110.67,64.59 110.67,64.84 110.71,64.98 110.71,65.76 110.43,66.04 CPU1.AW39
  BOTTOM w0.14: DM2.8 123.48,11.4 123.48,12.28 123.33,12.43 123.33,13.61 122.52,14.42 v1(122.35,14.42)
M_B_DQ2: length 64.7
  TOP w0.14: v1(124.72,15.17) 124.72,15.41 124.99,15.68 v2(125.02,15.68)
  L4 w0.114: v1(110.4,60.84) 111.66,59.58 111.66,56.58 111.48,56.4 111.48,49.33 112.22,48.59 112.22,34.29 117.06,29.44 117.4,29.1 118.45,29.1 119.54,28.01 119.54,27.2 120.4,26.34 120.58,26.16 120.76,26.16 120.93,26.33 121.1,26.33 121.28,26.15 121.28,25.97 121.13,25.82 121.13,25.64 121.31,25.46 121.49,25.46 121.64,25.61 121.82,25.61 122,25.43 122,25.25 121.83,25.07 121.83,24.89 122.01,24.71 122.19,24.71 122.42,24.95 122.6,24.95 123.71,23.85 123.71,18.72 124.53,17.89 124.53,15.36 v1(124.72,15.17)
  BOTTOM w0.089: CPU1.AY37 110.95,65.06 110.88,64.92 110.88,64.91 110.85,64.81 110.85,64.64 110.89,64.55 110.89,64.27 110.85,64.19 110.85,63.89 110.99,63.76 110.99,61.43 v1(110.4,60.84)
  BOTTOM w0.14: DM2.17 125.73,19.6 125.73,16.18 v1(124.72,15.17)
M_B_DQ3: length 64.8
  TOP w0.14: v1(126.78,17.92) 126.19,17.92 126.19,17.92 v2(126.14,17.92)
  L4 w0.114: v1(112.12,58.15) 112.54,57.73 112.54,49.8 113.37,48.98 113.37,35.92 115.62,33.67 115.62,33.49 115.16,33.03 115.16,32.85 115.34,32.68 115.52,32.68 115.98,33.13 116.16,33.13 125.9,23.38 125.9,22.29 125.78,22.16 125.27,22.16 125.15,22.04 125.15,21.78 125.27,21.65 126.47,21.65 126.59,21.53 126.59,21.27 126.47,21.15 125.27,21.15 125.15,21.02 125.15,20.77 125.27,20.64 126.42,20.64 126.54,20.51 126.54,20.26 126.42,20.13 125.27,20.13 125.15,20 125.15,19.11 126.33,17.92 v1(126.78,17.92)
  BOTTOM w0.089: CPU1.AW37 111.01,65.78 111.12,65.67 111.13,65.67 111.3,65.5 111.3,65.49 111.33,65.46 111.33,64.96 111.65,64.63 111.65,58.62 v1(112.12,58.15)
  BOTTOM w0.14: DM2.21 126.73,19.6 126.73,17.98 v1(126.78,17.92)
M_B_DQ4: length 62.7
  TOP w0.14: v2(121.72,17.33) 121.89,17.16 v1(122.34,17.16)
  L4 w0.114: v1(110.31,57.54) 109.86,57.08 109.86,55.02 109.86,55.01 109.86,54.67 110.35,54.18 110.35,48.39 110.82,47.92 110.82,33.67 118.19,26.29 118.19,25.63 117.79,25.22 117.79,25.04 117.97,24.86 118.15,24.86 118.73,25.45 118.91,25.45 119.09,25.27 119.09,25.09 118.46,24.45 118.46,24.27 118.64,24.09 118.82,24.09 119.45,24.73 119.63,24.73 119.81,24.55 119.81,24.37 119.15,23.71 119.15,23.53 119.33,23.35 119.51,23.35 120.17,24.01 120.35,24.01 120.53,23.83 120.53,23.65 120.22,23.34 120.22,18.63 121.68,17.16 v1(122.34,17.16)
  BOTTOM w0.089: CPU1.BB39 109.79,62.86 109.6,62.67 109.6,61.06 109.45,60.9 109.45,58.4 v1(110.31,57.54)
  BOTTOM w0.14: v1(122.34,17.16) 121.9,17.6 121.9,18.26 122.23,18.59 DM2.3
M_B_DQ5: length 62.9
  L4 w0.114: v1(122.35,15.77) 122.8,15.33 123.04,15.33 123.37,15.66 123.37,16.29 122.77,16.89 122.77,18.18 122.48,18.48 121.82,18.48 121.14,19.15 121.14,19.74 121.02,19.87 120.83,19.87 120.7,19.99 120.7,20.25 120.83,20.38 121.02,20.38 121.14,20.5 121.14,20.76 121.02,20.88 120.83,20.88 120.7,21.01 120.7,21.26 120.83,21.39 121.02,21.39 121.14,21.52 121.14,21.77 121.02,21.9 120.83,21.9 120.7,22.03 120.7,22.28 120.83,22.41 121.02,22.41 121.14,22.53 121.14,23.98 111.18,33.94 111.18,48.13 110.68,48.63 110.68,54.33 110.76,54.41 110.76,55.93 110.79,55.96 110.79,56.3 110.55,56.54 110.54,56.54 110.34,56.74 v1(110.34,56.88)
  BOTTOM w0.089: v1(110.34,56.88) 110.34,56.91 v2(109.45,57.8) 109.27,57.97 109.27,60.98 109.42,61.13 109.42,62.77 109.52,62.87 109.52,64.19 109.6,64.35 109.68,64.52 109.68,64.62 CPU1.BA39
  BOTTOM w0.14: v1(122.35,15.77) 122.88,16.3 122.88,17.77 123.23,18.11 DM2.7
M_B_DQ6: length 64
  TOP w0.14: v2(124.16,13.52) 124.16,13.55 124.38,13.77 v1(124.79,13.77)
  L4 w0.114: v1(112.12,56.72) 111.71,56.3 111.71,49.6 112.67,48.63 112.67,34.33 115.84,31.17 116.02,31.17 116.23,31.38 116.41,31.38 116.59,31.2 116.59,31.02 116.38,30.81 116.38,30.63 116.55,30.45 116.73,30.45 116.97,30.69 117.15,30.69 117.33,30.51 117.33,30.33 117.09,30.09 117.09,29.91 117.42,29.59 117.48,29.53 118.57,29.53 120.34,27.75 120.34,27.57 120.12,27.34 120.12,27.16 120.29,26.98 120.47,26.98 120.7,27.21 120.88,27.21 124.22,23.88 124.22,18.83 125.14,17.92 125.14,14.12 v1(124.79,13.77)
  BOTTOM w0.089: v1(112.12,56.72) 111.33,57.51 111.33,61.05 111.47,61.18 111.47,64.38 CPU1.BA37
  BOTTOM w0.14: v1(124.79,13.77) 125.48,13.08 125.48,11.4 DM2.16
M_B_DQ7: length 62.5
  L4 w0.114: v1(126.98,13.78) 125.55,15.21 125.55,18.12 124.77,18.9 124.77,24.02 116.9,31.89 115.62,31.89 114.6,32.9 114.6,33.21 114.91,33.51 114.91,33.69 114.73,33.87 114.55,33.87 114.24,33.57 114.06,33.57 113.89,33.75 113.89,33.93 114.19,34.23 114.19,34.41 114.01,34.59 113.83,34.59 113.53,34.29 113.35,34.29 113.03,34.61 113.03,35.77 113.03,35.77 113.03,48.78 112.12,49.68 v1(112.12,56.01)
  BOTTOM w0.089: v1(112.12,56.01) v2(111.29,56.84) 111,57.14 111,61.11 111.21,61.32 111.21,63.78 111.11,63.89 CPU1.BB37
  BOTTOM w0.14: DM2.20 126.48,11.4 126.48,13.28 v1(126.98,13.78)
M_B_DQ8: length 68
  TOP w0.14: v2(126.44,14.79) 126.44,14.82 126.8,15.17 v1(126.98,15.17)
  L4 w0.114: v1(126.98,15.17) 127.58,15.78 127.58,27.87 122.28,33.17 122.28,33.38 122.48,33.59 122.48,33.8 122.34,33.95 122.12,33.95 121.92,33.74 121.71,33.74 121.56,33.89 121.56,34.1 121.77,34.31 121.77,34.52 121.62,34.67 121.41,34.67 121.2,34.46 120.99,34.46 120.84,34.61 120.84,34.82 121.05,35.03 121.05,35.24 120.9,35.39 120.69,35.39 120.48,35.18 120.27,35.18 120.12,35.33 120.12,35.54 120.33,35.75 120.33,35.96 120.18,36.1 119.97,36.1 119.76,35.9 119.55,35.9 119.4,36.05 119.4,36.26 119.61,36.46 119.61,36.67 119.46,36.82 119.25,36.82 119.04,36.61 118.83,36.61 118.68,36.76 118.68,36.97 118.89,37.18 118.89,37.39 118.74,37.54 118.53,37.54 118.32,37.33 118.11,37.33 117.96,37.48 117.96,37.69 118.17,37.9 118.17,38.11 118.02,38.26 117.81,38.26 117.6,38.05 117.39,38.05 117.24,38.2 117.24,38.41 117.45,38.62 117.45,38.83 114.21,42.07 114.21,49.9 113.26,50.85 113.26,58.97 v1(112.12,60.1)
  BOTTOM w0.089: v1(112.12,60.1) 112.54,60.52 112.54,60.87 112.7,61.03 112.7,62.32 112.42,62.61 112.42,64.15 112.37,64.27 112.37,64.54 112.4,64.64 112.4,64.84 112.36,64.94 112.36,65.27 CPU1.AY35
  BOTTOM w0.14: v1(126.98,15.17) 127.48,14.68 127.48,11.4 DM2.24
M_B_DQ9: length 68.8
  TOP w0.14: v2(126.21,16.6) v1(126.82,16.6)
  L4 w0.114: v1(126.82,16.6) 127.22,17 127.22,27.72 126.97,27.97 126.76,27.97 126.56,27.77 126.35,27.77 126.2,27.91 126.2,28.12 126.4,28.33 126.4,28.54 126.25,28.69 126.04,28.69 125.84,28.48 125.63,28.48 125.48,28.63 125.48,28.84 125.68,29.05 125.68,29.26 125.53,29.41 125.32,29.41 125.12,29.2 124.91,29.2 124.76,29.35 124.76,29.56 124.96,29.77 124.96,29.98 124.82,30.13 124.61,30.13 124.4,29.92 124.19,29.92 124.04,30.07 124.04,30.28 124.25,30.49 124.25,30.7 116.48,38.47 116.48,38.68 116.68,38.88 116.68,39.09 116.53,39.23 116.32,39.23 116.12,39.04 115.91,39.04 115.76,39.18 115.76,39.39 115.96,39.59 115.96,39.8 115.81,39.95 115.6,39.95 115.4,39.75 115.19,39.75 115.04,39.9 115.04,40.11 115.24,40.31 115.24,40.52 115.09,40.67 114.88,40.67 114.68,40.47 114.47,40.47 113.86,41.09 113.86,49.75 112.9,50.71 112.9,58.03 v1(112.12,58.8)
  BOTTOM w0.089: v1(112.12,58.8) 112.81,59.49 112.81,60.69 112.88,60.76 112.88,62.4 112.61,62.67 112.61,64.16 112.58,64.22 112.58,64.22 112.54,64.3 112.54,64.51 112.58,64.6 112.58,64.87 112.54,64.96 112.54,65.59 112.24,65.89 CPU1.AW35
  BOTTOM w0.14: v1(126.82,16.6) 126.99,16.6 128.34,15.25 128.34,13.07 128.48,12.93 128.48,11.4 DM2.28
M_B_DQ10: length 67.4
  L4 w0.114: v1(115.83,57.39) 116,57.22 116,52.13 116.95,51.18 116.95,47.9 120.83,44.03 120.83,42.91 120.68,42.76 120.19,42.76 120.04,42.61 120.04,42.4 120.19,42.25 120.68,42.25 120.83,42.1 120.83,41.89 120.68,41.74 120.21,41.74 120.07,41.6 120.07,41.38 120.21,41.24 120.68,41.24 120.83,41.09 120.83,40.88 120.68,40.73 120.24,40.73 120.09,40.58 120.09,40.37 120.24,40.22 120.68,40.22 120.83,40.07 120.83,39.47 131.95,28.35 131.95,20.26 132,20.2 132,14.57 131.85,14.42 131.64,14.42 131.5,14.27 131.5,14.06 131.64,13.91 132.11,13.91 132.26,13.76 132.26,13.22 132.11,13.06 v1(130.91,13.06)
  BOTTOM w0.089: CPU1.AY33 113.62,65.16 113.76,64.96 113.76,64.72 113.84,64.37 113.88,64.31 113.9,64.2 113.92,64.13 113.92,63.69 113.79,63.57 113.79,63.21 114.37,62.63 114.37,61.27 115,60.64 v2(115,58.68) 115,58.23 115.78,57.45 115.78,57.44 v1(115.83,57.39)
  BOTTOM w0.14: v1(130.91,13.06) 130.91,12.94 130.97,12.88 130.97,12.05 130.98,12.05 DM2.38
M_B_DQ11: length 66.4
  TOP w0.14: v2(130.33,14.16) 130.53,14.36 v1(130.91,14.36)
  L4 w0.114: v1(112.15,66.6) 112.15,66.59 112.15,63.35 115.21,60.29 115.21,58.01 115.42,57.8 115.42,56.62 115.56,56.49 115.56,52.19 116.6,51.15 116.6,47.75 119.68,44.67 119.68,40.11 131.42,28.37 131.42,19.49 131.78,19.14 131.78,15.22 v1(130.91,14.36)
  BOTTOM w0.089: CPU1.AW33 112.7,66.04 v1(112.15,66.6)
  BOTTOM w0.14: v1(130.91,14.36) 131.04,14.36 131.8,13.61 131.8,12.58 131.98,12.41 DM2.42
M_B_DQ12: length 66.4
  TOP w0.14: v1(129.3,15.92) 128.92,15.92 v2(128.68,16.16)
  L4 w0.114: v1(112.12,60.75) 113.48,59.39 113.48,51.13 114.57,50.04 114.57,42.22 123.13,33.65 123.13,33.44 122.92,33.24 122.92,33.02 123.07,32.88 123.28,32.88 123.49,33.08 123.7,33.08 123.85,32.93 123.85,32.72 123.64,32.52 123.64,32.31 128.09,27.86 128.09,15.81 127.64,15.35 127.64,14.08 127.79,13.93 128.04,13.93 128.19,14.08 128.19,15.1 129.02,15.92 v1(129.3,15.92)
  BOTTOM w0.089: v1(112.12,60.75) 112.52,61.14 112.52,61.23 112.52,61.23 112.52,61.57 112.52,61.58 112.52,62.23 112.14,62.6 CPU1.BB35
  BOTTOM w0.14: v1(129.3,15.92) 129.2,16.02 129.06,16.02 127.81,17.27 127.79,17.29 127.79,18.42 127.73,18.49 127.73,19.6 DM2.25
M_B_DQ13: length 66.9
  TOP w0.14: v2(131.78,15.38) 131.72,15.38 131.25,15.85 v1(131.25,15.89)
  L4 w0.114: v1(112.11,62.05) 112.89,62.05 114.86,60.08 114.86,58.06 115.2,57.71 115.2,56.53 115.21,56.53 115.21,52.08 116.24,51.05 116.24,47.61 117.25,46.6 117.25,46.39 116.87,46.01 116.87,45.8 117.02,45.65 117.23,45.65 117.61,46.03 117.82,46.03 117.97,45.88 117.97,45.67 117.59,45.29 117.59,45.08 117.74,44.93 117.95,44.93 118.33,45.31 118.54,45.31 119.18,44.67 119.18,44.32 119.03,44.17 118.23,44.17 118.08,44.02 118.08,43.81 118.23,43.66 119.03,43.66 119.18,43.51 119.18,40.11 131.07,28.22 131.07,19.13 131.55,18.65 131.55,16.18 v1(131.25,15.89)
  BOTTOM w0.089: v1(112.11,62.05) 111.83,62.32 111.83,64.42 CPU1.BA35
  BOTTOM w0.14: DM2.41 131.73,19.6 131.73,16.59 131.39,16.26 131.39,16.06 131.25,15.92 v1(131.25,15.89)
M_B_DQ14: length 66.7
  TOP w0.14: v2(128.75,17.49) 129.03,17.21 v1(129.3,17.21)
  L4 w0.114: v1(114.14,60.11) 113.79,60.11 113.67,59.98 113.67,59.53 113.71,59.49 113.71,51.4 114.71,50.4 114.92,50.19 114.92,42.37 115.38,41.91 115.59,41.91 116.29,42.61 116.5,42.61 116.65,42.46 116.65,42.25 115.95,41.55 115.95,41.34 116.1,41.19 116.31,41.19 117.01,41.9 117.22,41.9 117.37,41.75 117.37,41.54 116.67,40.83 116.67,40.62 124.56,32.73 124.56,32.52 124.35,32.31 124.35,32.1 124.5,31.95 124.71,31.95 124.92,32.16 125.13,32.16 125.28,32.01 125.28,31.8 125.07,31.59 125.07,31.38 125.22,31.23 125.43,31.23 125.64,31.44 125.85,31.44 126,31.29 126,31.08 125.79,30.87 125.79,30.66 125.94,30.51 126.15,30.51 126.36,30.72 126.57,30.72 126.72,30.57 126.72,30.36 126.51,30.15 126.51,29.94 126.66,29.79 126.87,29.79 127.08,30 127.29,30 127.44,29.85 127.44,29.64 127.23,29.43 127.23,29.22 127.38,29.07 127.59,29.07 127.8,29.28 128.01,29.28 128.47,28.82 128.47,18.04 v1(129.3,17.21)
  BOTTOM w0.089: v1(114.14,60.11) 114.14,62.61 113.62,63.14 113.62,63.67 113.73,63.78 113.73,64.16 113.71,64.23 113.47,64.62 CPU1.BA33
  BOTTOM w0.14: DM2.29 128.76,19.56 128.76,17.78 128.87,17.68 128.87,17.67 v1(129.3,17.21)
