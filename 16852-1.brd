# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
NGFF_MSATA_DEVSLP: length 6.1
  TOP w0.102: AFTP6209.1 92.76,113.65 v1(92.46,113.65) 92.3,113.5 R6216.1
  BOTTOM w0.102: WWAN1.38 95.84,113.5 95.35,114 92.8,114 v1(92.46,113.65)
NGFF_PCIE#_SATA: length 10.3
  BOTTOM w0.089: 132.46,83.04 132.36,82.94 131.83,82.94 131.74,82.98 131.48,82.98 131.38,82.94 130.95,82.94 130.55,82.54 CPU1.H3
  BOTTOM w0.102: R1610.2 134.75,88.5 134.75,87.74 133.65,86.65 133.65,84.44 133.99,84.11 133.99,83.32 v2(133.93,83.27) 133.71,83.04 132.46,83.04
NGFF_WAKE#: length 6.8
  TOP w0.127: R6218.1 91.92,117.46 v1(92.41,117.94) 92.3,117.94 AFTP6249.1
  BOTTOM w0.127: WWAN1.54 95.72,117.5 95.28,117.94 v1(92.41,117.94)
ODTA0: length 59.1
  TOP w0.127: v1(165.43,108.14) 165.67,108.14 166.38,108.84 167.78,108.84 VRAM1.K1
  TOP w0.279: v1(175.08,84.79) 175.25,84.79 v2(175.82,85.35)
  L4 w0.127: 158.72,108.86 161.25,108.86 161.6,109.21 163.93,109.21 165,108.14 v1(165.43,108.14) ; 171.34,89.92 171.71,89.55 171.71,89.39 171.96,89.15 172.34,89.15 172.7,88.79 172.7,86.36 173.12,85.95 174.14,85.95 174.55,85.53 174.55,85.32 v1(175.08,84.79)
  L4 w0.254: 171.34,89.92 170.96,90.3 166.47,90.3 165.76,91.02 164.57,91.02 163.3,89.75 163.27,89.75 162.99,89.47 162.99,89.44 162.99,89.44 162.99,89.18 162.43,88.62 161.8,88.62 156.17,94.26 156.17,106.78 158.25,108.86 158.72,108.86
  BOTTOM w0.127: v1(165.43,108.14) 165.39,108.1 164.7,108.1 164.52,107.92 164.03,107.92 163.66,108.29 163.66,108.64 163.46,108.84 162.06,108.84 VRAM2.K1
  BOTTOM w0.14: v1(175.08,84.79) 175.49,85.2 GPU1.L18
ODTA1: length 55.7
  TOP w0.127: v1(188.09,108.14) 188.79,108.84 190.28,108.84 VRAM4.K1
  L4 w0.127: v1(188.09,108.14) 188.39,108.44 188.39,109.11 188.7,109.43 189.57,109.43 189.95,109.05 191.56,109.05 191.69,109.18 191.69,110.43 191.81,110.56 192.28,110.56 192.5,110.34 192.5,109.1 192.73,108.87 ; 182.06,89.26 179.17,89.26 178.89,88.98 178.89,87.88 177.89,86.88 177.37,86.88 v1(176.95,86.46)
  L4 w0.254: 192.73,108.87 196.59,105.01 196.59,95.84 192.17,91.43 189.61,91.43 188.32,90.13 184.33,90.13 183.85,89.65 183.06,89.65 182.66,89.26 182.06,89.26
  BOTTOM w0.127: v1(188.09,108.14) 187.96,108.01 187.17,108.01 187.08,107.92 186.52,107.92 186.16,108.28 186.16,108.64 185.96,108.84 184.56,108.84 VRAM3.K1
  BOTTOM w0.14: v1(176.95,86.46) 177.4,86 GPU1.K16
P_SYS: length 249.6
  TOP w0.102: R2425.1 v1(204.34,16.62) ; PG4415.2 240.28,15.15 240.76,15.62 v1(240.79,15.62) 240.83,15.62 241.3,15.15 PR4425.1 ; v1(153.03,106.41) v2(150.93,106.41) 150.75,106.41 149.73,107.43 PR4671.1
  L3 w0.102: v1(200.96,55.48) 200.18,55.48 199.47,56.19 199.47,57.54 199.77,57.85 199.77,58.56 199.06,59.27 199.06,62.8 199.19,62.93 199.19,63.28 196.85,65.62 196.85,70.65 195.88,71.61 195.88,78.29 194.51,79.66 194.51,82.97 199.31,87.77 201.83,87.77 202.15,88.08 202.15,91.39 205.49,94.73 205.49,98.18 209.78,102.47 209.78,113.5 209.88,113.6 209.88,114.79 209.78,114.89 209.78,115.25 210.19,115.66 v1(210.19,115.94)
  L4 w0.102: v1(240.79,15.62) 238.96,15.62 236.57,13.23 236.57,12.61 235.66,11.71 235.45,11.49 234.07,11.49 233.44,12.13 226.72,12.13 225.78,11.19 220.12,11.19 219.63,11.67 214.38,11.67 214.05,11.34 211.58,11.34 v1(210.79,10.55) ; v1(153.03,106.41) 154.05,107.43 154.05,108.82 154.13,108.9 154.13,109 156.41,111.29 156.41,111.8 156.66,112.05 156.66,112.07 156.92,112.33 156.92,120.97 163.19,127.24 190.75,127.24 191.47,126.53 204.17,126.53 205.74,124.95 205.74,119.31 209.12,115.94 v1(210.19,115.94)
  L6 w0.102: v1(198.75,47.81) 198.75,45.7 197.89,44.83 197.89,41.15 199.57,39.47 199.57,35.03 201.75,32.85 203.46,32.85 204.09,32.22 204.09,31.44 204.57,30.96 204.57,28.87 202.27,26.56 202.27,24.27 201.9,23.91 201.9,22.39 203.66,20.63 203.66,18.32 204.34,17.64 v1(204.34,16.62)
  BOTTOM w0.102: v1(198.75,47.81) 198.75,48.63 198.37,49.01 198.37,52.89 v1(200.96,55.48) ; v1(210.79,10.55) 210.79,14.44 210.46,14.77 209.45,14.77 207.59,16.62 v1(204.34,16.62)
PANEL_BKEN_EC: length 18.6
  TOP w0.102: KBC24.117 210.71,24.86 210.26,25.31 205.48,25.31 204.72,24.54 v1(204.72,24.05)
  BOTTOM w0.102: v1(204.72,24.05) 204.71,24.06 203.99,24.06 v2(203.94,24.01) 203.88,23.95 203.88,23.11 203,22.23 202.64,22.23 202.21,22.66 201.38,22.66 200.73,23.3 198.87,23.3 R2439.2
PANEL_SIZE_ID: length 115.5
  TOP w0.102: v1(49.78,80.48) 50.38,80.48 v2(50.64,80.21) 50.44,80.01 50.18,80.01 49.97,79.8 R5526.1 R5525.2 ; v1(84.81,86.09) 84.81,79.3 84.05,78.54 v1(84.05,76.87)
  L4 w0.102: v1(84.05,76.87) 84.07,76.87 85.27,75.68 88.05,75.68 89.29,74.44 89.29,73.6 89.17,73.48 89.17,73.15 91.32,71 116.66,71 118.09,72.43 120.31,72.43 122.04,70.7 124.3,70.7 124.39,70.61 124.66,70.34 124.66,69.37 v1(125.16,68.87)
  L6 w0.102: v1(45.47,80.81) 47.22,79.06 52.43,79.06 55.14,81.77 55.14,85.89 57.07,87.82 58.8,87.82 59.7,88.72 59.7,88.85 60.37,89.52 62.43,89.52 62.73,89.82 67.3,89.82 70.06,87.07 72.23,87.07 73.26,86.04 82.65,86.04 82.7,86.09 v1(84.81,86.09)
  BOTTOM w0.102: v1(49.78,80.48) 49.71,80.4 45.87,80.4 v1(45.47,80.81) 45.47,81.99 46.1,82.63 R5521.2 ; CPU1.AP13 124.84,69.15 125.12,68.87 v1(125.16,68.87)
PANEL_SIZE_ID_CONN: length 3.7
  TOP w0.102: v2(49.58,77.23) 49.58,77.23 v1(49.15,77.66) 49.09,77.73 R5525.1
  BOTTOM w0.102: LCD1.22 v1(49.15,77.66)
PBAT_PRES1#: length 10.9
  TOP w0.508: RN4302.8 236.83,35.57 AFTP4310.1 238.63,33.2 235.71,30.28 v1(235.71,28.56)
  BOTTOM w0.508: v1(235.71,28.56) 235.71,27.14 BATT1.6
PBAT_PRES#: length 79.3
  TOP w0.203: KBC24.97 202.31,21.19 v1(202.06,20.94)
  TOP w0.254: v1(241.66,22.69) 241,22.69 240.89,22.79 v2(240.61,22.79) 238.3,22.79 PG4416.1
  TOP w0.508: v1(237.27,37.2) RN4302.1
  L3 w0.508: v1(241.66,22.69) 241.72,22.69 242.11,23.08 242.11,24.62 241.67,25.06 241.67,27.53 240.65,28.55 240.65,29.9 238.71,31.85 238.71,35.76 v1(237.27,37.2)
  L4 w0.508: v1(241.66,22.69) 240.84,22.69 233.78,15.63 229.82,15.63 229.18,16.27 226.29,16.27 225.04,15.02 220.99,15.02 219.43,16.59 219.43,17.23 217.73,18.94 217.73,20.75 217.36,21.12 216.74,21.12 216.05,21.8 213.25,21.8 212.88,22.17 212.88,22.5 212.26,23.11 211.11,23.11 210.11,24.12 208.64,24.12 207.01,25.74 202.89,25.74 201.7,24.56 201.7,23.02 202.06,22.66 v1(202.06,20.94)
  BOTTOM w0.508: ED4304.3 238.19,36.28 v1(237.27,37.2) ; v1(202.06,20.94) 201.74,21.26 R2415.1
PBAT_SMBCLK1: length 12.2
  TOP w0.14: v1(235.42,32.73) 235.7,33.01 235.7,33.5 235.61,33.59 235.13,33.59 AFTP4312.1 235.43,33.89 235.58,34.04 235.58,34.94 235.46,35.06 RN4302.6
  BOTTOM w0.14: BATT1.4 232.63,26.95 232.77,27.09 232.77,28.05 235.7,30.99 235.7,32.44 v1(235.42,32.73)
PBAT_SMBDAT1: length 12.2
  TOP w0.14: RN4302.7 235.96,35.06 235.85,34.94 235.85,34.1 236.05,33.89 AFTP4311.1 236.42,33.59 236.09,33.59 235.97,33.46 235.97,33.01 v1(236.25,32.73)
  BOTTOM w0.14: BATT1.5 233.17,26.95 233.03,27.09 233.03,27.94 235.97,30.88 235.97,32.44 v1(236.25,32.73)
PCH_ALW_ON: length 66.5
  TOP w0.102: KBC24.71 201.91,32.74 v1(202.31,32.34) ; R4102.1 158.05,49.27 157.66,48.88 157.66,46.01 156.9,45.25 156.9,41.76 159.56,39.1 163.54,39.1 164.37,38.26 v2(167.23,38.26) 169.95,38.26 172.47,40.78 181.86,40.78 182.57,40.07 182.93,40.07 183.21,40.34 184.05,40.34 185.04,39.36 185.74,39.36 v1(185.79,39.31)
  L6 w0.102: v1(185.79,39.31) 185.88,39.22 v1(185.88,33.92)
  BOTTOM w0.102: R2496.1 203.2,31.35 202.74,31.81 202.74,31.84 202.31,32.27 v1(202.31,32.34) 202.22,32.43 198.49,32.43 197.12,33.81 185.99,33.81 v1(185.88,33.92)
PCH_BATLOW#: length 13.6
  TOP w0.102: v1(124.74,57.26) 124.74,59.77 123.97,60.54 123.97,60.63 123.5,61.11 123.45,61.11 123.09,61.47 123.09,61.97 124.54,63.42 v2(124.54,64.73) 124.8,65 124.8,65.74 124.73,65.82 124.73,66.26 124.24,66.75 v1(124.24,66.84)
  BOTTOM w0.102: v1(124.24,66.84) 124.35,66.95 CPU1.AU13 ; RN1701.2 123.96,56.95 R1710.2 124.55,57.07 v1(124.74,57.26)
PCH_DPC_AUXN: length 112.6
  L6 w0.102: v1(188.42,49.14) 187.94,48.66 185.64,48.66 185.47,48.83 183.59,48.83 182.71,47.95 174.66,47.95 171.13,51.47 168.7,51.47 168.21,51.95 166.44,53.73 165.29,53.73 163.57,55.46 162.23,55.46 160.94,54.16 157.21,54.16 154.85,56.53 148.5,56.53 146.68,58.35 144.25,58.35 143.57,59.03 143.57,62.14 137.67,68.04 137.67,68.69 136.14,70.22 136.14,74.58 134.31,76.42 132.32,76.42 131.53,75.63 127.04,75.63 125.98,76.69 122.45,76.69 121.75,77.38 121.75,77.74 121.25,78.24 120.08,78.24 119.7,77.86 118.36,77.86 118.02,78.19 116.92,78.19 115.37,79.74 107.19,79.74 105.79,81.14 105.79,81.5 104.59,82.71 104.59,83.2 v1(105.06,83.68)
  BOTTOM w0.127: v2(190.91,49.36) 190.91,49.21 ; 190.91,49.21 188.49,49.21 v1(188.42,49.14) ; 190.91,49.21 191.72,49.21 191.91,49.4 IOBD4.11 ; CPU1.E48 104.59,83.87 104.78,83.68 v1(105.06,83.68)
PCH_DPC_AUXP: length 113.1
  L6 w0.102: v1(104.13,83.61) 104.38,83.36 104.38,82.62 105.59,81.42 105.59,81.06 107.11,79.54 115.29,79.54 116.84,77.99 117.94,77.99 118.27,77.66 119.78,77.66 120.16,78.04 121.17,78.04 121.55,77.66 121.55,77.3 122.37,76.48 125.9,76.48 126.96,75.42 131.61,75.42 132.4,76.21 134.22,76.21 135.94,74.5 135.94,70.13 137.46,68.61 137.46,67.96 143.37,62.05 143.37,58.95 144.17,58.15 146.59,58.15 148.42,56.33 154.76,56.33 157.13,53.96 161.02,53.96 162.32,55.25 163.48,55.25 165.21,53.53 166.35,53.53 168.13,51.75 168.61,51.27 171.05,51.27 174.57,47.74 182.79,47.74 183.68,48.63 185.39,48.63 185.56,48.46 188.36,48.46 v1(188.42,48.4)
  BOTTOM w0.127: IOBD4.12 191.84,48.9 191.77,48.97 188.99,48.97 v1(188.42,48.4) 188.01,47.99 v2(188.01,47.97) ; v1(104.13,83.61) 104.4,83.34 CPU1.F48
PCH_DPC_N0: length 112.3
  L6 w0.102: v1(188.32,51.85) 188.32,51.8 186.17,49.65 183.37,49.65 182.35,48.63 174.94,48.63 171.42,52.16 168.98,52.16 168.5,52.64 166.72,54.42 165.58,54.42 163.34,56.65 155.69,56.65 155.13,57.22 148.78,57.22 146.96,59.04 145.02,59.04 144.31,59.74 144.31,62.37 138.43,68.25 138.43,70.87 136.83,72.47 136.83,74.86 134.89,76.81 131.43,76.81 130.7,76.08 127.42,76.08 126.54,76.95 126.54,77.05 125.85,77.74 122.31,77.74 121.37,78.68 120,78.68 119.82,78.86 117.17,78.86 115.65,80.38 107.87,80.38 107.19,81.05 107.19,81.48 105.74,82.93 105.74,83.84 104.82,84.76 104.59,84.76 v1(104.13,85.22)
  BOTTOM w0.127: CPU1.C50 103.83,85.22 v1(104.13,85.22) ; 190.93,52.27 191.9,52.27 192.03,52.4 IOBD4.5 ; 190.93,52.27 189.97,52.27 189.27,51.57 188.6,51.57 v1(188.32,51.85) ; 190.93,52.27 v2(190.93,52.44)
PCH_DPC_N1: length 113
  TOP w0.127: v2(101.36,85.4) 101.56,85.21 v1(102.03,85.21)
  L6 w0.102: v1(102.03,85.21) 102.27,84.97 102.88,84.97 103.72,85.81 104.38,85.81 106.17,84.02 106.17,83.26 107.03,82.41 115.16,82.41 117.23,80.34 118.29,80.34 118.66,80.71 120.04,80.71 121.98,78.77 129.35,78.77 129.59,79.01 133.39,79.01 133.81,78.6 135.9,78.6 139.05,75.44 139.05,73.52 141.32,71.26 143.87,71.26 145.75,69.38 145.75,67.72 147.8,65.67 148.82,65.67 149.56,64.92 149.56,61.78 152.8,58.54 155.8,58.54 157.01,57.34 163.63,57.34 165.86,55.1 167.01,55.1 168.78,53.33 169.19,52.92 179.08,52.92 179.46,52.54 189.26,52.54 189.74,52.06 189.74,50.96 190.02,50.67 190.25,50.67 v1(190.63,51.05)
  BOTTOM w0.127: v1(102.03,85.21) 102.3,85.21 CPU1.C52 ; IOBD4.8 191.9,50.9 191.76,50.76 190.92,50.76 v1(190.63,51.05)
PCH_DPC_P0: length 112.7
  TOP w0.127: v2(103.73,84.69) 103.73,84.63 v1(104.12,84.25)
  L6 w0.102: v1(104.12,84.25) 104.42,84.56 104.74,84.56 105.54,83.76 105.54,82.85 106.98,81.4 106.98,80.97 107.78,80.17 115.57,80.17 117.09,78.65 119.74,78.65 119.92,78.47 121.29,78.47 122.23,77.54 125.76,77.54 126.34,76.96 126.34,76.87 127.33,75.88 130.78,75.88 131.51,76.61 134.8,76.61 136.63,74.78 136.63,72.38 138.23,70.78 138.23,68.17 144.11,62.28 144.11,59.66 144.93,58.84 146.88,58.84 148.7,57.01 155.05,57.01 155.61,56.45 163.26,56.45 165.49,54.21 166.64,54.21 168.41,52.44 168.9,51.95 171.33,51.95 174.86,48.43 182.44,48.43 183.46,49.45 186.25,49.45 187.93,51.12 188.24,51.12 v1(188.32,51.05)
  BOTTOM w0.127: v1(188.32,51.05) 188.6,51.33 189.37,51.33 190.07,52.03 191.9,52.03 192.03,51.9 IOBD4.6 ; v1(104.12,84.25) 104.12,84.44 103.79,84.76 CPU1.D50
PCH_DPC_P1: length 112.8
  TOP w0.127: v2(101.74,84.18) 101.76,84.18 101.87,84.28 v1(102.3,84.28)
  L6 w0.102: v1(102.3,84.28) 102.3,84.65 102.41,84.77 102.96,84.77 103.8,85.61 104.29,85.61 105.97,83.94 105.97,83.18 106.94,82.2 115.08,82.2 117.15,80.14 118.38,80.14 118.75,80.5 119.96,80.5 121.9,78.56 129.43,78.56 129.68,78.81 133.31,78.81 133.72,78.39 135.82,78.39 138.85,75.36 138.85,73.44 141.23,71.05 143.79,71.05 145.54,69.3 145.54,67.64 147.71,65.47 148.73,65.47 149.36,64.84 149.36,61.7 152.72,58.34 155.72,58.34 156.92,57.14 163.54,57.14 165.78,54.9 166.92,54.9 168.7,53.12 169.11,52.72 178.99,52.72 179.37,52.34 189.17,52.34 189.53,51.98 189.53,50.87 189.94,50.47 190.41,50.47 v1(190.63,50.25)
  BOTTOM w0.127: CPU1.D52 102.46,84.76 102.3,84.6 v1(102.3,84.28) ; v1(190.63,50.25) 190.9,50.52 191.78,50.52 191.9,50.4 IOBD4.9
PCH_DPWROK: length 134.7
  TOP w0.127: R2497.1 v1(204.34,15.73) ; RN1703.2 121.4,53.02 v1(121.1,53.33)
  L6 w0.127: v1(204.34,15.73) 203.31,16.76 203.31,20.59 201.66,22.24 201.66,24.01 202.03,24.37 202.03,26.66 204.33,28.97 204.33,30.86 203.66,31.53 v1(203.66,32.04)
  BOTTOM w0.127: CPU1.BB20 121.1,63.96 121.1,61.22 121.49,60.83 121.49,54.1 121.1,53.71 v1(121.1,53.33) 121.1,52.31 EC1714.1 R1704.2 R1718.1 120.93,49.81 121.41,49.81 123.19,48.03 128.04,48.03 150.38,25.69 173.62,25.69 180.87,32.94 181.34,32.94 181.95,32.33 183.46,32.33 185.49,34.36 186.14,34.36 186.46,34.05 199.36,34.05 200.6,32.81 v2(201.4,32.81) 203.01,32.81 203.66,32.16 v1(203.66,32.04)
PCH_JTAG_TCK: length 63.3
  TOP w0.114: R9914.2 v1(56.24,101.18) ; v1(85.85,103.94) 85.88,103.97 86.46,103.97 86.75,103.68 R407.1
  BOTTOM w0.089: 100.43,88.05 100.29,87.91 100.29,87.89 100.29,86.56 100.03,86.3 CPU1.B56
  BOTTOM w0.114: 100.43,88.05 101.01,88.63 101.01,91.41 v2(100.59,91.83) 100.2,92.21 100.2,95.51 99.47,96.25 99.44,96.25 98.86,96.84 98.86,97.31 98.52,97.65 98.36,97.65 96.78,99.23 96.78,99.52 94.62,101.68 87.51,101.68 85.85,103.34 v1(85.85,103.94) 85.33,103.94 85.16,104.11 83.35,104.11 83.09,103.85 81.55,103.85 81.25,104.15 79.73,104.15 79.56,104.32 73.34,104.32 72.49,105.17 62.7,105.17 62.13,104.61 59.48,104.61 56.37,101.49 56.37,101.31 v1(56.24,101.18)
PCH_JTAG_TDI: length 61.3
  TOP w0.114: v1(83.62,103.43) 83.57,103.39 83.02,103.39 R408.1
  BOTTOM w0.089: CPU1.D59 99.06,85.15 99.06,85.79 99.11,85.93 99.11,86.2 99.09,86.26 99.09,86.52 99.11,86.58 99.11,87.03 98.96,87.18 98.96,87.56 99.28,87.88 99.42,87.88
  BOTTOM w0.114: R9916.2 58.67,98.09 58.67,98.28 60.23,99.84 60.23,101.26 62.63,103.67 63.98,103.67 65.02,104.71 72.3,104.71 73.15,103.86 79.25,103.86 79.43,103.69 81.02,103.69 81.32,103.39 83.58,103.39 v1(83.62,103.43) 84.05,102.99 85.55,102.99 87.32,101.23 94.43,101.23 96.32,99.33 96.32,98.01 97.93,96.4 98.12,96.4 v2(99.18,95.35) 99.56,94.96 99.56,88.02 99.42,87.88
PCH_JTAG_TDO: length 76
  TOP w0.114: XDP1.52 58,89.44 58.35,89.08 v1(58.42,89.08) ; v1(57.12,94.6) 58.42,94.6 v1(58.45,94.57) ; R409.1 84.7,103.67 v1(84.98,103.67)
  BOTTOM w0.114: CPU1.A56 100.03,87.93 100.81,88.71 100.81,90.36 100,91.17 100,95.13 98.48,96.66 98,96.66 96.55,98.1 96.55,99.43 94.52,101.45 87.42,101.45 85.65,103.22 85.43,103.22 v1(84.98,103.67) 84,103.67 83.8,103.87 83.44,103.87 83.19,103.62 81.41,103.62 81.11,103.92 79.58,103.92 79.41,104.09 73.24,104.09 72.39,104.94 63.19,104.94 62.68,104.43 62.68,104.08 61.56,102.96 59.7,102.96 58.46,101.72 58.46,99.82 57.55,98.9 57.55,96.6 57.12,96.17 v1(57.12,94.6) ; v1(58.42,89.08) 58.42,89.71 59.18,90.47 R9919.2 59.18,90.76 58.42,91.53 v2(58.24,91.53) 58.06,91.53 57.45,92.14 57.45,93.3 57.7,93.55 57.74,93.55 58.45,94.26 v1(58.45,94.57)
PCH_JTAG_TMS: length 59.5
  TOP w0.114: v1(82.19,102.92) 82.13,102.92 82.01,103.04 81.93,103.04 81.67,103.3 R416.1
  BOTTOM w0.089: 99.22,88.08 98.79,87.64 98.79,87.09 98.94,86.94 98.94,86.61 98.91,86.55 98.91,86.22 98.94,86.16 98.94,85.96 98.76,85.49 CPU1.C59
  BOTTOM w0.114: R9917.2 59.31,98.59 60.58,99.86 60.58,101.29 62.7,103.41 64.05,103.41 65.12,104.49 72.2,104.49 73.05,103.64 79.1,103.64 79.27,103.46 80.92,103.46 81.47,102.92 v1(82.19,102.92) 82.21,102.91 83.55,102.91 84.35,102.1 86.01,102.1 87.12,101 94.33,101 96.09,99.24 96.09,97.91 v2(98.04,95.97) 98.04,95.93 99.36,94.61 99.36,88.22 99.22,88.08
PCH_PLTRST#: length 32
  TOP w0.127: v1(152.61,70.94) 152.58,70.9 151.55,70.9 151.1,70.44 150.4,70.44 v2(150.36,70.4) 150.22,70.53 149.29,70.53 148.77,70.01 145.01,70.01 144.21,69.21 143.38,69.21 143.25,69.09 137.71,69.09 137.35,69.44 132.33,69.44 132.16,69.61 130.53,69.61 130.12,70.01 128.52,70.01 128.31,69.81 127.23,69.81 v1(126.97,69.56)
  L3 w0.127: v1(152.12,74.37) 152.72,73.77 152.72,71.04 v1(152.61,70.94)
  BOTTOM w0.127: CPU1.AN10 126.78,69.56 v1(126.97,69.56) ; R1713.2 152.17,74.34 152.15,74.37 v1(152.12,74.37)
PCH_PLTRST#_EC: length 5.5
  TOP w0.102: KBC24.56 205.92,38.61 205.44,39.09 205.44,40.1 C2402.2 R2410.1 203.71,40.18 203.7,40.17 v2(203.56,40.17)
PCH_POPIRCOMP: length 6.9
  TOP w0.203: RN401.3 118.84,70.68 119.19,70.32 119.19,69.91 119.48,69.62 119.75,69.62 120.14,69.23 120.14,68.64 120.47,68.31 120.8,68.31 v2(121.22,68.73) 121.25,68.69 121.62,68.69 121.95,68.36 121.95,68 v1(122.39,67.56)
  BOTTOM w0.305: CPU1.AU16 122.55,67.53 122.42,67.53 v1(122.39,67.56)
PCH_RSMRST#: length 101
  TOP w0.127: v1(208.66,26.66) 206.88,26.66 206.17,25.94 KBC24.88
  L3 w0.127: v1(196.24,54.87) 196.24,53.79 200.04,50 201.26,50 203.66,47.6 203.66,47.11 202.93,46.39 v1(202.72,46.39)
  L4 w0.127: v1(196.24,54.87) 194.83,56.28 194.44,56.28 193.22,57.5 186.79,57.5 186.13,56.84 184.95,56.84 184.65,56.55 180.55,56.55 179.35,57.75 179.35,60.27 178.07,61.55 169.61,61.55 164.2,66.97 164.2,68.35 163.62,68.93 163.62,68.96 161.92,70.66 155.61,70.66 154.84,71.44 v1(151.38,71.44)
  L6 w0.127: v1(208.66,26.66) 208.66,26.95 208.41,27.21 208.41,27.88 208.66,28.13 208.66,32.49 206.76,34.39 206.76,36.85 205.94,37.66 205.94,38.8 206.31,39.17 206.31,39.67 205.8,40.17 205.8,40.56 202.72,43.64 v1(202.72,46.39)
  BOTTOM w0.127: R1702.2 EC1712.1 151.7,71.12 v1(151.38,71.44) 150.92,71.9 v2(150.92,71.91)
PCH_SMBCLK: length 411.2
  TOP w0.14: R9912.1 v1(57.12,101.18) ; 111.57,10.54 110.56,11.55 110.56,15.29 110.57,15.3 110.57,15.53 110.98,15.94 v1(110.98,16.13) ; 111.57,10.54 v2(111.43,10.4) ; 111.57,10.54 112.01,10.1 114.51,10.1 114.81,10.4 115.9,10.4 118.02,8.28 118.02,8.02 118.47,7.57 v1(118.47,7.38) ; U6701.1 106.73,6.54 106.22,7.05 v1(106.22,7.22)
  L3 w0.127: v1(57.68,63.59) 57.42,63.85 57.04,63.85 56.72,64.18 56.72,65.6 56.07,66.25 56.07,82.2 58.61,84.74 58.61,87.57 57.74,88.44 57.74,90.75 56.5,91.99 56.5,92.65 56.24,92.92 56.24,98.87 57.31,99.88 57.31,101 v1(57.12,101.18)
  L6 w0.114: v1(110.98,16.13) 111.48,15.63 111.48,15.31 111.58,15.21 111.58,14.71 109.24,12.37 102.57,12.37 102.36,12.16 74.02,12.16 72.51,10.65 47.07,10.65 46.01,11.71 46.01,18.01 47.36,19.36 59.58,19.36 76.45,36.22 76.45,52.48 75.71,53.22 73.97,54.96 73.26,54.96 72.61,55.61 66.93,55.61 65.53,57.01 65.53,60.31 61.59,64.25 58.76,64.25 58.31,63.8 57.89,63.8 v1(57.68,63.59) ; v1(118.47,7.38) 118.86,7.38 121.23,9.74 121.87,9.74 123.67,11.54 159.89,11.54 160.16,11.27 162.65,11.27 162.92,11.54 185.63,11.54 188.5,14.42 188.5,15.35 188.09,15.76 v1(188.09,15.86) 187.79,16.15 187.79,20.29 188.92,21.42 188.92,23.81 188.56,24.16 188.56,25.42 188.56,38.53 188.18,38.91 188.18,39.22 188.18,41.48 188.47,41.77 v1(188.47,43.42) 188.45,43.44 187.47,43.44 187.14,43.11 185.95,43.11 185.12,43.93 172.67,43.93 171.67,44.93 169.05,44.93 168.4,45.58 168.4,46.76 165.56,49.6 159.8,49.6 158.9,48.7 153.83,48.7 153.32,49.22 152.23,49.22 151.71,48.7 144.4,48.7 142.44,50.66 142.44,52.49 144.64,54.7 145.25,54.7 145.78,55.23 145.78,55.88 v1(145.41,56.25)
  BOTTOM w0.14: v1(106.22,7.22) 106.75,7.75 118.1,7.75 v1(118.47,7.38) 118.76,7.66 119.39,7.66 EC6505.1 119.82,7.35 R6515.1 ; Q1801.4 143.19,57.01 144.65,57.01 v1(145.41,56.25) 145.11,55.94 RN1810.3 ; v1(188.09,15.86) 186.73,17.22 DM2.253 ; DM1.253 109.72,16.8 110.39,16.13 v1(110.98,16.13) ; IOBD4.15 192,47.4 191.89,47.52 191.75,47.52 188.09,43.86 188.09,43.57 188.24,43.42 v1(188.47,43.42)
PCH_SMBDATA: length 411.3
  TOP w0.14: v1(111,15.35) 110.83,15.18 110.83,12.76 ; v2(111.02,12.76) 110.83,12.76 ; 110.83,12.76 110.83,11.67 112.12,10.37 114.4,10.37 114.69,10.67 116.01,10.67 118.29,8.39 118.3,8.39 v1(118.47,8.21) ; R9911.1 58.01,100.92 v1(57.78,101.15) ; U6701.4 106.78,4.92 106.78,4.91 v1(106.39,4.91)
  L3 w0.127: v1(57.78,101.15) 57.55,100.92 57.55,99.78 56.48,98.77 56.48,93.02 56.74,92.75 56.74,92.09 57.98,90.85 57.98,88.54 58.85,87.67 58.85,84.64 56.31,82.1 56.31,66.35 56.96,65.7 56.96,64.28 57.14,64.09 57.4,64.09 v1(57.68,64.37)
  L6 w0.114: v1(111,15.35) 111.37,14.98 111.37,14.8 109.15,12.58 102.48,12.58 102.27,12.38 73.93,12.38 72.42,10.87 47.16,10.87 46.23,11.8 46.23,17.92 47.45,19.14 59.67,19.14 76.66,36.13 76.66,52.57 75.93,53.31 74.06,55.17 73.35,55.17 72.7,55.83 67.02,55.83 65.75,57.1 65.75,60.4 61.68,64.46 58.67,64.46 58.22,64.01 58.03,64.01 v1(57.68,64.37) ; v1(145.34,55.41) 144.84,54.91 144.55,54.91 142.22,52.58 142.22,50.57 144.31,48.49 151.8,48.49 152.32,49 153.23,49 153.74,48.49 158.99,48.49 159.89,49.38 165.48,49.38 168.19,46.67 168.19,45.49 168.96,44.71 171.58,44.71 172.58,43.72 185.03,43.72 185.86,42.89 187.23,42.89 187.34,43 v1(187.83,43) 188,43 188.25,42.75 188.25,41.86 187.97,41.57 187.97,39.13 187.97,38.82 188.35,38.44 188.35,38.14 188.35,24.07 188.7,23.72 188.7,21.51 187.58,20.38 187.58,15.76 188.09,15.25 v1(188.09,15.1) 188.28,14.9 188.28,14.51 185.54,11.76 162.83,11.76 162.56,11.49 160.25,11.49 159.98,11.76 123.58,11.76 121.78,9.96 121.14,9.96 119.39,8.21 v1(118.47,8.21)
  BOTTOM w0.14: v1(111,15.35) 109.98,14.33 109.98,11.4 DM1.254 ; IOBD4.14 192,47.9 191.89,47.78 191.64,47.78 187.58,43.73 187.58,43.29 187.83,43.04 v1(187.83,43) ; Q1801.1 144.71,58.94 145.62,58.94 146.14,58.42 146.14,56.33 145.85,56.05 145.85,55.67 145.6,55.41 v1(145.34,55.41) 145.22,55.29 RN1810.4 ; R6511.1 119.82,8.24 EC6506.1 119.39,7.93 118.76,7.93 v1(118.47,8.21) 118.28,8.02 106.09,8.02 105.71,7.65 105.71,7.05 106.39,6.37 v1(106.39,4.91) ; DM2.254 186.97,12.14 187.15,12.31 187.15,12.35 187.17,12.37 187.17,14.75 187.52,15.1 v1(188.09,15.1)
PCH_SPI_CS2#: length 3.8
  BOTTOM w0.14: R1816.2 135.01,68.57 134.65,68.21 v2(134.29,68.21) 133.63,68.21 132.94,67.52 132.28,67.52 132.05,67.29 CPU1.AU1
PCH_THERMTRIP: length 13
  BOTTOM w0.089: 96.42,88.58 96.31,88.47 96.31,87.15 96.46,87 96.46,86.61 96.43,86.56 96.43,86.22 96.46,86.15 96.46,85.98 96.37,85.72 96.33,85.66 CPU1.C63
  BOTTOM w0.14: R419.2 93.08,94.47 93.85,94.47 94.31,94.93 ED401.1 94.47,94.93 94.99,94.4 95.33,94.4 95.48,94.25 95.48,94.01 v2(96.01,93.48) 96.31,93.18 96.31,92.27 96.65,91.93 96.65,88.81 96.42,88.58
PCH_WAKE#: length 43.6
  TOP w0.102: v1(123.7,61.72) 124.93,62.95 128.02,62.95 128.02,62.95 130.63,62.95 131.04,62.55 134.45,62.55 136.62,64.71 139.8,64.71 143.36,61.15 143.36,60.72 142.83,60.18 v1(142.8,60.18) ; v1(148.08,63.1) 148.08,63.23 148.11,63.26 148.11,63.51 148.21,63.61 148.21,64.12 148.59,64.5 148.72,64.5 148.84,64.63 R1705.2
  BOTTOM w0.102: v1(148.08,63.1) 147.96,63.23 147.96,63.47 147.43,63.99 147.42,63.99 147.37,64.04 146.84,64.04 146.61,63.82 146.61,63.66 143.13,60.18 v1(142.8,60.18) ; CPU1.BB15 123.39,62.1 123.5,61.98 123.5,61.92 v1(123.7,61.72) 123.92,61.72 124.79,60.85 124.79,60.53 124.18,59.92 124.18,59.37 124.43,59.11 124.43,58.41 v2(124.99,57.85) 124.99,57.82 125.17,57.64 125.17,57.08 124.92,56.83 124.79,56.83 124.46,56.5 RN1701.3
PCI_CLK_LPC0: length 11.1
  BOTTOM w0.089: CPU1.AW9 126.78,65.78 126.78,63.63 128.71,61.69 128.71,60.56 129.1,60.18 129.1,60.17 129.88,59.39 129.88,59.23
  BOTTOM w0.14: 129.88,59.23 130.94,58.18 v2(130.94,57.69) R1804.1
PCI_CLK_LPC1: length 10.6
  BOTTOM w0.089: 129.5,61.49 127.3,63.69 127.3,64.97 127.04,65.23 CPU1.AY9
  BOTTOM w0.14: 129.5,61.49 129.5,60.34 130.79,59.04 v2(130.79,59.03) 130.79,58.91 131.36,58.35 131.36,58.32 131.78,57.9 R1805.1
PCI_CLK_LPC1_B: length 205.2
  TOP w0.14: R9153.1 v1(284.85,29.31)
  L6 w0.114: v1(205.26,42.66) 205.34,42.66 206.4,41.6 206.4,40.84 206.69,40.55 206.69,39.02 206.32,38.65 206.32,37.96 207.13,37.14 207.13,34.55 209.03,32.65 209.03,27.98 208.78,27.73 208.78,27.36 209.12,27.02 209.12,24.65 210.43,23.34 210.43,19.71 211.28,18.86 211.76,18.86 212.45,18.18 212.45,17.33 213.53,16.25 213.53,15.72 214.37,14.89 215.38,14.89 219.64,10.63 224.54,10.63 225,10.18 225,8.89 225.52,8.37 226.07,8.37 226.44,8.01 230.3,8.01 230.67,8.37 235.58,8.37 237.61,10.41 237.61,10.68 237.87,10.94 240.62,10.94 241.34,11.66 244.4,11.66 253.07,20.33 256.75,20.33 257.87,21.44 271.17,21.44 273.19,23.46 275.84,23.46 v1(276.48,22.82) 276.96,22.82 278.51,24.37 280.64,24.37 284.85,28.58 v1(284.85,29.31)
  BOTTOM w0.14: v1(205.26,42.66) 205.26,43.44 203.94,44.76 201.37,44.76 201.23,44.62 200.21,44.62 198.81,43.22 194.58,43.22 194.54,43.26 193.47,43.26 190.99,40.79 190.99,40.03 189.15,38.19 184.97,38.19 184.42,38.74 174.84,38.74 171.73,41.84 167.59,41.84 167.32,41.57 147.05,41.57 136.94,51.67 135.96,51.67 134.74,52.9 132.91,52.9 v2(131.72,54.08) 130.92,54.88 EC1802.1 130.92,55.89 R1804.2 ; R9121.1 276.71,22.59 v1(276.48,22.82)
PCI_CLK_LPC1_B_R: length 251
  TOP w0.14: v1(283.31,30.24) 283.49,30.24 283.53,30.2 R9153.2 ; U9103.1 73.85,5.89 v2(75.76,7.8) 76.48,8.52 v1(76.48,8.8)
  L3 w0.127: v1(76.48,8.8) 76.81,9.13 76.81,9.48 78.59,11.26 97.85,11.26 98.17,11.58 109.88,11.58 111.27,12.96 115.08,12.96 118.08,9.97 119.19,9.97 119.39,9.76 123.73,9.76 124.75,10.78 142.68,10.78 143.78,11.89 144.27,11.89 144.5,12.11 147.75,12.11 147.95,12.32 180.89,12.32 182.9,14.33 182.9,22.23 185.14,24.46 187.32,24.46 189.28,22.5 189.28,21.09 194.04,16.33 197.45,16.33 198.08,15.69 201,15.69 201.49,16.18 210.63,16.18 211.07,15.73 212.6,15.73 214.64,13.7 218.9,13.7 219.1,13.9 225.6,13.9 228.35,11.16 228.35,9.38 228.73,9 228.96,9 229.48,8.48 233.65,8.48 237,11.83 237.6,11.83 238.75,12.99 241.37,12.99 243.5,15.12 243.5,16.4 245.52,18.43 246.15,18.43 247.26,19.54 247.26,19.9 246.46,20.71 246.46,24.23 248.51,26.29 250.32,26.29 251.7,24.9 251.7,24.85 251.96,24.58 254.9,24.58 256.91,26.6 261.67,26.6 262.53,27.47 262.56,27.47 262.64,27.54 263.4,27.54 264.67,28.81 269.75,28.81 271.03,30.1 279.63,30.1 280.32,30.78 282.77,30.78 v1(283.31,30.24)
PCIE_CALR_RX: length 3
  TOP w0.127: R7618.2 170.26,78.27 171.04,77.49 v2(171.3,77.49) 171.59,77.2 v1(171.86,77.2)
  BOTTOM w0.127: GPU1.AA22 172.06,77.4 v1(171.86,77.2)
PCIE_CALR_TX: length 2.3
  TOP w0.127: R7622.2 171.8,78.43 v1(171.84,78.4) 171.85,78.4 172.31,77.94 v2(172.47,77.94)
  BOTTOM w0.127: GPU1.Y22 v1(171.84,78.4)
PCIE_CLK_XDP_N: length 57.5
  L6 w0.102: v1(62,88) 62.18,87.82 62.18,87.51 62.56,87.13 63.04,87.13 65.26,84.92 70.41,84.92 71.42,83.91 77.97,83.91 79.38,85.33 85.21,85.33 87.73,87.85 97.04,87.85 98.3,86.6 102.49,86.6 102.87,86.98 103.22,86.98 103.76,87.53 104.37,87.53 104.86,87.03 105.69,87.03 107.26,85.46 107.26,84.38 107.26,84.1 v1(107.78,83.58)
  BOTTOM w0.102: v1(107.78,83.58) 107.56,83.58 CPU1.F43
  BOTTOM w0.127: 62,89.09 62,89.39 61.66,89.74 60.74,89.74 60.39,90.09 60.39,90.4 R9923.1 ; 62,89.09 v1(62,88) ; 62,89.09 v2(61.77,89.09)
PCIE_CLK_XDP_P: length 57.8
  TOP w0.127: v2(107.79,84.82) v1(107.79,84.21)
  L6 w0.102: v1(62.71,88.08) 62.38,87.75 62.38,87.6 62.65,87.34 63.13,87.34 65.34,85.12 70.5,85.12 71.5,84.12 77.88,84.12 79.3,85.53 85.12,85.53 87.65,88.06 97.13,88.06 98.38,86.8 102.4,86.8 102.79,87.18 103.13,87.18 103.68,87.73 104.45,87.73 104.95,87.23 105.77,87.23 107.47,85.54 107.47,84.47 107.47,84.31 107.57,84.21 v1(107.79,84.21)
  BOTTOM w0.127: CPU1.E43 107.33,84.21 107.46,84.34 107.66,84.34 v1(107.79,84.21) ; R9913.1 60.64,90.4 60.64,90.19 60.84,89.98 61.76,89.98 62.24,89.49 62.24,88.38 62.55,88.08 v1(62.71,88.08)
PCIE_LAN_WAKE#: length 261
  TOP w0.127: v1(156.11,61.14) 156.11,61.45 155.79,61.77 v2(155.5,61.77) D1702.2 ; v1(62.28,40.47) 62.28,39.85 64.41,37.72 117.63,37.72 121.59,41.69 123.31,43.41 143.69,43.41 150.94,43.41 151.01,43.34 154.4,39.96 156.52,37.84 156.99,37.38 157.85,36.52 162.77,36.52 v1(162.94,36.69)
  L3 w0.127: v1(180.14,36.05) 179.53,36.66 166.01,36.66 165.25,37.42 163.67,37.42 v1(162.94,36.69) ; v1(156.11,61.14) 156.65,60.6 156.65,53.52 170.39,39.79 172.14,39.79 172.15,39.8 172.52,39.8 172.54,39.79 179.73,39.79 v1(179.91,39.96) ; v1(62.28,40.47) 62.17,40.47 61.19,41.46 61.19,44.26 60.66,44.79 60.66,46.66 59.12,48.19 55.02,48.19 52.7,50.51 51.07,50.51 50.09,51.48 46.55,51.48 45.93,52.11 41.59,52.11 39.61,54.09 39.61,60.7 37.76,62.56 37.72,62.56 36.58,63.7 36.58,69.07 33.53,72.12 33.53,73.29 34.71,74.47 34.86,74.47 35.12,74.73 35.12,75.1 34.86,75.36 31.31,75.36 30.4,76.26 30.4,79.55 32.05,81.2 32.05,82.85 34.79,85.58 36.7,85.58 42.2,91.08 43.08,91.08 46.03,94.03 v1(47.78,94.03)
  L6 w0.127: v1(179.91,39.96) 180.14,39.73 v1(180.14,36.05)
  BOTTOM w0.127: LOM31.21 47.07,94.78 47.4,95.11 47.75,95.11 47.99,94.87 47.99,94.24 v1(47.78,94.03) 47.84,93.97 R3106.1
PCIE_RCOMPN: length 1.9
  TOP w0.305: R1604.1 128.87,83.11 v1(128.78,83.01) 128.63,82.86 v2(128.63,82.46)
  BOTTOM w0.305: v1(128.78,83.01) 128.95,83.01 CPU1.F5
PCIE_RCOMPP: length 1.9
  TOP w0.305: R1604.2 v1(128.78,83.66) v2(128.5,84.21)
  BOTTOM w0.305: CPU1.E5 v1(128.78,83.66)
PCIE_RX_CON_N5: length 3.4
  BOTTOM w0.127: LOM31.18 47.1,95.98 47.49,96.37 47.49,97.17 47.78,97.46 48.13,97.46 C3104.1
PCIE_RX_CON_P5: length 3.4
  BOTTOM w0.127: v2(47.44,97.71) 47.57,97.59 ; 47.57,97.59 47.68,97.71 48.13,97.71 C3108.1 ; 47.57,97.59 47.25,97.27 47.25,96.68 46.94,96.38 LOM31.17
PCIE_RX_CPU_N5: length 89.7
  L6 w0.102: v1(55.12,90.41) 55.59,90.41 55.72,90.28 59.23,90.28 59.63,90.69 61.94,90.69 62.25,90.99 71.57,90.99 73.34,89.22 75.99,89.22 77.55,87.66 82.88,87.66 86.83,91.6 98.07,91.6 100.26,89.42 105.17,89.42 105.71,88.88 108.09,88.88 109.48,87.49 112.19,87.49 113.71,85.97 116.89,85.97 118.89,83.97 118.89,82.18 119.41,81.66 120.77,81.66 121.34,82.23 121.34,83.38 122.12,84.16 122.52,84.16 122.71,83.96 122.71,83.81 122.57,83.67 v1(122.42,83.67)
  BOTTOM w0.127: C3104.2 49.72,97.52 50.02,97.52 50.63,96.91 51.16,96.91 53.81,94.26 53.81,92.82 ; 53.81,92.82 53.81,91.76 54.11,91.45 54.11,91.41 v1(55.12,90.41) ; 53.81,92.82 v2(53.62,92.82) ; v1(122.42,83.67) 122.67,83.67 122.87,83.47 CPU1.F16
PCIE_RX_CPU_N6: length 143.6
  TOP w0.127: v1(122.42,82.37) 122.17,82.37 v2(121.87,82.66)
  L6 w0.102: v1(122.42,82.37) 122.63,82.16 122.63,81.58 122.32,81.28 119.28,81.28 118.52,82.04 118.52,83.04 116.28,85.27 113.63,85.27 112.38,86.52 108.88,86.52 108.31,87.1 108.31,87.81 107.64,88.47 105.43,88.47 104.79,89.11 99.82,89.11 98.44,90.5 87.1,90.5 83.76,87.16 73.17,87.16 71.85,88.48 69.62,88.48 67.59,90.51 62.45,90.51 62.14,90.21 60.09,90.21 59.02,89.13 59.02,89.01 58.51,88.5 57.43,88.5 56.79,88.5 54.46,86.17 54.46,85.28 54.46,82.05 54.08,81.67 52.59,81.67 52.19,81.27 50.66,79.74 49.03,79.74 46.74,82.03 41.38,82.03 38.68,79.33 36.27,79.33 35.23,78.29 35.23,76.57 33.1,74.43 26.24,74.43 22.96,71.15 22.96,63.51 25.21,61.26 28.4,61.26 29.04,60.61 30.71,60.61 31.01,60.31 v1(31.1,60.31)
  BOTTOM w0.127: CPU1.G18 122.09,82.69 v1(122.42,82.37) ; WLAN1.43 29.82,58.25 30.34,58.77 30.34,60.07 30.58,60.31 v1(31.1,60.31)
PCIE_RX_CPU_P5: length 90
  L6 w0.102: v1(55.19,91.04) 55.25,91.04 55.8,90.49 59.14,90.49 59.55,90.89 61.86,90.89 62.16,91.2 71.65,91.2 73.43,89.42 76.07,89.42 77.64,87.86 82.8,87.86 86.74,91.81 98.16,91.81 100.34,89.62 105.25,89.62 105.79,89.08 108.18,89.08 109.57,87.69 112.28,87.69 113.79,86.18 116.97,86.18 119.09,84.06 119.09,82.26 119.49,81.86 120.68,81.86 121.13,82.31 121.13,83.46 122.03,84.36 122.6,84.36 123.32,83.64 v1(123.32,83.58)
  BOTTOM w0.127: v1(55.19,91.04) 55.07,91.16 54.74,91.16 54.05,91.86 54.05,94.36 53.57,94.83 ; C3108.2 49.61,97.76 50.12,97.76 50.73,97.15 51.26,97.15 53.57,94.83 ; CPU1.E16 122.91,83.99 123.23,83.67 123.24,83.67 v1(123.32,83.58) ; 53.57,94.83 v2(53.72,94.98)
PCIE_RX_CPU_P6: length 143.7
  TOP w0.127: v2(30.47,60.47) 30.51,60.47 v1(30.99,60.95)
  L6 w0.102: v1(30.99,60.95) 30.86,60.82 29.13,60.82 28.48,61.47 25.29,61.47 23.16,63.59 23.16,71.07 26.32,74.23 33.18,74.23 35.43,76.48 35.43,78.21 36.36,79.13 38.77,79.13 41.46,81.82 46.66,81.82 48.95,79.54 50.75,79.54 52.4,81.19 52.4,81.19 52.68,81.47 54.16,81.47 54.66,81.97 54.66,85.36 54.66,86.09 56.87,88.3 57.35,88.3 57.35,88.3 58.6,88.3 59.22,88.92 59.22,89.05 60.17,90 62.23,90 62.53,90.31 67.51,90.31 69.53,88.28 71.77,88.28 73.09,86.96 83.85,86.96 87.18,90.29 98.36,90.29 99.74,88.91 104.71,88.91 105.35,88.27 107.56,88.27 108.1,87.73 108.1,87.01 108.8,86.32 112.3,86.32 113.55,85.07 116.2,85.07 118.31,82.95 118.31,81.96 119.19,81.08 122.41,81.08 122.68,81.35 122.83,81.5 122.83,82.6 v1(122.42,83.02)
  BOTTOM w0.127: WLAN1.41 29.85,58.75 30.1,59 30.1,60.17 30.48,60.55 30.59,60.55 v1(30.99,60.95) ; v1(122.42,83.02) 122.09,83.34 CPU1.F18
PCIE_TX_CON_N5: length 95.5
  L6 w0.102: v1(54.91,93.08) 55.13,93.08 55.34,92.86 55.34,92.18 56.56,90.97 58.94,90.97 59.35,91.37 61.66,91.37 61.96,91.68 70.27,91.68 70.58,91.98 73.86,91.98 74.68,91.17 77.28,91.17 79.93,88.53 82.74,88.53 86.51,92.31 98.39,92.31 100.54,90.16 105.46,90.16 105.54,90.08 105.57,90.08 106.1,89.55 108.63,89.55 110.03,88.15 116.38,88.15 117.73,89.5 117.73,89.51 117.86,89.63 117.86,90.67 119.04,91.85 119.39,91.85 119.65,91.59 v1(119.65,91.5)
  BOTTOM w0.127: C1603.1 120,91.04 119.84,91.2 119.84,91.31 v1(119.65,91.5) ; v2(55.78,96.91) 56.01,96.91 ; 56.01,96.91 56.01,95.16 55.94,95.09 55.94,94.19 55.45,93.69 54.76,93.69 54.65,93.59 54.65,93.34 v1(54.91,93.08) ; 56.01,96.91 56.01,98.51 54.08,100.44 46.74,100.44 44.64,98.34 44.64,97.9 44.8,97.74 44.8,97.32 LOM31.14
PCIE_TX_CON_N6: length 130.4
  L6 w0.102: v1(27.28,59.6) 27,59.88 26.36,59.88 26.16,60.08 25.24,60.08 22.12,63.2 22.12,71.29 24.68,73.85 24.69,73.85 30.78,79.94 34.21,79.94 34.46,79.69 35.13,79.69 35.47,80.02 38.4,80.02 41.12,82.74 42.33,82.74 45.5,85.91 47.32,85.91 50.52,89.1 50.52,91.01 51.49,91.97 51.49,91.98 52.88,93.37 52.88,94.44 54.88,96.43 55.33,96.43 55.33,96.43 78.94,96.43 80,97.48 92.91,97.48 94.76,95.63 96.23,95.63 96.81,95.04 102.43,95.04 104.75,92.72 104.75,92.71 105.28,92.17 105.28,92.14 105.32,92.1 105.32,91.42 105.66,91.08 108.26,91.08 109.49,89.85 113.26,89.85 114.1,89.01 115,89.01 115.73,89.74 115.73,90.06 116.14,90.48 116.78,90.48 v1(116.84,90.54)
  BOTTOM w0.127: C1601.1 117.28,90.54 v1(116.84,90.54) 116.84,90.76 v2(116.56,91.04) ; WLAN1.37 27.43,59.75 v1(27.28,59.6)
PCIE_TX_CON_P5: length 94.6
  L6 w0.102: v1(119.66,92.21) 119.5,92.05 118.95,92.05 117.65,90.75 117.65,89.72 117.53,89.59 116.29,88.36 110.11,88.36 108.71,89.75 106.18,89.75 105.66,90.28 105.62,90.28 105.55,90.36 100.63,90.36 98.48,92.51 86.43,92.51 82.65,88.73 80.01,88.73 77.37,91.37 74.76,91.37 73.95,92.19 70.49,92.19 70.19,91.88 61.88,91.88 61.57,91.58 59.26,91.58 58.86,91.17 56.64,91.17 55.55,92.27 55.55,92.9 v1(55.72,93.08)
  BOTTOM w0.127: 56.26,98.18 56.26,95.06 56.18,94.99 56.18,94.09 55.72,93.62 v1(55.72,93.08) ; 56.26,98.18 v2(56.46,98.18) ; 56.26,98.18 56.26,98.61 54.18,100.68 46.64,100.68 44.4,98.44 LOM31.13 ; v1(119.66,92.21) 119.94,91.93 C1604.1
PCIE_TX_CON_P6: length 130.5
  L6 w0.102: v1(27.28,60.4) 26.96,60.08 26.45,60.08 26.24,60.28 25.32,60.28 22.33,63.28 22.33,71.2 24.77,73.65 30.87,79.74 34.12,79.74 34.38,79.49 35.22,79.49 35.55,79.82 38.48,79.82 41.2,82.54 42.42,82.54 45.59,85.7 47.41,85.7 50.72,89.02 50.72,90.92 51.69,91.89 51.69,91.89 53.09,93.29 53.09,94.35 54.96,96.23 79.03,96.23 80.08,97.28 92.82,97.28 94.68,95.43 96.14,95.43 96.72,94.84 102.34,94.84 104.54,92.64 104.54,92.62 105.08,92.09 105.08,92.05 105.11,92.02 105.11,91.34 105.58,90.88 108.17,90.88 109.4,89.65 113.17,89.65 114.01,88.81 115.09,88.81 115.93,89.65 115.93,89.98 116.23,90.28 116.48,90.28 116.84,89.92 v1(116.84,89.77)
  BOTTOM w0.127: WLAN1.35 28.34,60.25 28.08,59.99 27.69,59.99 v1(27.28,60.4) ; v2(116.69,89.19) 116.84,89.34 v1(116.84,89.77) 116.84,89.91 117.11,90.18 117.26,90.18 C1602.1
PCIE_TX_CPU_N5: length 6.7
  BOTTOM w0.089: 121.17,88.76 121.17,88.74 121.2,88.71 121.2,86.95 121.24,86.91 121.24,86.61 121.21,86.56 121.21,86.22 121.24,86.15 121.24,85.98 121.15,85.72 121.11,85.66 CPU1.C19
  BOTTOM w0.127: C1603.2 121.04,91.04 120.82,90.82 120.82,90.46 120.94,90.33 121.39,90.33 121.51,90.21 121.51,89.58 121.17,89.24 121.17,88.76
PCIE_TX_CPU_N6: length 6.9
  BOTTOM w0.089: 120.48,88.52 120.5,88.51 120.5,86.23 120.6,86.13 120.6,86.11 120.65,86.06 120.65,85.98 120.76,85.87 120.76,85.71 CPU1.D20
  BOTTOM w0.127: C1601.2 118.48,90.79 119.27,90 ; 119.27,90 120.48,88.79 120.48,88.52 ; 119.27,90 v2(119.35,90.08)
PCIE_TX_CPU_P5: length 7.8
  BOTTOM w0.089: 121.41,88.76 121.41,88.74 121.39,88.71 121.39,87.11 121.42,87.08 121.42,86.56 121.41,86.55 121.39,86.5 121.39,86.28 121.42,86.22 121.42,85.94 121.39,85.88 121.36,85.75 121.32,85.61 121.32,85.24 121.2,85.09 121.11,84.96 121.04,84.86 CPU1.D19
  BOTTOM w0.127: C1604.2 121.75,91.4 121.75,90.33 ; 121.75,90.33 v2(121.89,90.33) ; 121.75,90.33 121.75,89.48 121.41,89.14 121.41,88.76
PCIE_TX_CPU_P6: length 6.8
  BOTTOM w0.089: CPU1.C20 120.41,86.05 120.31,86.15 120.31,88.4 120.27,88.44 120.27,88.48 120.24,88.51 120.24,88.52
  BOTTOM w0.127: 120.24,88.52 120.24,88.69 119.36,89.57 119.13,89.57 118.69,89.14 118.41,89.14 ; v2(118.41,88.99) 118.41,89.14 ; 118.41,89.14 118.19,89.14 118.06,89.27 118.06,89.7 118.26,89.9 C1602.2
PCIE_WAKE#: length 3
  TOP w0.127: R1705.1 150.58,64.91 v2(151.21,64.91) 151.42,64.91 D1702.3
PCIE_WLAN_WAKE#: length 310.9
  TOP w0.127: R6218.2 90.56,117.65 90.56,118.4 v1(90.61,118.45) ; D1702.1 151.67,62.01 151.02,62.66 150.59,62.66 150.33,62.92 150.33,63.35 150.3,63.37 R1714.2 150.72,63.74 150.91,63.55 151.47,63.55 151.54,63.48 152.11,62.91 154.57,62.91 v2(154.81,63.15) 154.81,63.87 v1(154.69,63.99)
  L3 w0.127: v1(149.45,79.23) 149.45,77.73 151.37,75.82 152.05,75.82 153.84,74.02 153.84,67.43 153.87,67.41 153.87,64.93 154.69,64.12 v1(154.69,63.99) ; v1(49.02,110.45) 48.3,111.17 47.57,111.17 46.77,110.38 46.77,102.9 42.67,98.79 34.45,98.79 30.1,94.44 30.1,84.31 29.27,83.49 29.27,75.61 29.84,75.04 29.84,70.09 31.88,68.06 31.88,62.09 32.19,61.77 32.19,60.25 32.32,60.13 32.32,57.33 v1(31.88,56.88) ; v1(151.04,121.84) 152.48,121.84 156.74,117.58 156.74,111.77 155.09,110.12 154.08,110.12 148.78,104.82 148.78,99.21 v1(147.27,97.7)
  L4 w0.127: v1(25.53,52.69) 25.53,55.87 25.21,56.19 25.21,56.56 26.42,57.77 27.42,57.77 28.61,58.96 28.61,61.04 28.2,61.45 27.31,61.45 v1(26.54,62.22) ; v1(58.04,118.73) 68.73,118.73 70.12,117.33 75.57,117.33 79.06,113.85 82.48,113.85 87.43,118.79 90.27,118.79 v1(90.61,118.45) 93.38,118.45 93.67,118.16 94.43,118.16 95.07,117.52 95.82,117.52 99.57,121.27 100.37,121.27 100.91,121.81 102.15,121.81 102.45,122.12 102.82,122.12 104.03,120.91 104.12,120.91 106.32,118.7 116.7,118.7 119.39,121.4 122.3,121.4 124.01,123.11 127.41,123.11 128.52,124.22 132.29,124.22 134.57,126.5 134.93,126.5 134.93,126.5 143.26,126.5 144.85,124.91 146.54,124.91 146.9,124.91 149.96,121.84 v1(151.04,121.84)
  L6 w0.127: v1(30.73,61.58) 29.65,62.66 27.24,62.66 26.8,62.22 v1(26.54,62.22) ; v1(49.02,110.45) 46.91,112.56 46.91,119.52 47.5,120.1 53.77,120.1 55.14,118.73 v1(58.04,118.73) ; v1(149.45,79.23) 153.49,83.27 153.49,87.95 154.05,88.5 154.05,90.3 153.06,91.3 151.38,91.3 147.27,95.41 v1(147.27,97.7)
  BOTTOM w0.127: v1(25.53,52.69) 26.48,51.74 R6121.1 ; v1(30.73,61.58) 30.94,61.78 31.67,61.78 31.76,61.69 31.88,61.69 32.19,61.38 32.19,60.25 32.64,59.81 32.64,57.64 v1(31.88,56.88) 30.92,55.93 30.61,55.93 30.29,55.61 30.23,55.61 29.87,55.25 WLAN1.55
PCIE_WLAN_WAKE#_R: length 17.5
  TOP w0.127: v1(34.7,54.35) 34.8,54.35 34.8,54.35 35.24,54.35 v2(35.26,54.37)
  BOTTOM w0.127: WLAN1.70 35.81,51.5 ; 35.81,51.5 35.56,51.75 35.56,53.49 v1(34.7,54.35) ; 35.81,51.5 34.42,51.5 32.08,49.16 32.08,48.7 31.7,48.32 27.56,48.32 26.67,49.21 R6121.2
PD4403_A: length 4.7
  TOP w0.102: PQ4408.B 235.16,6.02 PD4404.A 231.85,8.06 v2(231.67,7.88)
PD4403_K: length 2.5
  TOP w0.102: PD4404.K 231.74,5.78 PR4458.2 v2(231.57,5.04)
PD#: length 3.7
  TOP w0.102: v1(27.43,14.72) 27.61,14.54 27.61,13.75 27.48,13.62 HDA27.47
  BOTTOM w0.102: v1(27.43,14.72) 26.86,14.15 R2708.2 26.87,13.94 26.87,13.07 v2(26.85,13.04)
PECI_EC: length 3.9
  TOP w0.14: KBC24.94 202.02,23.54 202.28,23.28 v1(202.34,23.28)
  BOTTOM w0.14: C2405.1 R2437.1 201.04,23.83 v2(201.64,23.24) 202.29,23.24 v1(202.34,23.28)
PEG_CLK1_CPU: length 140.2
  TOP w0.127: EC6103.1 32.55,58.56 31.82,59.29 v1(31.78,59.29)
  L6 w0.102: v1(105.88,92.29) 105.5,92.67 105.5,92.95 105.33,93.13 104.96,93.13 102.52,95.57 97.27,95.57 96.67,96.17 94.99,96.17 93.13,98.03 79.38,98.03 78.27,96.91 55.53,96.91 54.68,96.91 53.94,96.17 52.37,96.17 51.18,94.99 51.18,92.36 51,92.18 51,92.17 49.91,91.08 49.91,89.17 47.13,86.39 45.31,86.39 42.13,83.22 40.92,83.22 38.2,80.5 35.95,80.5 35.13,81.32 31.16,81.32 25.55,75.7 24.24,75.7 23.54,75 23.54,74.81 20.55,71.83 20.55,62.44 24.77,58.23 27.89,58.23 29.11,59.45 31.62,59.45 v1(31.78,59.29)
  BOTTOM w0.089: 106.95,88.26 106.97,88.26 107,88.28 107.28,88.28 107.73,87.83 107.73,86.61 107.63,86.51 107.52,86.51 107.46,86.57 CPU1.A42
  BOTTOM w0.127: v2(105.66,90.79) 105.8,90.65 ; 105.8,90.65 106.72,91.57 106.72,92.49 106.53,92.68 106.23,92.68 105.88,92.33 v1(105.88,92.29) ; 105.8,90.65 105.68,90.52 105.68,89.28 106.7,88.26 106.95,88.26 ; WLAN1.47 30.25,57.25 31.31,58.31 31.31,58.56 31.06,58.8 31.06,59.27 31.19,59.4 31.67,59.4 v1(31.78,59.29)
PEG_CLK1_CPU#: length 140.2
  TOP w0.127: v1(31.88,58.53) 31.88,58.51 32.6,57.78 32.61,57.78 32.65,57.74 EC6102.1
  L6 w0.102: v1(105.89,92.92) 105.82,92.92 105.74,93 105.41,93.33 105.04,93.33 103.13,95.24 102.6,95.77 97.36,95.77 96.75,96.38 95.07,96.38 93.22,98.23 79.3,98.23 78.18,97.11 55.62,97.11 54.59,97.11 53.85,96.38 52.28,96.38 50.98,95.07 50.98,92.44 50.8,92.26 50.8,92.26 49.71,91.16 49.71,89.26 47.05,86.6 45.22,86.6 42.05,83.42 40.83,83.42 38.12,80.71 36.03,80.71 35.22,81.52 31.07,81.52 25.46,75.91 24.16,75.91 23.33,75.08 23.33,74.9 20.35,71.91 20.35,62.36 24.68,58.02 27.97,58.02 29.19,59.24 31.21,59.24 31.88,58.58 v1(31.88,58.53)
  BOTTOM w0.089: CPU1.B42 107.92,86.53 107.92,87.9 107.35,88.47 107,88.47 106.97,88.5 106.95,88.5
  BOTTOM w0.127: 106.78,92.77 106.63,92.92 v1(105.89,92.92) ; 106.78,92.77 v2(106.91,92.9) ; 106.78,92.77 106.96,92.59 106.96,91.47 105.92,90.42 105.92,89.38 106.8,88.5 106.95,88.5 ; v1(31.88,58.53) 31.63,58.28 31.62,58.28 30.09,56.75 WLAN1.49
PEG_CLK2_CPU: length 84.8
  L6 w0.102: v1(107.99,97.42) 107.81,97.42 106.97,98.26 105.71,98.26 103.8,100.16 98.3,100.16 96.45,102.02 87.57,102.02 86.39,103.19 84.34,103.19 83.55,102.4 81.9,102.4 80.78,101.28 73.5,101.28 72.02,99.81 60.88,99.81 60.24,100.44 54.14,100.44 52.66,101.92 50.9,101.92 49.83,100.85 48.39,100.85 47.96,100.42 47.96,99.92 v1(47.75,99.71)
  BOTTOM w0.089: CPU1.C41 108.02,85.87 108.32,86.17 108.32,88.5 108,88.82 108,88.86 107.98,88.88
  BOTTOM w0.127: LOM31.15 45.2,97.78 45.35,97.93 45.35,98.38 45.75,98.78 47.78,98.78 47.98,98.98 47.98,99.48 v1(47.75,99.71) ; 107.7,94.65 107.7,97.12 v1(107.99,97.42) ; 107.7,94.65 v2(107.87,94.65) ; 107.7,94.65 107.7,91.35 106.69,90.35 106.69,89.54 106.98,89.25 107.61,89.25 107.98,88.88
PEG_CLK2_CPU#: length 84.8
  L6 w0.102: v1(48.55,99.71) 48.38,99.71 48.16,99.93 48.16,100.34 48.47,100.65 49.92,100.65 50.98,101.71 52.58,101.71 54.05,100.24 60.16,100.24 60.79,99.6 72.11,99.6 73.58,101.08 80.86,101.08 81.98,102.19 83.63,102.19 84.43,102.99 86.31,102.99 87.48,101.81 96.36,101.81 98.22,99.96 103.72,99.96 105.62,98.05 106.89,98.05 107.16,97.78 v1(107.16,97.44)
  BOTTOM w0.089: CPU1.D41 108.02,85.33 107.74,85.62 107.74,85.86 108.13,86.25 108.13,88.42 107.86,88.69 107.83,88.69 107.81,88.7
  BOTTOM w0.127: v1(107.16,97.44) 107.45,97.15 107.45,95.79 ; v2(107.29,95.79) 107.45,95.79 ; 107.45,95.79 107.45,91.45 106.45,90.45 106.45,89.44 106.88,89.01 107.51,89.01 107.81,88.7 ; LOM31.16 45.6,98.28 45.85,98.54 47.88,98.54 48.22,98.88 48.22,99.46 48.47,99.71 v1(48.55,99.71)
PEG_CLK_CPU: length 101.7
  L6 w0.102: v1(160.15,72.12) 160.32,71.94 160.62,71.94 160.83,72.15 160.83,72.65 160.37,73.11 158.07,73.11 156.97,72.01 150.35,72.01 148.29,74.07 148.29,75.43 148.36,75.51 148.36,78.42 148.11,78.67 148.11,79.71 141.85,85.96 141.11,85.96 140.36,86.72 140.36,90.04 142.35,92.04 142.35,93.85 139.01,97.19 129.58,97.19 127.68,99.1 120.82,99.1 120.16,99.76 119.57,99.76 v1(119.29,99.48)
  BOTTOM w0.089: CPU1.C42 107.25,85.62 107.25,85.83 107.2,85.96 107.2,86.16 107.24,86.25 107.24,86.52 107.2,86.61 107.2,86.91 107.41,87.12 107.41,87.48 106.96,87.93 106.48,87.93 105.91,88.5 105.91,88.54 105.9,88.55
  BOTTOM w0.127: 105.37,96.28 105.37,91.28 105.17,91.08 105.17,89.28 105.9,88.55 ; 105.37,96.28 v2(105.54,96.28) ; 105.37,96.28 105.37,97.04 108.63,100.3 116.75,100.3 117.29,99.76 119.02,99.76 v1(119.29,99.48) ; v1(160.15,72.12) 160.29,71.98 160.81,71.98 160.81,71.98 161.42,71.98 162.08,71.32 164.67,71.32 164.95,71.04 165.74,71.04 165.86,71.17 166.27,71.17 166.64,70.8 GPU1.AK30
PEG_CLK_CPU#: length 101.8
  L6 w0.102: v1(160.66,71.49) 160.66,71.69 161.04,72.07 161.04,72.73 160.45,73.31 157.99,73.31 156.88,72.21 150.43,72.21 148.49,74.15 148.49,75.35 148.56,75.42 148.56,78.51 148.31,78.76 148.31,79.79 141.93,86.17 141.2,86.17 140.56,86.8 140.56,89.96 142.56,91.95 142.56,93.94 139.1,97.39 129.67,97.39 127.76,99.3 120.9,99.3 120.24,99.96 119.61,99.96 v1(119.29,100.28)
  BOTTOM w0.089: CPU1.D42 107.07,85.15 107.07,85.79 107.02,85.93 107.02,86.2 107.06,86.29 107.06,86.49 107.02,86.58 107.02,86.99 107.23,87.19 107.23,87.41 106.9,87.74 106.4,87.74 105.78,88.37 105.74,88.37 105.73,88.38
  BOTTOM w0.127: 105.73,88.38 105.64,88.47 104.93,89.18 104.93,91.18 105.13,91.38 105.13,94.57 ; 105.13,94.57 v2(104.95,94.57) ; 105.13,94.57 105.13,97.14 108.53,100.54 116.85,100.54 117.39,100 119.02,100 v1(119.29,100.28) ; v1(160.66,71.49) 160.91,71.74 161.32,71.74 161.98,71.08 164.57,71.08 164.85,70.8 GPU1.AK32
PEG_CLK_XDP: length 4
  TOP w0.127: XDP1.40 61,92.02 60.74,92.28 60.74,92.6 v1(60.88,92.75)
  BOTTOM w0.127: R9913.2 60.88,91.69 v1(60.88,92.75) 61.14,92.49 v2(61.47,92.49)
PEG_CLK_XDP#: length 4
  TOP w0.127: XDP1.42 60.5,92.47 v1(60.22,92.75)
  BOTTOM w0.127: R9923.2 60.22,91.77 v1(60.22,92.75) 60.37,92.89 60.37,93.38 v2(60.38,93.38)
PEG_RX_CPU_N0: length 63.6
  TOP w0.127: C7302.2 155.57,72.7 154.49,72.7 152.98,74.2 152.98,76.21 ; 152.98,76.21 v2(152.81,76.21) ; 152.98,76.21 152.98,76.61 152.29,77.31 152.29,79.43 154.01,81.16 154.01,84.78 150.16,88.63 150.16,89.68 148.53,91.31 147.6,91.31 144.35,94.56 144.35,94.94 144.83,95.42 144.83,95.6 144.65,95.78 144.47,95.78 143.99,95.3 143.61,95.3 142.15,96.76 131.61,96.76 129.68,94.83 129.68,93.5 129.03,92.85 129.03,88.25 128,87.22 128,85.82 126.25,84.07 125.91,84.07 125.6,83.77 125.6,82.25 125.11,81.75 v1(125.11,81.73)
  BOTTOM w0.127: CPU1.H13 124.83,82.04 125.11,81.77 v1(125.11,81.73)
PEG_RX_CPU_N1: length 62
  TOP w0.127: v1(126.07,83.02) 126.2,83.14 126.82,83.14 127.2,83.52 127.2,84.26 128.02,85.08 128.87,85.08 129.37,85.58 129.92,85.58 130.43,86.09 130.43,89.54 130.56,89.67 131.43,89.67 131.7,89.93 131.7,90.39 131.43,90.66 130.56,90.66 130.43,90.78 130.43,92.39 131.66,93.62 133.91,95.87 141.98,95.87 147.3,90.55 148.23,90.55 149.33,89.45 149.33,88.4 153.26,84.47 153.26,81.5 151.14,79.38 151.14,74.38 151.84,73.68 152.43,73.68 153.54,72.57 ; 153.54,72.57 154.98,71.13 155.31,71.13 C7304.2 ; 153.54,72.57 v2(153.42,72.45)
  BOTTOM w0.127: CPU1.G11 125.75,82.69 v1(126.07,83.02)
PEG_RX_CPU_N2: length 63.3
  TOP w0.127: v1(123.34,82.3) 123.4,82.37 124.52,82.37 124.99,82.84 124.99,83.91 124.83,84.07 124.83,85.44 126.11,86.73 126.49,86.73 126.87,87.11 126.87,93.08 131.31,97.52 143.99,97.52 144.58,96.94 146.11,95.4 146.11,93.86 147.33,92.64 147.89,92.09 148.82,92.09 150.93,89.97 150.93,89 153.06,86.87 153.69,86.87 154.76,85.79 154.76,80.84 153.05,79.13 153.05,77.61 153.77,76.88 153.77,75.07 ; C7306.2 154.43,74.6 154,74.6 153.77,74.83 153.77,75.07 ; 153.77,75.07 v2(153.59,75.07)
  BOTTOM w0.127: v1(123.34,82.3) 123.08,82.04 CPU1.H16
PEG_RX_CPU_N3: length 59.8
  TOP w0.127: v1(124.24,83.02) 123.84,83.42 123.84,85.55 125.36,87.08 125.36,93.09 130.79,98.51 144.4,98.51 147.1,95.81 147.1,94.27 148.3,93.08 149.23,93.08 151.98,90.32 151.98,89.35 153.13,88.2 153.48,87.86 154.1,87.86 155.75,86.2 155.75,80.4 155.5,80.15 ; 155.5,80.15 v2(155.63,80.02) ; 155.5,80.15 154.21,78.85 154.21,78.58 154.44,78.34 C7308.2
  BOTTOM w0.127: v1(124.24,83.02) 123.92,82.69 CPU1.G15
PEG_RX_CPU_P0: length 63.3
  TOP w0.127: v1(125.12,82.38) 125.17,82.38 125.36,82.57 125.36,83.87 125.81,84.31 126.15,84.31 127.76,85.92 127.76,87.32 128.79,88.35 128.79,92.95 129.44,93.6 129.44,94.93 131.51,97 142.25,97 143.71,95.54 143.89,95.54 144.37,96.03 144.75,96.03 145.07,95.7 145.07,95.32 144.59,94.84 144.59,94.66 147.7,91.55 148.63,91.55 150.41,89.78 150.41,88.73 154.25,84.88 154.25,81.06 152.53,79.33 152.53,77.41 153.23,76.71 153.23,74.3 154.59,72.94 154.94,72.94 ; 154.94,72.94 v2(154.94,73.11) ; 154.94,72.94 155.57,72.94 C7301.2
  BOTTOM w0.127: CPU1.G13 124.83,82.69 125.12,82.4 v1(125.12,82.38)
PEG_RX_CPU_P1: length 61.9
  TOP w0.127: v2(154.84,71.87) 154.71,71.74 ; 154.71,71.74 152.53,73.92 151.94,73.92 151.38,74.48 151.38,79.28 153.5,81.4 153.5,84.57 149.57,88.5 149.57,89.55 148.33,90.79 147.4,90.79 142.08,96.11 133.81,96.11 131.42,93.72 130.19,92.49 130.19,90.68 130.46,90.42 131.33,90.42 131.46,90.29 131.46,90.03 131.33,89.91 130.46,89.91 130.19,89.64 130.19,86.19 129.82,85.82 129.27,85.82 128.77,85.32 127.92,85.32 126.96,84.36 126.96,83.62 126.72,83.38 126.36,83.38 v1(126.07,83.67) ; 154.71,71.74 155.08,71.37 155.62,71.37 C7303.2
  BOTTOM w0.127: v1(126.07,83.67) 125.75,83.34 CPU1.F11
PEG_RX_CPU_P2: length 63.3
  TOP w0.127: 154.02,76.21 154.02,74.93 154.1,74.85 154.43,74.85 C7305.2 ; 154.02,76.21 v2(154.18,76.21) ; 154.02,76.21 154.02,76.98 153.29,77.71 153.29,79.03 155,80.74 155,85.89 153.79,87.11 153.16,87.11 151.17,89.1 151.17,90.07 148.92,92.33 147.99,92.33 147.5,92.81 146.35,93.96 146.35,95.5 144.75,97.11 144.09,97.76 131.21,97.76 126.63,93.18 126.63,87.21 126.39,86.97 126.01,86.97 124.59,85.54 124.59,83.97 124.75,83.81 124.75,82.94 124.42,82.61 123.66,82.61 v1(123.33,82.94)
  BOTTOM w0.127: v1(123.33,82.94) 123.08,82.69 CPU1.G16
