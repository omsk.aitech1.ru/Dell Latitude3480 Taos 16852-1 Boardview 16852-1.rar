# Allegro board 16852-1.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
C402H22
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
C603H32
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H36
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H38
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C603H40
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
C805H54
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
C805H56
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
C805H58
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
C1206H71
  rect 1.854x1.27 smd: 1(0,1.397) 2(0,-1.397)
C1808H40
  rect 2.286x1.27 smd: 1(0,2.032) 2(0,-2.032)
CON2O-U
  custom 0.159x0.159 smd: 1(0,0.254) 2(0,-0.254)
CT3528H79
  rect 2.286x2.286 smd: 1(0,1.905) 2(0,-1.905)
CT7343H83
  rect 2.413x2.286 smd: 1(0,3.15) 2(0,-3.15)
DFN8F3-G245165H34
  rect 0.406x0.965 smd: 1(0.975,1.526) 2(0.325,1.526) 3(-0.325,1.526) 4(-0.975,1.526) 5(-0.975,-1.526)
  rect 0.025x0.025 smd: 6(-0.325,-1.526) 8(0.975,-1.526)
  custom 0.241x0.241 smd: 7(0.325,-1.526)
  rect 2.438x1.651 smd: 9(0,0)
DFN8G2-G1711H26
  rect 0.305x0.635 smd: 1(0.75,1.127) 2(0.25,1.127) 3(-0.25,1.127) 4(-0.75,1.127) 5(-0.75,-1.127) 6(-0.25,-1.127) 7(0.25,-1.127) 8(0.75,-1.127)
  rect 1.702x1.092 smd: 9(0,0)
DFN8G2030-G1614-1H24
  rect 0.305x1.092 smd: 1(0.75,1.462) 2(0.25,1.462) 3(-0.25,1.462) 4(-0.75,1.462) 5(-0.75,-1.462) 6(-0.25,-1.462) 7(0.25,-1.462) 8(0.75,-1.462)
  rect 1.6x1.397 smd: 9(0,0)
DFN10G2510H22
  rect 0.305x0.787 smd: 1(1,0.494) 5(-1,0.494) 6(-1,-0.494) 10(1,-0.494)
  rect 0.254x0.787 smd: 2(0.521,0.494) 4(-0.521,0.494) 7(-0.521,-0.494) 9(0.521,-0.494)
  rect 0.025x0.025 smd: 3(0,0.494)
  rect 0.406x1.753 smd: 8(0,-0.494)
DFN10G2510H26
  rect 0.305x0.787 smd: 1(1,0.494) 5(-1,0.494) 6(-1,-0.494) 10(1,-0.494)
  rect 0.254x0.787 smd: 2(0.521,0.494) 4(-0.521,0.494) 7(-0.521,-0.494) 9(0.521,-0.494)
  rect 0.025x0.025 smd: 3(0,0.494)
  rect 0.406x1.753 smd: 8(0,-0.494)
DFN14J3020-G255D85H32
  custom 0.151x0.151 smd: 1(1.2,1.076) 6(-0.8,1.076) 8(-1.2,-1.076) 13(0.8,-1.076)
  rect 0.025x0.025 smd: 2(0.8,1.076) 7(-1.2,1.076) 9(-0.8,-1.076) 14(1.2,-1.076)
  rect 0.203x0.864 smd: 3(0.4,1.076) 4(0,1.076) 5(-0.4,1.076) 10(-0.4,-1.076) 11(0,-1.076) 12(0.4,-1.076)
  rect 2.54x0.838 smd: 15(0,0)
DO214AAAKH97
  rect 2.261x1.905 smd: A(0,2.35) K(0,-2.35)
FL4S030HT6R300-DT
  rect 0.305x1.295 smd: 1(-11.6,5.65) 2(-10.8,5.65) 3(-10,5.65) 4(-9.2,5.65) 5(-8.4,5.65) 6(-7.6,5.65) 7(-6.8,5.65) 8(-6,5.65) 9(-5.2,5.65) 10(-4.4,5.65) 11(-3.6,5.65) 12(-2.8,5.65) 13(-2,5.65) 14(-1.2,5.65) 15(-0.4,5.65) 16(0.4,5.65) 17(1.2,5.65) 18(2,5.65) 19(2.8,5.65) 20(3.6,5.65) 21(4.4,5.65) 22(5.2,5.65) 23(6,5.65) 24(6.8,5.65) 25(7.6,5.65) 26(8.4,5.65) 27(9.2,5.65) 28(10,5.65) 29(10.8,5.65) 30(11.6,5.65)
  rect 1.803x2.21 smd: 31(-13.94,0) 32(13.94,0)
G6179HT0321-001
  rect 0.635x2.108 smd: 1(1.905,3.466) 2(0.635,3.466) 3(-0.635,3.466) 4(-1.905,3.466) 5(-1.905,-3.466) 6(-0.635,-3.466) 7(0.635,-3.466) 8(1.905,-3.466)
GAP-CLOSE-PWR
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
GAP-CLOSE-PWR-3
  rect 0.66x0.762 smd: 1(-0.305,0) 2(0.305,0)
HOLE197R166
  round 5.004 hole 4.216: 1(0,0)
HOLE256R115
  round 6.502 hole 2.921: 1(0,0)
HOLE335R115
  round 8.509 hole 2.921: 1(0,0)
HS81100
  rect 0.813x1.6 smd: 1(-5.625,2.9) 2(-4.375,2.9) 3(-3.125,2.9) 4(-1.875,2.9) 5(-0.625,2.9) 6(0.625,2.9) 7(1.875,2.9) 8(3.125,2.9) 9(4.375,2.9) 10(5.625,2.9)
  rect 2.108x2.997 smd: 11(-8.175,0) 12(8.175,0)
HT85BE95R46-D-5
  round 8.509 hole 4.623: 1(0,0)
JSD1210-0111FC
  rect 0.889x0.813 smd: 1(-3.7,0) 2(3.7,0)
  rect 0.711x0.711 smd: A(-2.25,1.55) B(2.25,1.55) C(-0.75,1.55) C1(0.75,1.55)
L402H22
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
L1608-UH38
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
L2520-D620H48
  rect 2.261x1.245 smd: 1(0,1.018) 2(0,-1.018)
L3030-3009-2H40
  rect 3.251x1.524 smd: 1(0,1.108) 2(0,-1.108)
L7066-1830-UH119
  rect 3.505x2.921 smd: 1(0,2.78) 2(0,-2.78)
L7366-1930H158
  rect 3.505x3.073 smd: 1(0,2.856) 2(0,-2.856)
L125100-4P-4H28
  rect 0.762x0.432 smd: 1(-0.625,0.341) 2(0.625,0.341) 3(0.625,-0.341) 4(-0.625,-0.341)
LFCSP32G5-G2D6H32
  custom 0.076x0.076 smd: 1(1.75,2.208) 8(-1.75,2.208) 9(-2.208,1.75) 16(-2.208,-1.75) 17(-1.75,-2.208) 24(1.75,-2.208) 25(2.208,-1.75) 32(2.208,1.75)
  rect 0.305x0.584 smd: 2(1.25,2.208) 3(0.75,2.208) 4(0.25,2.208) 5(-0.25,2.208) 6(-0.75,2.208) 7(-1.25,2.208) 18(-1.25,-2.208) 19(-0.75,-2.208) 20(-0.25,-2.208) 21(0.25,-2.208) 22(0.75,-2.208) 23(1.25,-2.208)
  rect 0.584x0.305 smd: 10(-2.208,1.25) 11(-2.208,0.75) 12(-2.208,0.25) 13(-2.208,-0.25) 14(-2.208,-0.75) 15(-2.208,-1.25) 26(2.208,-1.25) 27(2.208,-0.75) 28(2.208,-0.25) 29(2.208,0.25) 30(2.208,0.75) 31(2.208,1.25)
  rect 2.591x2.591 smd: 33(0,0)
LFDFN8G2-G1309H40
  rect 0.305x0.483 smd: 1(0.75,0.911) 2(0.25,0.911) 3(-0.25,0.911) 4(-0.75,0.911) 5(-0.75,-0.911) 6(-0.25,-0.911) 7(0.25,-0.911) 8(0.75,-0.911)
  rect 1.295x0.889 smd: 9(0,0)
LFQFN48J6-G4D6H40
  rect 0.203x0.686 smd: 1(2.2,2.857) 2(1.8,2.857) 3(1.4,2.857) 4(1,2.857) 5(0.6,2.857) 6(0.2,2.857) 7(-0.2,2.857) 8(-0.6,2.857) 9(-1,2.857) 10(-1.4,2.857) 11(-1.8,2.857) 12(-2.2,2.857) 25(-2.2,-2.857) 26(-1.8,-2.857) 27(-1.4,-2.857) 28(-1,-2.857) 29(-0.6,-2.857) 30(-0.2,-2.857) 31(0.2,-2.857) 32(0.6,-2.857) 33(1,-2.857) 34(1.4,-2.857) 35(1.8,-2.857) 36(2.2,-2.857)
  rect 0.686x0.203 smd: 13(-2.857,2.2) 14(-2.857,1.8) 15(-2.857,1.4) 16(-2.857,1) 17(-2.857,0.6) 18(-2.857,0.2) 19(-2.857,-0.2) 20(-2.857,-0.6) 21(-2.857,-1) 22(-2.857,-1.4) 23(-2.857,-1.8) 24(-2.857,-2.2) 37(2.857,-2.2) 38(2.857,-1.8) 39(2.857,-1.4) 40(2.857,-1) 41(2.857,-0.6) 42(2.857,-0.2) 43(2.857,0.2) 44(2.857,0.6) 45(2.857,1) 46(2.857,1.4) 47(2.857,1.8) 48(2.857,2.2)
  rect 4.597x4.597 smd: 49(0,0)
LGA12G2H40
  rect 0.381x0.381 smd: 1(0.809,0.809) 4(-0.809,0.809) 7(-0.809,-0.809) 10(0.809,-0.809)
  rect 0.305x0.432 smd: 2(0.25,0.784) 3(-0.25,0.784) 8(-0.25,-0.784) 9(0.25,-0.784)
  rect 0.432x0.305 smd: 5(-0.784,0.25) 6(-0.784,-0.25) 11(0.784,-0.25) 12(0.784,0.25)
LVD-A40SFYG
  rect 0.305x1.295 smd: 1(-9.75,-1.95) 2(-9.25,-1.95) 3(-8.75,-1.95) 4(-8.25,-1.95) 5(-7.75,-1.95) 6(-7.25,-1.95) 7(-6.75,-1.95) 8(-6.25,-1.95) 9(-5.75,-1.95) 10(-5.25,-1.95) 11(-4.75,-1.95) 12(-4.25,-1.95) 13(-3.75,-1.95) 14(-3.25,-1.95) 15(-2.75,-1.95) 16(-2.25,-1.95) 17(-1.75,-1.95) 18(-1.25,-1.95) 19(-0.75,-1.95) 20(-0.25,-1.95) 21(0.25,-1.95) 22(0.75,-1.95) 23(1.25,-1.95) 24(1.75,-1.95) 25(2.25,-1.95) 26(2.75,-1.95) 27(3.25,-1.95) 28(3.75,-1.95) 29(4.25,-1.95) 30(4.75,-1.95) 31(5.25,-1.95) 32(5.75,-1.95) 33(6.25,-1.95) 34(6.75,-1.95) 35(7.25,-1.95) 36(7.75,-1.95) 37(8.25,-1.95) 38(8.75,-1.95) 39(9.25,-1.95) 40(9.75,-1.95)
  rect 1.194x3.2 smd: 41(-12.15,0) 45(12.15,0)
  rect 2.311x1.295 smd: 42(-8.9,1.95) 43(0,1.95) 44(8.9,1.95)
MSOP8-1H44
  rect 0.356x1.524 smd: 1(-0.975,-2.055) 2(-0.325,-2.055) 3(0.325,-2.055) 4(0.975,-2.055) 5(0.975,2.055) 6(0.325,2.055) 7(-0.325,2.055) 8(-0.975,2.055)
MSOP10-G2D5H44
  rect 0.305x1.372 smd: 1(-1,-2.146) 2(-0.5,-2.146) 3(0,-2.146) 4(0.5,-2.146) 5(1,-2.146) 6(1,2.146) 7(0.5,2.146) 8(0,2.146) 9(-0.5,2.146) 10(-1,2.146)
  rect 2.489x2.489 smd: 11(0,0)
NFSA0-S6705-TP40
  round 0.254 hole 1.651 unplated: (-10,0)
  round 0.254 hole 1.168 unplated: (10,0)
  rect 0.305x1.549 smd: 1(9.25,-5.275) 2(9,2.275) 3(8.75,-5.275) 4(8.5,2.275) 5(8.25,-5.275) 6(8,2.275) 7(7.75,-5.275) 16(5.5,2.275) 17(5.25,-5.275) 18(5,2.275) 19(4.75,-5.275) 20(4.5,2.275) 21(4.25,-5.275) 22(4,2.275) 23(3.75,-5.275) 24(3.5,2.275) 25(3.25,-5.275) 26(3,2.275) 27(2.75,-5.275) 28(2.5,2.275) 29(2.25,-5.275) 30(2,2.275) 31(1.75,-5.275) 32(1.5,2.275) 33(1.25,-5.275) 34(1,2.275) 35(0.75,-5.275) 36(0.5,2.275) 37(0.25,-5.275) 38(0,2.275) 39(-0.25,-5.275) 40(-0.5,2.275) 41(-0.75,-5.275) 42(-1,2.275) 43(-1.25,-5.275) 44(-1.5,2.275) 45(-1.75,-5.275) 46(-2,2.275) 47(-2.25,-5.275) 48(-2.5,2.275) 49(-2.75,-5.275) 50(-3,2.275) 51(-3.25,-5.275) 52(-3.5,2.275) 53(-3.75,-5.275) 54(-4,2.275) 55(-4.25,-5.275) 56(-4.5,2.275) 57(-4.75,-5.275) 58(-5,2.275) 59(-5.25,-5.275) 60(-5.5,2.275) 61(-5.75,-5.275) 62(-6,2.275) 63(-6.25,-5.275) 64(-6.5,2.275) 65(-6.75,-5.275) 66(-7,2.275) 67(-7.25,-5.275) 68(-7.5,2.275) 69(-7.75,-5.275) 70(-8,2.275) 71(-8.25,-5.275) 72(-8.5,2.275) 73(-8.75,-5.275) 74(-9,2.275) 75(-9.25,-5.275)
  rect 1.194x2.743 smd: 76(10.35,-4.5) 77(-10.35,-4.5)
NTC-402H22-U
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
NTC-402H24-U
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
OSC-3225-4P-4H36
  rect 1.397x1.067 smd: 1(-1.171,-0.756) 2(1.171,-0.756) 3(1.171,0.756) 4(-1.171,0.756)
POLYSW-2114H30
  rect 1.6x0.965 smd: 1(0,0.94) 2(0,-0.94)
POLYSW-4633-UH43
  rect 3.505x1.626 smd: 1(0,1.834) 2(0,-1.834)
PPAK-8P-3232H36
  rect 0.406x0.914 smd: 1(-0.975,-2.396) 2(-0.325,-2.396) 3(0.325,-2.396) 4(0.975,-2.396)
  rect 3.353x2.692 smd: 5(0,0)
  rect 0.025x0.025 smd: 6(0.65,0.838) 7(0,0.838) 8(-0.65,0.838)
PPAK-8P-G5324H44-COLAY
  rect 0.762x1.016 smd: 1(-1.905,-3.01) 2(-0.635,-3.01) 3(0.635,-3.01) 4(1.905,-3.01) 5(1.905,3.01) 6(0.635,3.01) 7(-0.635,3.01) 8(-1.905,3.01)
  rect 5.207x2.896 smd: 9(0,0.65)
  rect 5.207x0.787 smd: 10(0,-1.7)
QFN16-G1D8-UH32
  rect 0.305x0.914 smd: 1(0.75,1.551) 2(0.25,1.551) 3(-0.25,1.551) 4(-0.75,1.551) 9(-0.75,-1.551) 10(-0.25,-1.551) 11(0.25,-1.551) 12(0.75,-1.551)
  rect 0.914x0.305 smd: 5(-1.551,0.75) 6(-1.551,0.25) 7(-1.551,-0.25) 8(-1.551,-0.75) 13(1.551,-0.75) 14(1.551,-0.25) 15(1.551,0.25) 16(1.551,0.75)
  rect 1.778x1.778 smd: 17(0,0)
QFN20-G1D75H32
  rect 0.203x0.914 smd: 1(0.8,1.551) 2(0.4,1.551) 3(0,1.551) 4(-0.4,1.551) 5(-0.8,1.551) 11(-0.8,-1.551) 12(-0.4,-1.551) 13(0,-1.551) 14(0.4,-1.551) 15(0.8,-1.551)
  rect 0.914x0.203 smd: 6(-1.551,0.8) 7(-1.551,0.4) 8(-1.551,0) 9(-1.551,-0.4) 10(-1.551,-0.8) 16(1.551,-0.8) 17(1.551,-0.4) 18(1.551,0) 19(1.551,0.4) 20(1.551,0.8)
  rect 1.753x1.753 smd: 21(0,0)
QFN20-G2D25H32
  rect 0.305x1.168 smd: 1(1,1.924) 2(0.5,1.924) 3(0,1.924) 4(-0.5,1.924) 5(-1,1.924) 11(-1,-1.924) 12(-0.5,-1.924) 13(0,-1.924) 14(0.5,-1.924) 15(1,-1.924)
  rect 1.168x0.305 smd: 6(-1.924,1) 7(-1.924,0.5) 8(-1.924,0) 9(-1.924,-0.5) 10(-1.924,-1) 16(1.924,-1) 17(1.924,-0.5) 18(1.924,0) 19(1.924,0.5) 20(1.924,1)
  rect 2.261x2.261 smd: 21(0,0)
QFN20-G2D75-UH32
  rect 0.305x0.94 smd: 1(0.999,2.045) 2(0.5,2.045) 3(0,2.045) 4(-0.5,2.045) 5(-0.999,2.045) 11(-0.999,-2.045) 12(-0.5,-2.045) 13(0,-2.045) 14(0.5,-2.045) 15(0.999,-2.045)
  rect 0.94x0.305 smd: 6(-2.045,0.999) 7(-2.045,0.5) 8(-2.045,0) 9(-2.045,-0.5) 10(-2.045,-0.999) 16(2.045,-0.999) 17(2.045,-0.5) 18(2.045,0) 19(2.045,0.5) 20(2.045,0.999)
  rect 2.743x2.743 smd: 21(0,0)
QFN20Z3-G1D1H36
  custom 0.064x0.064 smd: 1(0.9,1.424) 5(-0.9,1.424) 6(-1.424,0.9) 10(-1.424,-0.9) 11(-0.9,-1.424) 15(0.9,-1.424) 16(1.424,-0.9) 20(1.424,0.9)
  rect 0.254x1.168 smd: 2(0.45,1.424) 3(0,1.424) 4(-0.45,1.424) 12(-0.45,-1.424) 13(0,-1.424) 14(0.45,-1.424)
  rect 1.168x0.254 smd: 7(-1.424,0.45) 8(-1.424,0) 9(-1.424,-0.45) 17(1.424,-0.45) 18(1.424,0) 19(1.424,0.45)
  rect 1.092x1.092 smd: 21(0,0)
QFN22G4-G2PH42
  rect 0.305x0.914 smd: 1(1.25,2.051) 2(0.75,2.051) 3(0.25,2.051) 4(-0.25,2.051) 5(-0.75,2.051) 6(-1.25,2.051) 16(0.75,-2.051) 17(1.25,-2.051)
  custom 0.326x0.326 smd: 7(-2.051,1.25)
  rect 0.025x0.025 smd: 8(-2.051,0.75) 9(-2.051,0.25) 10(-2.051,-0.75) 13(-0.75,-2.051) 14(-0.25,-2.051) 15(0.25,-2.051)
  custom 0.232x0.232 smd: 11(-2.051,-1.25)
  custom 0.229x0.229 smd: 12(-1.25,-2.051)
  rect 0.914x0.305 smd: 18(2.051,-1.25) 19(2.051,-0.75) 20(2.051,-0.25) 21(2.051,0.25) 22(2.051,1.25)
QFN28-G2D7H32
  rect 0.203x0.94 smd: 1(1.2,2.032) 2(0.8,2.032) 3(0.4,2.032) 4(0,2.032) 5(-0.4,2.032) 6(-0.8,2.032) 7(-1.2,2.032) 15(-1.2,-2.032) 16(-0.8,-2.032) 17(-0.4,-2.032) 18(0,-2.032) 19(0.4,-2.032) 20(0.8,-2.032) 21(1.2,-2.032)
  rect 0.94x0.203 smd: 8(-2.032,1.2) 9(-2.032,0.8) 10(-2.032,0.4) 11(-2.032,0) 12(-2.032,-0.4) 13(-2.032,-0.8) 14(-2.032,-1.2) 22(2.032,-1.2) 23(2.032,-0.8) 24(2.032,-0.4) 25(2.032,0) 26(2.032,0.4) 27(2.032,0.8) 28(2.032,1.2)
  rect 2.692x2.692 smd: 29(0,0)
QFN32G5-G3D6H32
  rect 0.305x0.914 smd: 1(1.75,2.551) 8(-1.75,2.551) 17(-1.75,-2.551) 24(1.75,-2.551)
  rect 0.305x0.991 smd: 2(1.25,2.513) 3(0.75,2.513) 4(0.25,2.513) 5(-0.25,2.513) 6(-0.75,2.513) 7(-1.25,2.513) 18(-1.25,-2.513) 19(-0.75,-2.513) 20(-0.25,-2.513) 21(0.25,-2.513) 22(0.75,-2.513) 23(1.25,-2.513)
  rect 0.914x0.305 smd: 9(-2.551,1.75) 16(-2.551,-1.75) 25(2.551,-1.75) 32(2.551,1.75)
  rect 0.991x0.305 smd: 10(-2.513,1.25) 11(-2.513,0.75) 12(-2.513,0.25) 13(-2.513,-0.25) 14(-2.513,-0.75) 15(-2.513,-1.25) 26(2.513,-1.25) 27(2.513,-0.75) 28(2.513,-0.25) 29(2.513,0.25) 30(2.513,0.75) 31(2.513,1.25)
  rect 3.607x3.607 smd: 33(0,0)
QFN32J4-G2D85H36
  rect 0.203x0.864 smd: 1(1.4,2.085) 2(1,2.085) 3(0.6,2.085) 4(0.2,2.085) 5(-0.2,2.085) 6(-0.6,2.085) 7(-1,2.085) 8(-1.4,2.085) 17(-1.4,-2.085) 18(-1,-2.085) 19(-0.6,-2.085) 20(-0.2,-2.085) 21(0.2,-2.085) 22(0.6,-2.085) 23(1,-2.085) 24(1.4,-2.085)
  rect 0.864x0.203 smd: 9(-2.085,1.4) 10(-2.085,1) 11(-2.085,0.6) 12(-2.085,0.2) 13(-2.085,-0.2) 14(-2.085,-0.6) 15(-2.085,-1) 16(-2.085,-1.4) 25(2.085,-1.4) 26(2.085,-1) 27(2.085,-0.6) 28(2.085,-0.2) 29(2.085,0.2) 30(2.085,0.6) 31(2.085,1) 32(2.085,1.4)
  rect 2.845x2.845 smd: 33(0,0)
QFN36J4060-G2554H48
  rect 0.203x0.559 smd: 1(1,2.873) 2(0.6,2.873) 3(0.2,2.873) 4(-0.2,2.873) 5(-0.6,2.873) 6(-1,2.873)
  rect 0.61x0.203 smd: 7(-1.848,2.2) 8(-1.848,1.8) 9(-1.848,1.4) 10(-1.848,1) 25(1.848,-2.2) 26(1.848,-1.8) 27(1.848,-1.4) 28(1.848,-1) 29(1.848,-0.6) 30(1.848,-0.2) 31(1.848,0.2) 32(1.848,0.6) 33(1.848,1) 34(1.848,1.4) 35(1.848,1.8) 36(1.848,2.2)
  rect 0.559x0.203 smd: 11(-1.848,0.6) 12(-1.848,0.2) 13(-1.848,-0.2) 14(-1.848,-0.6) 15(-1.848,-1) 16(-1.848,-1.4) 17(-1.848,-1.8) 18(-1.848,-2.2)
  rect 0.025x0.025 smd: 19(-1,-2.848) 20(-0.6,-2.848) 21(-0.2,-2.848) 22(0.2,-2.848) 23(0.6,-2.848) 24(1,-2.848)
  custom 0.665x0.665 smd: 37(0,0)
QFN40-G3D5H32
  rect 0.203x0.914 smd: 1(1.8,2.553) 10(-1.8,2.553) 21(-1.8,-2.553) 30(1.8,-2.553)
  rect 0.203x0.965 smd: 2(1.4,2.527) 3(1,2.527) 4(0.6,2.527) 5(0.2,2.527) 6(-0.2,2.527) 7(-0.6,2.527) 8(-1,2.527) 9(-1.4,2.527) 22(-1.4,-2.527) 23(-1,-2.527) 24(-0.6,-2.527) 25(-0.2,-2.527) 26(0.2,-2.527) 27(0.6,-2.527) 28(1,-2.527) 29(1.4,-2.527)
  rect 0.914x0.203 smd: 11(-2.553,1.8) 20(-2.553,-1.8) 31(2.553,-1.8) 40(2.553,1.8)
  rect 0.965x0.203 smd: 12(-2.527,1.4) 13(-2.527,1) 14(-2.527,0.6) 15(-2.527,0.2) 16(-2.527,-0.2) 17(-2.527,-0.6) 18(-2.527,-1) 19(-2.527,-1.4) 32(2.527,-1.4) 33(2.527,-1) 34(2.527,-0.6) 35(2.527,-0.2) 36(2.527,0.2) 37(2.527,0.6) 38(2.527,1) 39(2.527,1.4)
  rect 3.505x3.505 smd: 41(0,0)
QFN48J6-G465H40
  rect 0.203x0.965 smd: 1(2.2,3.025) 2(1.8,3.025) 3(1.4,3.025) 4(1,3.025) 5(0.6,3.025) 6(0.2,3.025) 7(-0.2,3.025) 8(-0.6,3.025) 9(-1,3.025) 10(-1.4,3.025) 11(-1.8,3.025) 12(-2.2,3.025) 25(-2.2,-3.025) 26(-1.8,-3.025) 27(-1.4,-3.025) 28(-1,-3.025) 29(-0.6,-3.025) 30(-0.2,-3.025) 31(0.2,-3.025) 32(0.6,-3.025) 33(1,-3.025) 34(1.4,-3.025) 35(1.8,-3.025) 36(2.2,-3.025)
  rect 0.965x0.203 smd: 13(-3.025,2.2) 14(-3.025,1.8) 15(-3.025,1.4) 16(-3.025,1) 17(-3.025,0.6) 18(-3.025,0.2) 19(-3.025,-0.2) 20(-3.025,-0.6) 21(-3.025,-1) 22(-3.025,-1.4) 23(-3.025,-1.8) 24(-3.025,-2.2) 37(3.025,-2.2) 38(3.025,-1.8) 39(3.025,-1.4) 40(3.025,-1) 41(3.025,-0.6) 42(3.025,-0.2) 43(3.025,0.2) 44(3.025,0.6) 45(3.025,1) 46(3.025,1.4) 47(3.025,1.8) 48(3.025,2.2)
  rect 4.648x4.648 smd: 49(0,0)
QSH-030-01-FDAK
  round 0.254 hole 1.016 unplated: (-10.066,2.67) (10.066,2.67)
  rect 0.305x2.515 smd: 1(-7.25,-2.99) 2(-7.25,2.99) 3(-6.75,-2.99) 4(-6.75,2.99) 5(-6.25,-2.99) 6(-6.25,2.99) 7(-5.751,-2.99) 8(-5.751,2.99) 9(-5.25,-2.99) 10(-5.25,2.99) 11(-4.75,-2.99) 12(-4.75,2.99) 13(-4.249,-2.99) 14(-4.249,2.99) 15(-3.75,-2.99) 16(-3.75,2.99) 17(-3.25,-2.99) 18(-3.25,2.99) 19(-2.75,-2.99) 20(-2.75,2.99) 21(-2.25,-2.99) 22(-2.25,2.99) 23(-1.75,-2.99) 24(-1.75,2.99) 25(-1.25,-2.99) 26(-1.25,2.99) 27(-0.751,-2.99) 28(-0.751,2.99) 29(-0.25,-2.99) 30(-0.25,2.99) 31(0.25,-2.99) 32(0.25,2.99) 33(0.751,-2.99) 34(0.751,2.99) 35(1.25,-2.99) 36(1.25,2.99) 37(1.75,-2.99) 38(1.75,2.99) 39(2.25,-2.99) 40(2.25,2.99) 41(2.75,-2.99) 42(2.75,2.99) 43(3.25,-2.99) 44(3.25,2.99) 45(3.75,-2.99) 46(3.75,2.99) 47(4.249,-2.99) 48(4.249,2.99) 49(4.75,-2.99) 50(4.75,2.99) 51(5.25,-2.99) 52(5.25,2.99) 53(5.751,-2.99) 54(5.751,2.99) 55(6.25,-2.99) 56(6.25,2.99) 57(6.75,-2.99) 58(6.75,2.99) 59(7.25,-2.99) 60(7.25,2.99)
  rect 2.54x0.432 smd: 61(-8.065,0) 64(8.065,0)
  rect 4.699x0.432 smd: 62(-3.175,0) 63(3.175,0)
R402H14
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H15
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R402H16
  custom 0.14x0.14 smd: 1(0,0.445) 2(0,-0.445)
R603H22
  custom 0.197x0.197 smd: 1(0,0.66) 2(0,-0.66)
R805H24
  rect 1.549x0.94 smd: 1(0,0.838) 2(0,-0.838)
R1206H28
  rect 1.854x1.27 smd: 1(0,1.397) 2(0,-1.397)
R3720H40
  rect 4.013x1.041 smd: 1(0,0.867) 2(0,-0.867)
SC70-2D2-312H44
  custom 0.152x0.152 smd: 1(-0.65,-0.902) 2(0.65,-0.902) 3(0,0.902)
SC70-5-1H44
  rect 0.356x1.219 smd: 1(-0.65,-0.922) 2(0,-0.922) 3(0.65,-0.922) 4(0.65,0.921) 5(-0.65,0.921)
SC70-5H44
  rect 0.406x1.219 smd: 1(0.65,0.826) 2(0,0.826) 3(-0.65,0.826) 4(-0.65,-0.826) 5(0.65,-0.826)
SF58S006VBBR2000-U
  rect 0.813x0.991 smd: 1(-3.775,-9.165) 2(-1.575,-9.165) 3(0.625,-9.165) 5(-2.675,-9.165) 6(-0.475,-9.165) 7(1.725,-9.165)
  rect 0.889x0.94 smd: DSW1(3.81,-0.325)
  rect 0.813x0.94 smd: DSW2(5.15,-0.325)
  rect 0.889x1.295 smd: GND1(-6.875,-15.85)
  rect 0.533x2.591 smd: GND2(-8.135,-12.6)
  rect 0.508x1.905 smd: GND3(-8.15,-6.55) GND4(-8.15,-2.63)
  custom 0.193x0.193 smd: GND5(-6.792,-0.235)
  rect 2.108x0.406 smd: GND6(-3.38,-0.05) GND7(0.32,-0.05)
  rect 0.838x1.905 smd: GND8(6.975,-0.8)
  rect 0.864x2.007 smd: GND9(6.97,-8.28)
  rect 0.813x2.489 smd: GND10(7,-15.25)
SKT-HDMI23-188137
  oval 0.787x0.94 hole 0.533: 1(-4.5,5.75) 2(-4,7.25) 3(-3.5,5.75) 4(-3,7.25) 5(-2.5,5.75) 6(-2,7.25) 7(-1.5,5.75) 8(-1,7.25) 9(-0.5,5.75) 10(0,7.25) 11(0.5,5.75) 12(1,7.25) 13(1.5,5.75) 14(2,7.25) 15(2.5,5.75) 16(3,7.25) 17(3.5,5.75) 18(4,7.25) 19(4.5,5.75)
  oval 1.626x2.515 hole 0.914x1.803: 20(-7.25,6.5) 21(7.25,6.5) 22(-9.15,0) 23(9.15,0)
SKT-USB13-160166-2
  round 1.067 hole 0.711: 1(3.5,9.2) 2(1,9.2) 3(-1,9.2) 4(-3.5,9.2) 5(-4,7.7) 6(-2,7.7) 7(0,7.7) 8(2,7.7) 9(4,7.7)
  oval 1.422x2.997 hole 0.711x2.286: 10(6.4,8.45) 11(-6.4,8.45)
  oval 1.626x2.235 hole 0.914x1.524: 12(7.85,0) 13(-7.85,0)
SLP2510P8-1H24
  rect 0.305x0.762 smd: 1(-1,-0.5) 5(1,-0.5) 6(1,0.5) 10(-1,0.5)
  rect 0.203x0.762 smd: 2(-0.5,-0.5) 4(0.5,-0.5) 7(0.5,0.5) 9(-0.5,0.5)
  rect 0.406x0.762 smd: 3(0,-0.5) 8(0,0.5)
SMD49-12H36
  rect 1.753x1.397 smd: 1(0,1.295) 2(0,-1.295)
SMD-ARES4
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SMD-ARES4H18
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SMD-ARES4H20
  rect 0.356x0.66 smd: 1(-0.325,-0.599) 2(0.325,-0.599) 3(0.325,0.599) 4(-0.325,0.599)
SMD-OSC38H20
  rect 1.092x0.737 smd: 1(-0.769,-0.495) 2(0.769,-0.495) 3(0.769,0.495) 4(-0.769,0.495)
SOD123FLAKH40
  rect 1.143x1.651 smd: A(0,1.622) K(0,-1.622)
SOD323-2513AKH36
  rect 0.559x1.168 smd: A(0,1.05) K(0,-1.05)
SOD323AKH38
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD323AKH42
  rect 0.559x1.016 smd: A(0,1.143) K(0,-1.143)
SOD882-10D6-1H20
  custom 0.114x0.114 smd: 1(0,0.445) 2(0,-0.445)
SOIC8-1H86
  rect 0.635x1.651 smd: 1(-1.905,-3.493) 2(-0.635,-3.493) 3(0.635,-3.493) 4(1.905,-3.493) 5(1.905,3.493) 6(0.635,3.493) 7(-0.635,3.493) 8(-1.905,3.493)
SOIC8-G2D3H70
  rect 0.635x1.651 smd: 1(-1.905,-2.553) 2(-0.635,-2.553) 3(0.635,-2.553) 4(1.905,-2.553) 5(1.905,2.553) 6(0.635,2.553) 7(-0.635,2.553) 8(-1.905,2.553)
  rect 2.311x2.311 smd: 9(0,0)
SOIC8H69
  rect 0.635x1.651 smd: 1(-1.905,-2.54) 2(-0.635,-2.54) 3(0.635,-2.54) 4(1.905,-2.54) 5(1.905,2.54) 6(0.635,2.54) 7(-0.635,2.54) 8(-1.905,2.54)
SOT23-2D4-312H44
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D4-312H46
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D4-312H48
  custom 0.191x0.191 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT23-2D8-123H52
  custom 0.254x0.254 smd: 1(0,1.118) 2(-1.016,-1.118) 3(1.016,-1.118)
SOT23CBE2D4H44
  custom 0.191x0.191 smd: B(-0.984,-0.953) C(0,0.953) E(0.984,-0.953)
SOT23DGS2D4H44
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D4H48
  custom 0.191x0.191 smd: D(0,0.953) G(-0.984,-0.953) S(0.984,-0.953)
SOT23DGS2D8H50
  custom 0.254x0.254 smd: D(0,1.118) G(-1.016,-1.118) S(1.016,-1.118)
SOT323CBE2D2H40
  custom 0.152x0.152 smd: B(-0.65,-0.902) C(0,0.902) E(0.65,-0.902)
SOT-6-1H50
  rect 0.584x1.219 smd: 1(-0.95,-1.194) 2(0,-1.194) 3(0.95,-1.194) 4(0.95,1.194) 5(0,1.194) 6(-0.95,1.194)
SOT-6-1H58
  rect 0.584x1.219 smd: 1(-0.95,-1.194) 2(0,-1.194) 3(0.95,-1.194) 4(0.95,1.194) 5(0,1.194) 6(-0.95,1.194)
SOT-6H44
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-6H58
  rect 0.584x1.016 smd: 1(-0.953,-1.346) 2(0,-1.346) 3(0.953,-1.346) 4(0.953,1.346) 5(0,1.346) 6(-0.953,1.346)
SOT-23-5H51
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-5H56
  rect 0.508x1.524 smd: 1(-0.95,-1.143) 2(0,-1.143) 3(0.95,-1.143) 4(0.95,1.143) 5(-0.95,1.143)
SOT-23-9H44
  custom 0.178x0.178 smd: 1(-0.95,-0.999) 2(0.95,-0.999) 3(0,0.999)
SOT-23-10H44
  rect 0.762x1.143 smd: 1(-0.984,-0.953) 2(0.984,-0.953) 3(0,0.953)
SOT-363H44
  rect 0.406x1.016 smd: 1(-0.65,-0.94) 2(0,-0.94) 3(0.65,-0.94) 4(0.65,0.94) 5(0,0.94) 6(-0.65,0.94)
SPR4527H308
  rect 8.992x3.404 smd: 1(-2.248,0)
SPR5230H134
  rect 4.902x2.692 smd: 1(-1.499,0)
STF236R128H93
  round 5.994 hole 3.251: 1(0,0)
STF236R128H101
  round 5.994 hole 3.251: 1(0,0)
STF237R128H44
  round 6.02 hole 3.251: 1(0,0)
STF237R128H128
  round 6.02 hole 3.251: 1(0,0)
TF31-16S-0D5SH-800
  rect 0.305x1.295 smd: 1(-3.75,3.25) 2(-3.25,3.25) 3(-2.75,3.25) 4(-2.25,3.25) 5(-1.75,3.25) 6(-1.25,3.25) 7(-0.75,3.25) 8(-0.25,3.25) 9(0.25,3.25) 10(0.75,3.25) 11(1.25,3.25) 12(1.75,3.25) 13(2.25,3.25) 14(2.75,3.25) 15(3.25,3.25) 16(3.75,3.25)
  rect 1.905x2.21 smd: 17(-5.7,0) 18(5.7,0)
TJE-533-S-V-T-R-744
  rect 0.61x0.991 smd: 1(-1.845,2.205) 2(-1.845,-2.205) 3(1.845,2.205) 4(1.845,-2.205)
  rect 0.457x1.397 smd: 5(-2.521,0) 6(2.521,0)
TPAD14-OP
  round 0.356 smd: 1(0,0)
TQFP128-2H48
  rect 0.203x1.524 smd: 1(6.2,7.747) 2(5.8,7.747) 3(5.4,7.747) 4(5,7.747) 5(4.6,7.747) 6(4.2,7.747) 7(3.8,7.747) 8(3.4,7.747) 9(3,7.747) 10(2.6,7.747) 11(2.2,7.747) 12(1.8,7.747) 13(1.4,7.747) 14(0.999,7.747) 15(0.599,7.747) 16(0.199,7.747) 17(-0.199,7.747) 18(-0.599,7.747) 19(-0.999,7.747) 20(-1.4,7.747) 21(-1.8,7.747) 22(-2.2,7.747) 23(-2.6,7.747) 24(-3,7.747) 25(-3.4,7.747) 26(-3.8,7.747) 27(-4.2,7.747) 28(-4.6,7.747) 29(-5,7.747) 30(-5.4,7.747) 31(-5.8,7.747) 32(-6.2,7.747) 65(-6.2,-7.747) 66(-5.8,-7.747) 67(-5.4,-7.747) 68(-5,-7.747) 69(-4.6,-7.747) 70(-4.2,-7.747) 71(-3.8,-7.747) 72(-3.4,-7.747) 73(-3,-7.747) 74(-2.6,-7.747) 75(-2.2,-7.747) 76(-1.8,-7.747) 77(-1.4,-7.747) 78(-0.999,-7.747) 79(-0.599,-7.747) 80(-0.199,-7.747) 81(0.199,-7.747) 82(0.599,-7.747) 83(0.999,-7.747) 84(1.4,-7.747) 85(1.8,-7.747) 86(2.2,-7.747) 87(2.6,-7.747) 88(3,-7.747) 89(3.4,-7.747) 90(3.8,-7.747) 91(4.2,-7.747) 92(4.6,-7.747) 93(5,-7.747) 94(5.4,-7.747) 95(5.8,-7.747) 96(6.2,-7.747)
  rect 1.524x0.203 smd: 33(-7.747,6.2) 34(-7.747,5.8) 35(-7.747,5.4) 36(-7.747,5) 37(-7.747,4.6) 38(-7.747,4.2) 39(-7.747,3.8) 40(-7.747,3.4) 41(-7.747,3) 42(-7.747,2.6) 43(-7.747,2.2) 44(-7.747,1.8) 45(-7.747,1.4) 46(-7.747,0.999) 47(-7.747,0.599) 48(-7.747,0.199) 49(-7.747,-0.199) 50(-7.747,-0.599) 51(-7.747,-0.999) 52(-7.747,-1.4) 53(-7.747,-1.8) 54(-7.747,-2.2) 55(-7.747,-2.6) 56(-7.747,-3) 57(-7.747,-3.4) 58(-7.747,-3.8) 59(-7.747,-4.2) 60(-7.747,-4.6) 61(-7.747,-5) 62(-7.747,-5.4) 63(-7.747,-5.8) 64(-7.747,-6.2) 97(7.747,-6.2) 98(7.747,-5.8) 99(7.747,-5.4) 100(7.747,-5) 101(7.747,-4.6) 102(7.747,-4.2) 103(7.747,-3.8) 104(7.747,-3.4) 105(7.747,-3) 106(7.747,-2.6) 107(7.747,-2.2) 108(7.747,-1.8) 109(7.747,-1.4) 110(7.747,-0.999) 111(7.747,-0.599) 112(7.747,-0.199) 113(7.747,0.199) 114(7.747,0.599) 115(7.747,0.999) 116(7.747,1.4) 117(7.747,1.8) 118(7.747,2.2) 119(7.747,2.6) 120(7.747,3) 121(7.747,3.4) 122(7.747,3.8) 123(7.747,4.2) 124(7.747,4.6) 125(7.747,5) 126(7.747,5.4) 127(7.747,5.8) 128(7.747,6.2)
TSOIC8H44
  rect 0.356x1.524 smd: 1(-0.975,-2.819) 2(-0.325,-2.819) 3(0.325,-2.819) 4(0.974,-2.819) 5(0.975,2.819) 6(0.325,2.819) 7(-0.325,2.819) 8(-0.975,2.819)
unnamed
  round 0.254 hole 3.023 unplated: (0,0)
XFORM24C1510H168
  rect 0.61x2.642 smd: 1(-5.5,-4.314) 2(-4.5,-4.314) 3(-3.5,-4.314) 4(-2.5,-4.314) 5(-1.5,-4.314) 6(-0.5,-4.314) 7(0.5,-4.314) 8(1.5,-4.314) 9(2.5,-4.314) 10(3.5,-4.314) 11(4.5,-4.314) 12(5.5,-4.314) 13(5.5,4.314) 14(4.5,4.314) 15(3.5,4.314) 16(2.5,4.314) 17(1.5,4.314) 18(0.5,4.314) 19(-0.5,4.314) 20(-1.5,4.314) 21(-2.5,4.314) 22(-3.5,4.314) 23(-4.5,4.314) 24(-5.5,4.314)

## Nets
1.8V_RUN_FB: PC5410.2 PR5410.2 PR5411.1 PU5401.7
3.3V_ALW_1: PC8601.2 PC8603.2 PQ8604.5 PQ8604.6 PQ8609.G PR8606.2 PR8619.2
3.3V_RUN_VGA_1: D8601.3 D8602.3 PQ8604.3 PR8609.1
3.3V_WLAN_EN: Q6101.2 R6101.1 R6104.2
3.3V_WLAN_ENABLE: C6113.1 Q6101.3 R6103.2 U6101.3
3.3V_WLAN_ENABLE#: Q6101.5 Q6101.6 R6102.2
3.3V_WWAN_ENABLE: C6206.1 Q6201.3 R6220.2 U6201.3
3.3V_WWAN_ENABLE#: Q6201.5 Q6201.6 R6211.2
3V5V_CT1: C4001.1 U4001.12
3V5V_CT2: C4002.1 U4001.10
3V5V_S0_ON: R4010.2 U4001.3 U4001.5
3V_5V_EN: C4009.1 D4001.A PR4502.1 PR4507.2 R4006.1 R4009.1
3V_5V_POK: EC1705.1 EC1711.1 PR4508.2 PR5308.1 PR5412.1 PU4501.7 R1718.2 R1728.2 R4033.1
3V_5V_POK#: Q1701.5 Q1701.6 R1726.1
3V_5V_POK_C: Q1701.2 R1727.2 R1728.1 R1729.1
5V_AUX_S5: PC4511.1 PU4501.13
5V_HDD_S0: AFTP5601.1 C6007.1 C6008.1 C6009.1 FC6004.1 HDD1.13 HDD1.14 HDD1.15 HDD1.16 R6006.2
5V_HDMI_S0: C5702.1 D5702.2 EC5701.1 EC5702.1 HDMI1.18
5V_S0: C2605.1 C2611.1 C4005.1 C5710.1 C6001.1 C6002.1 D5701.3 D5702.3 EC9203.1 EC9718.1 EC9719.1 EC9720.1 EC9721.1 EC9722.1 ED9201.5 FAN261.2 FC6001.1 FC6003.1 FC9712.1 FC9714.1 FC9715.1 FC9716.1 IOBD4.1 Q5701.G R2702.1 R2703.2 R2704.1 R5527.2 R5710.1 R6006.1 R6504.1 R6512.2 R6705.1 R9202.2 U4001.13 U4001.14
5V_S5: C3402.1 C3406.1 C3504.1 C3511.1 C4033.1 C4034.1 DB2.1 EC9732.1 EC9733.1 EC9734.1 FC5301.1 FC5401.1 PC4707.1 PC4807.1 PC5001.1 PC5302.1 PC5406.1 PC5407.1 PC8508.1 PG4516.2 PG4517.2 PG4518.2 PG4519.2 PG4520.2 PG4521.2 PG4523.2 PR4303.1 PR4603.1 PR4657.1 PR4702.2 PR4803.2 PR5118.2 PR5307.1 PR8510.1 PU4701.7 PU4701.36 PU4801.3 PU4801.7 PU4801.36 PU5001.4 PU5301.21 PU5401.4 PU5402.4 PU8501.26 PU8501.31 Q6403.E Q6404.E Q6405.E Q6502.E R3405.1 R9201.1 U3401.1 U3401.7 U3401.8 U3502.5 U3503.5 U4001.1 U4001.2 U4001.4 U4002.3 U4006.3
+3V_1D8V_AVDD: C2715.1 C2721.1 HDA27.40 R2713.2
+3V_AVDD: C2716.1 C2717.1 C2719.1 HDA27.1 HDA27.9 R2722.1 R2724.1 R2731.2
+3VLP: KBC24.120 R2454.1 R2467.2
+5V_AVDD: C2710.1 C2711.1 HDA27.26 R2703.1
+5V_KB_BL: AFTP6248.1 C6501.1 KBLIT1.1 R6504.2
+5V_PVDD: C2706.1 C2707.1 C2708.1 C2709.1 HDA27.41 HDA27.46 R2702.2 R2704.2
+V1.00A_SIP: C2101.1 C2104.1 C2116.1 C2124.1 CPU1.A10 CPU1.A14 CPU1.AB17 CPU1.AB19 CPU1.AB20 CPU1.AK20 CPU1.K17 CPU1.L1 CPU1.L21 CPU1.P18 CPU1.T1 CPU1.Y18 R1118.2 R1803.2 R2107.1 R2108.1 R2109.1 R2111.1
+V1.00A_XDP: C9902.1 C9904.1 R9927.2 R9932.1
+V1.00U_CPU: C720.1 C721.1 C4012.1 CPU1.K20 CPU1.K21 FC708.1 R2492.1 R4025.2 R4036.1
+V1.00U_CPU_LS: R4025.1 U4006.6 U4006.7 U4006.8
+V1.8A_SIP: C1122.1 C2108.1 CPU1.AA1 CPU1.AF16 R1139.2
+V3.3A_SIP: C1113.1 C1123.1 C1183.1 C2105.1 C2106.1 C2107.1 C2109.1 C2110.1 C2111.1 CPU1.AD15 CPU1.AG15 CPU1.AJ16 CPU1.AJ21 CPU1.AK15 CPU1.AK17 CPU1.T16 CPU1.V19 CPU1.Y15 CPU1.Y16 R1112.2 R1701.1 R1731.1 R2101.1
+VCCAMPHYPLL_1P0: C2122.1 CPU1.K15 CPU1.L15 R2110.2
+VCCAMPHYPLL_1P0_L: C1172.1 C1181.1 R1102.2 R2110.1
+VCCAPLL_1P0: C2123.1 CPU1.V15 R2111.2
+VCCAPLLEBB_1P0: C1173.1 C1180.1 CPU1.N18 R1101.2
+VCCCLK2: C2113.1 CPU1.K19 R2109.2
+VCCCLK4: C2114.1 CPU1.N20 R2108.2
+VCCCLK5: C2115.1 CPU1.L19 R2107.2
+VCCDSW_1P0: C2103.1 CPU1.AL1
+VCCFUSEPRG: CPU1.G20 R703.1
+VCCGT: C1136.1 C1138.1 C1147.1 C1148.1 C1149.1 C1150.1 CPU1.A48 CPU1.A53 CPU1.A58 CPU1.A62 CPU1.A66 CPU1.AA63 CPU1.AA64 CPU1.AA66 CPU1.AA67 CPU1.AA69 CPU1.AA70 CPU1.AA71 CPU1.AC64 CPU1.AC65 CPU1.AC66 CPU1.AC67 CPU1.AC68 CPU1.AC69 CPU1.AC70 CPU1.AC71 CPU1.J43 CPU1.J45 CPU1.J46 CPU1.J48 CPU1.J50 CPU1.J52 CPU1.J53 CPU1.J55 CPU1.J56 CPU1.J58 CPU1.J60 CPU1.K48 CPU1.K50 CPU1.K52 CPU1.K53 CPU1.K55 CPU1.K56 CPU1.K58 CPU1.K60 CPU1.L62 CPU1.L63 CPU1.L64 CPU1.L65 CPU1.L66 CPU1.L67 CPU1.L68 CPU1.L69 CPU1.L70 CPU1.L71 CPU1.M62 CPU1.N63 CPU1.N64 CPU1.N66 CPU1.N67 CPU1.N69 CPU1.N70 CPU1.N71 CPU1.R63 CPU1.R64 CPU1.R65 CPU1.R66 CPU1.R67 CPU1.R68 CPU1.R69 CPU1.R70 CPU1.R71 CPU1.T62 CPU1.U65 CPU1.U68 CPU1.U71 CPU1.W63 CPU1.W64 CPU1.W65 CPU1.W66 CPU1.W67 CPU1.W68 CPU1.W69 CPU1.W70 CPU1.W71 CPU1.Y62 FC703.1 FC704.1 FC1004.1 PC1031.1 PC1032.1 PC1033.1 PC1034.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1091.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PG4809.2 PL4801.2 PT4801.1 R721.1
+VCCIO: C1151.1 C1152.1 C1153.1 C1154.1 C4007.1 CPU1.AK28 CPU1.AK30 CPU1.AL30 CPU1.AL42 CPU1.AM28 CPU1.AM30 CPU1.AM42 FC706.1 PC1035.1 PC1036.1 PC1037.1 R801.1 R4048.1 U4002.6 U4002.7 U4002.8
+VCCMPHYGTAON_1P0_LS_SIP: C1174.1 C1182.1 C1704.1 CPU1.N15 CPU1.N16 CPU1.N17 CPU1.P15 CPU1.P16 R1101.1 R1102.1 R1106.1 R1724.2 R1735.2
+VCCPAZIO: CPU1.AJ19 R2101.2
+VCCPDSW_3P3: CPU1.AD17 CPU1.AD18 CPU1.AJ17 R1707.1 R1711.2
+VCCPRIM_CORE: C2102.1 C2120.1 C2121.1 CPU1.AF18 CPU1.AF19 CPU1.V20 CPU1.V21 PC1038.1 PC1039.1 R1117.2
+VCCPRTC_3P3: C2117.1 C2118.1 C2119.1 CPU1.AK19 CPU1.BB14 R2106.2
+VCCSA: CPU1.AK23 CPU1.AK25 CPU1.G23 CPU1.G25 CPU1.G27 CPU1.G28 CPU1.J22 CPU1.J23 CPU1.J27 CPU1.K23 CPU1.K25 CPU1.K27 CPU1.K28 CPU1.K30 FC707.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1050.1 PC1051.1 PC1052.1 PC1053.1 PC1054.1 PC1065.1 PC1066.1 PC1067.1 PC1068.1 PC1097.1 PC1098.1 PG5022.2 PL5001.2 R735.1
+VCCSRAM_1P0: C1175.1 C1176.1 CPU1.AF20 CPU1.AF21 CPU1.T19 CPU1.T20 R1106.2
+VCCST_CPU: C716.1 CPU1.A18 PC4610.1 PR4621.1 PR4622.1 PR4623.1 PR4624.1 R408.2 R409.2 R416.2 R417.2 R419.1 R421.2 R422.2 R423.2 R603.2 R723.1 R726.1 R727.1 R4036.2 R4045.2 R9906.1
+VCCSTG: C717.1 CPU1.A22 PR4669.1 R401.1 R703.2 R1722.1 R2440.1 R4045.1 R4048.2
+VDDQ_CPU_CLK: C715.1 C722.1 CPU1.AM40 R705.2
AV1_TP: CPU1.AV1 TP2307.1
AV71_TP: CPU1.AV71 TP2304.1
DVSS: HDA27.4 R2721.1
GND: AFTP2501.1 AFTP2803.1 AFTP4307.1 AFTP4308.1 AFTP4309.1 AFTP6102.1 AFTP6201.1 AFTP6217.1 AFTP6235.1 AFTP6244.1 AFTP6245.1 AFTP6314.1 AFTP6318.1 BATT1.8 BATT1.9 BATT1.10 C715.2 C716.2 C717.2 C718.2 C719.2 C720.2 C721.2 C722.2 C1101.2 C1102.2 C1103.2 C1113.2 C1116.2 C1117.2 C1122.2 C1123.2 C1136.2 C1138.2 C1147.2 C1148.2 C1149.2 C1150.2 C1151.2 C1152.2 C1153.2 C1154.2 C1172.2 C1173.2 C1174.2 C1175.2 C1176.2 C1180.2 C1181.2 C1182.2 C1183.2 C1202.2 C1203.2 C1204.2 C1205.2 C1206.2 C1207.2 C1208.2 C1209.2 C1210.2 C1211.2 C1212.2 C1213.2 C1214.2 C1215.2 C1216.2 C1217.2 C1218.2 C1219.2 C1221.2 C1223.2 C1224.2 C1225.2 C1226.2 C1227.2 C1228.2 C1229.2 C1230.2 C1231.2 C1232.2 C1301.2 C1303.2 C1304.2 C1305.2 C1306.2 C1307.2 C1308.2 C1309.2 C1310.2 C1311.2 C1312.2 C1313.2 C1314.2 C1315.2 C1316.2 C1317.2 C1318.2 C1319.2 C1320.2 C1321.2 C1322.2 C1324.2 C1325.2 C1326.2 C1327.2 C1328.2 C1329.2 C1330.2 C1331.2 C1701.2 C1704.2 C1801.1 C1802.1 C1803.2 C1804.2 C1805.2 C1806.2 C2101.2 C2102.2 C2103.2 C2104.2 C2105.2 C2106.2 C2107.2 C2108.2 C2109.2 C2110.2 C2111.2 C2112.2 C2113.2 C2114.2 C2115.2 C2116.2 C2117.2 C2118.2 C2119.2 C2120.2 C2121.2 C2122.2 C2123.2 C2124.2 C2401.2 C2402.1 C2403.2 C2405.2 C2406.2 C2410.2 C2411.2 C2412.2 C2413.2 C2414.2 C2417.2 C2418.2 C2420.2 C2423.2 C2424.1 C2425.1 C2426.2 C2428.2 C2429.2 C2501.2 C2502.2 C2503.2 C2504.2 C2505.2 C2506.2 C2507.2 C2601.2 C2602.2 C2604.2 C2605.2 C2608.2 C2609.2 C2610.2 C2611.2 C2619.2 C2620.2 C2621.2 C2622.2 C2701.2 C2704.1 C2706.2 C2707.2 C2708.2 C2709.2 C2714.2 C2716.2 C2717.2 C2718.2 C2719.2 C2724.2 C2725.2 C3101.2 C3102.2 C3103.2 C3105.2 C3106.2 C3107.2 C3109.2 C3110.2 C3111.2 C3112.2 C3113.2 C3114.2 C3115.2 C3116.2 C3117.2 C3118.2 C3119.2 C3120.2 C3121.2 C3201.2 C3401.2 C3402.2 C3403.2 C3404.2 C3405.2 C3406.2 C3504.2 C3509.2 C3511.2 C3514.2 C3515.2 C3516.2 C3517.2 C3518.2 C3519.2 C4001.2 C4002.2 C4004.2 C4005.2 C4007.2 C4009.2 C4012.2 C4013.2 C4014.2 C4016.2 C4033.2 C4034.2 C4101.2 C4102.2 C4103.2 C5501.2 C5502.2 C5503.2 C5504.2 C5505.2 C5506.2 C5507.2 C5509.2 C5515.2 C5516.2 C5535.1 C5536.1 C5538.2 C5539.2 C5540.2 C5541.2 C5542.1 C5621.2 C5622.2 C5623.2 C5702.2 C5710.2 C6001.2 C6002.2 C6007.2 C6008.2 C6009.2 C6010.2 C6011.2 C6012.2 C6013.2 C6014.2 C6107.2 C6108.2 C6109.2 C6110.2 C6111.2 C6112.2 C6113.2 C6201.2 C6202.2 C6203.2 C6206.2 C6501.2 C6502.2 C6504.2 C6701.2 C6702.2 C6703.2 C7001.2 C7002.2 C7609.2 C7710.2 C7711.2 C7713.2 C7714.2 C7715.2 C7801.1 C7802.2 C7805.1 C7901.2 C7903.2 C7904.2 C7918.2 C7919.2 C7920.2 C7921.2 C8001.2 C8002.2 C8003.2 C8004.2 C8005.2 C8006.2 C8007.2 C8008.2 C8009.2 C8010.2 C8011.2 C8012.2 C8013.2 C8014.2 C8015.2 C8016.2 C8017.2 C8018.2 C8019.2 C8020.2 C8021.2 C8022.2 C8023.2 C8024.2 C8025.2 C8026.2 C8027.2 C8028.2 C8029.2 C8030.2 C8031.2 C8032.2 C8033.2 C8034.2 C8035.2 C8036.2 C8037.2 C8038.2 C8039.2 C8040.2 C8041.2 C8042.2 C8043.2 C8044.2 C8045.2 C8046.2 C8047.2 C8048.2 C8049.2 C8050.2 C8051.2 C8052.2 C8053.2 C8054.2 C8055.2 C8056.2 C8057.2 C8058.2 C8059.2 C8060.2 C8061.2 C8062.2 C8063.2 C8064.2 C8065.2 C8066.2 C8129.2 C8130.2 C8131.2 C8132.2 C8133.2 C8134.2 C8135.2 C8136.2 C8137.2 C8138.2 C8139.2 C8140.2 C8141.2 C8142.2 C8143.2 C8144.2 C8145.2 C8146.2 C8147.2 C8148.2 C8149.2 C8150.2 C8151.2 C8152.2 C8153.2 C8154.2 C8155.2 C8156.2 C8157.2 C8158.2 C8201.2 C8202.2 C8203.2 C8204.2 C8205.2 C8206.2 C8207.2 C8208.2 C8209.2 C8210.2 C8211.2 C8212.2 C8213.2 C8214.2 C8215.2 C8216.2 C8217.2 C8218.2 C8219.2 C8220.2 C8221.2 C8222.2 C8223.2 C8224.2 C8225.2 C8226.2 C8227.2 C8228.2 C8229.2 C8230.2 C9101.2 C9102.2 C9103.2 C9104.2 C9105.2 C9106.2 C9107.2 C9108.2 C9109.2 C9110.2 C9111.2 C9112.2 C9113.2 C9114.2 C9115.1 C9116.1 C9117.2 C9201.2 C9202.2 C9601.2 C9603.2 C9901.2 C9902.2 C9903.2 C9904.2 C9905.2 CPU1.AA2 CPU1.AA4 CPU1.AA65 CPU1.AA68 CPU1.AB8 CPU1.AB15 CPU1.AB16 CPU1.AB18 CPU1.AB21 CPU1.AD8 CPU1.AD13 CPU1.AD16 CPU1.AD19 CPU1.AD20 CPU1.AD21 CPU1.AD62 CPU1.AE64 CPU1.AE65 CPU1.AE66 CPU1.AE67 CPU1.AE68 CPU1.AE69 CPU1.AF1 CPU1.AF2 CPU1.AF4 CPU1.AF10 CPU1.AF15 CPU1.AF17 CPU1.AF63 CPU1.AG16 CPU1.AG17 CPU1.AG18 CPU1.AG19 CPU1.AG20 CPU1.AG21 CPU1.AG71 CPU1.AH6 CPU1.AH13 CPU1.AH63 CPU1.AH64 CPU1.AH67 CPU1.AJ4 CPU1.AJ15 CPU1.AJ18 CPU1.AJ20 CPU1.AK8 CPU1.AK11 CPU1.AK16 CPU1.AK18 CPU1.AK21 CPU1.AK22 CPU1.AK27 CPU1.AK63 CPU1.AK68 CPU1.AK69 CPU1.AL2 CPU1.AL4 CPU1.AL28 CPU1.AL32 CPU1.AL35 CPU1.AL38 CPU1.AL45 CPU1.AL48 CPU1.AL52 CPU1.AL55 CPU1.AL58 CPU1.AL64 CPU1.AL65 CPU1.AL66 CPU1.AM8 CPU1.AM13 CPU1.AM21 CPU1.AM25 CPU1.AM27 CPU1.AM43 CPU1.AM45 CPU1.AM46 CPU1.AM55 CPU1.AM60 CPU1.AM61 CPU1.AM68 CPU1.AM71 CPU1.AN20 CPU1.AN23 CPU1.AN28 CPU1.AN30 CPU1.AN32 CPU1.AN33 CPU1.AN35 CPU1.AN37 CPU1.AN38 CPU1.AN40 CPU1.AN42 CPU1.AN58 CPU1.AN63 CPU1.AP10 CPU1.AP18 CPU1.AP20 CPU1.AP23 CPU1.AP28 CPU1.AP32 CPU1.AP35 CPU1.AP38 CPU1.AP42 CPU1.AP58 CPU1.AP63 CPU1.AP68 CPU1.AP70 CPU1.AR5 CPU1.AR8 CPU1.AR11 CPU1.AR15 CPU1.AR16 CPU1.AR20 CPU1.AR23 CPU1.AR28 CPU1.AR35 CPU1.AR42 CPU1.AR43 CPU1.AR45 CPU1.AR46 CPU1.AR48 CPU1.AR50 CPU1.AR52 CPU1.AR53 CPU1.AR55 CPU1.AR58 CPU1.AR63 CPU1.AT2 CPU1.AT4 CPU1.AT20 CPU1.AT23 CPU1.AT28 CPU1.AT35 CPU1.AT42 CPU1.AT56 CPU1.AT58 CPU1.AT63 CPU1.AT68 CPU1.AT71 CPU1.AU10 CPU1.AU15 CPU1.AU20 CPU1.AU32 CPU1.AU38 CPU1.AV68 CPU1.AV69 CPU1.AV70 CPU1.AW6 CPU1.AW8 CPU1.AW10 CPU1.AW12 CPU1.AW14 CPU1.AW16 CPU1.AW18 CPU1.AW21 CPU1.AW23 CPU1.AW26 CPU1.AW28 CPU1.AW30 CPU1.AW32 CPU1.AW34 CPU1.AW36 CPU1.AW38 CPU1.AW41 CPU1.AW43 CPU1.AW45 CPU1.AW47 CPU1.AW49 CPU1.AW51 CPU1.AW53 CPU1.AW55 CPU1.AW57 CPU1.AW60 CPU1.AW62 CPU1.AW64 CPU1.AW66 CPU1.AY66 CPU1.B10 CPU1.B14 CPU1.B18 CPU1.B22 CPU1.B30 CPU1.B34 CPU1.B39 CPU1.B44 CPU1.B48 CPU1.B53 CPU1.B58 CPU1.B62 CPU1.B66 CPU1.BA6 CPU1.BA10 CPU1.BA14 CPU1.BA18 CPU1.BA23 CPU1.BA28 CPU1.BA32 CPU1.BA36 CPU1.BA41 CPU1.BA45 CPU1.BA49 CPU1.BA53 CPU1.BA57 CPU1.BA62 CPU1.BA66 CPU1.BB6 CPU1.BB18 CPU1.BB26 CPU1.BB30 CPU1.BB34 CPU1.BB38 CPU1.BB43 CPU1.BB55 CPU1.BB60 CPU1.BB64 CPU1.C5 CPU1.C25 CPU1.D6 CPU1.D10 CPU1.D11 CPU1.D14 CPU1.D18 CPU1.D22 CPU1.D25 CPU1.D26 CPU1.D30 CPU1.D34 CPU1.D39 CPU1.D44 CPU1.D45 CPU1.D47 CPU1.D48 CPU1.D53 CPU1.D58 CPU1.D62 CPU1.D66 CPU1.D69 CPU1.E6 CPU1.E11 CPU1.E15 CPU1.E18 CPU1.E21 CPU1.E46 CPU1.E50 CPU1.E53 CPU1.E56 CPU1.E65 CPU1.F1 CPU1.F2 CPU1.F4 CPU1.F8 CPU1.F13 CPU1.F22 CPU1.F23 CPU1.F27 CPU1.F28 CPU1.F32 CPU1.F33 CPU1.F35 CPU1.F37 CPU1.F38 CPU1.F40 CPU1.F42 CPU1.F68 CPU1.G5 CPU1.G6 CPU1.G10 CPU1.G22 CPU1.G43 CPU1.G45 CPU1.G48 CPU1.G52 CPU1.G55 CPU1.G58 CPU1.G60 CPU1.G63 CPU1.G66 CPU1.H15 CPU1.H18 CPU1.H71 CPU1.J8 CPU1.J11 CPU1.J13 CPU1.J25 CPU1.J28 CPU1.J32 CPU1.J35 CPU1.J38 CPU1.J42 CPU1.K16 CPU1.K18 CPU1.K22 CPU1.K61 CPU1.K63 CPU1.K64 CPU1.K65 CPU1.K66 CPU1.K67 CPU1.K68 CPU1.K70 CPU1.K71 CPU1.L2 CPU1.L4 CPU1.L8 CPU1.L11 CPU1.L16 CPU1.L17 CPU1.L18 CPU1.L20 CPU1.N6 CPU1.N10 CPU1.N13 CPU1.N19 CPU1.N21 CPU1.N65 CPU1.N68 CPU1.P17 CPU1.P19 CPU1.P20 CPU1.P21 CPU1.R6 CPU1.R13 CPU1.T2 CPU1.T4 CPU1.T15 CPU1.T17 CPU1.T18 CPU1.T21 CPU1.U10 CPU1.U63 CPU1.U64 CPU1.U66 CPU1.U67 CPU1.U69 CPU1.U70 CPU1.V16 CPU1.V17 CPU1.V18 CPU1.W6 CPU1.W9 CPU1.W13 CPU1.Y17 CPU1.Y19 CPU1.Y20 CPU1.Y21 D2601.A D5702.1 DB1.8 DB1.10 DB1.11 DB1.12 DB2.4 DB2.5 DB2.6 DB3.4 DB3.7 DB3.8 DCIN1.7 DCIN1.8 DM1.1 DM1.2 DM1.5 DM1.6 DM1.9 DM1.10 DM1.14 DM1.15 DM1.18 DM1.19 DM1.22 DM1.23 DM1.26 DM1.27 DM1.30 DM1.31 DM1.35 DM1.36 DM1.39 DM1.40 DM1.43 DM1.44 DM1.47 DM1.48 DM1.51 DM1.52 DM1.56 DM1.57 DM1.60 DM1.61 DM1.64 DM1.65 DM1.68 DM1.69 DM1.72 DM1.73 DM1.77 DM1.78 DM1.81 DM1.82 DM1.85 DM1.86 DM1.89 DM1.90 DM1.93 DM1.94 DM1.98 DM1.99 DM1.102 DM1.103 DM1.106 DM1.107 DM1.167 DM1.168 DM1.171 DM1.172 DM1.175 DM1.176 DM1.180 DM1.181 DM1.184 DM1.185 DM1.188 DM1.189 DM1.192 DM1.193 DM1.196 DM1.197 DM1.201 DM1.202 DM1.205 DM1.206 DM1.209 DM1.210 DM1.213 DM1.214 DM1.217 DM1.218 DM1.222 DM1.223 DM1.226 DM1.227 DM1.230 DM1.231 DM1.234 DM1.235 DM1.238 DM1.239 DM1.243 DM1.244 DM1.247 DM1.248 DM1.251 DM1.252 DM1.261 DM1.262 DM2.1 DM2.2 DM2.5 DM2.6 DM2.9 DM2.10 DM2.14 DM2.15 DM2.18 DM2.19 DM2.22 DM2.23 DM2.26 DM2.27 DM2.30 DM2.31 DM2.35 DM2.36 DM2.39 DM2.40 DM2.43 DM2.44 DM2.47 DM2.48 DM2.51 DM2.52 DM2.56 DM2.57 DM2.60 DM2.61 DM2.64 DM2.65 DM2.68 DM2.69 DM2.72 DM2.73 DM2.77 DM2.78 DM2.81 DM2.82 DM2.85 DM2.86 DM2.89 DM2.90 DM2.93 DM2.94 DM2.98 DM2.99 DM2.102 DM2.103 DM2.106 DM2.107 DM2.167 DM2.168 DM2.171 DM2.172 DM2.175 DM2.176 DM2.180 DM2.181 DM2.184 DM2.185 DM2.188 DM2.189 DM2.192 DM2.193 DM2.196 DM2.197 DM2.201 DM2.202 DM2.205 DM2.206 DM2.209 DM2.210 DM2.213 DM2.214 DM2.217 DM2.218 DM2.222 DM2.223 DM2.226 DM2.227 DM2.230 DM2.231 DM2.234 DM2.235 DM2.238 DM2.239 DM2.243 DM2.244 DM2.247 DM2.248 DM2.251 DM2.252 DM2.261 DM2.262 EC1001.2 EC1002.2 EC1004.2 EC1059.2 EC1060.2 EC1062.2 EC1063.2 EC1220.2 EC1701.2 EC1702.2 EC1703.2 EC1704.2 EC1705.2 EC1706.2 EC1707.2 EC1708.2 EC1709.2 EC1710.1 EC1711.2 EC1712.2 EC1713.1 EC1714.2 EC1715.2 EC1716.2 EC1801.2 EC1802.2 EC1803.1 EC1805.2 EC1806.2 EC1807.2 EC1808.2 EC1901.1 EC1903.2 EC2001.2 EC2002.2 EC2401.2 EC2501.2 EC2502.2 EC2503.2 EC2504.2 EC2505.2 EC2506.2 EC2507.2 EC2508.2 EC2509.2 EC2601.2 EC2602.2 EC2603.2 EC2701.2 EC2703.2 EC2704.2 EC2705.2 EC2706.2 EC2707.2 EC2708.2 EC2709.2 EC2723.1 EC2901.1 EC2902.1 EC2903.1 EC2904.1 EC2909.2 EC2910.2 EC2911.2 EC2912.2 EC3101.1 EC3102.1 EC3103.1 EC3104.1 EC3105.1 EC3106.1 EC3107.1 EC3108.1 EC3618.2 EC3619.2 EC3701.2 EC4001.2 EC4314.2 EC5312.2 EC5501.2 EC5502.2 EC5504.2 EC5505.2 EC5701.2 EC5702.2 EC6001.2 EC6102.2 EC6103.2 EC6301.2 EC6302.2 EC6303.2 EC6304.2 EC6305.2 EC6401.2 EC6402.2 EC6403.2 EC6404.2 EC6406.2 EC6501.2 EC6502.2 EC6503.2 EC6504.2 EC6505.2 EC6506.2 EC6507.2 EC7001.2 EC8536.1 EC8537.1 EC9201.1 EC9202.1 EC9203.2 EC9701.2 EC9702.2 EC9703.2 EC9704.2 EC9705.2 EC9707.2 EC9710.2 EC9712.2 EC9714.2 EC9715.2 EC9716.2 EC9717.2 EC9718.2 EC9719.2 EC9720.2 EC9721.2 EC9722.2 EC9724.2 EC9725.2 EC9726.2 EC9727.2 EC9728.2 EC9732.2 EC9733.2 EC9734.2 EC9735.2 EC9736.2 EC9737.2 EC9739.2 EC9743.2 EC9744.2 EC9745.2 ED401.2 ED502.1 ED1217.2 ED1302.2 ED2901.3 ED2902.3 ED2903.3 ED3201.3 ED3201.8 ED3202.3 ED3202.8 ED3601.3 ED3601.8 ED3602.2 ED3603.3 ED3603.8 ED3604.2 ED3701.2 ED4304.1 ED4305.1 ED4306.1 ED5701.3 ED5701.8 ED5702.3 ED5702.8 ED5703.3 ED5703.8 ED6001.3 ED6001.8 ED6201.3 ED6201.8 ED6301.2 ED6401.2 ED9201.2 EL4303.2 EL4304.2 EL5503.2 FAN1.3 FAN1.5 FAN1.6 FAN261.5 FAN261.6 FAN261.7 FAN261.8 FC701.2 FC702.2 FC703.2 FC704.2 FC705.2 FC706.2 FC707.2 FC708.2 FC1001.2 FC1002.2 FC1003.2 FC1004.2 FC1005.2 FC1006.2 FC1301.2 FC1901.2 FC2401.2 FC2402.2 FC2403.2 FC2501.2 FC2701.2 FC4301.2 FC4701.2 FC4702.2 FC4801.2 FC5001.2 FC5301.2 FC5401.2 FC5402.2 FC5501.2 FC5502.2 FC5503.2 FC6001.2 FC6002.2 FC6003.2 FC6004.2 FC6005.2 FC6101.2 FC6201.2 FC9701.2 FC9702.2 FC9703.2 FC9704.2 FC9705.2 FC9706.2 FC9707.2 FC9708.2 FC9709.2 FC9717.2 FC9718.2 FC9719.2 FC9720.2 FC9721.2 FC9722.2 FC9723.2 FC9724.2 FC9725.2 FC9726.2 FC9727.2 FC9728.2 FC9729.2 FC9730.2 FC9731.2 FC9732.2 FC9733.2 FC9734.2 FC9735.2 FC9736.2 FC9737.2 FC9738.2 FPR1.1 FPR1.7 FPR1.8 G1801.1 G6401.1 G6402.1 GPU1.A3 GPU1.A30 GPU1.AA11 GPU1.AA13 GPU1.AA16 GPU1.AA27 GPU1.AB6 GPU1.AB10 GPU1.AB15 GPU1.AB24 GPU1.AB32 GPU1.AC9 GPU1.AC17 GPU1.AC24 GPU1.AC26 GPU1.AC27 GPU1.AD6 GPU1.AD8 GPU1.AD25 GPU1.AD32 GPU1.AE7 GPU1.AE14 GPU1.AE27 GPU1.AF32 GPU1.AG12 GPU1.AG27 GPU1.AH10 GPU1.AH28 GPU1.AH32 GPU1.B6 GPU1.B8 GPU1.B10 GPU1.B12 GPU1.B14 GPU1.B16 GPU1.B18 GPU1.B20 GPU1.B22 GPU1.B24 GPU1.B26 GPU1.C1 GPU1.C32 GPU1.E28 GPU1.F2 GPU1.F6 GPU1.F8 GPU1.F10 GPU1.F12 GPU1.F14 GPU1.F16 GPU1.F18 GPU1.F20 GPU1.F22 GPU1.F24 GPU1.F26 GPU1.G8 GPU1.G10 GPU1.G27 GPU1.G31 GPU1.H2 GPU1.H6 GPU1.H14 GPU1.H17 GPU1.H20 GPU1.J7 GPU1.J27 GPU1.J31 GPU1.K2 GPU1.K6 GPU1.K11 GPU1.K22 GPU1.K28 GPU1.K32 GPU1.L27 GPU1.M6 GPU1.M12 GPU1.M32 GPU1.N11 GPU1.N13 GPU1.N16 GPU1.N18 GPU1.N21 GPU1.N25 GPU1.N27 GPU1.P6 GPU1.P9 GPU1.P25 GPU1.P32 GPU1.R11 GPU1.R12 GPU1.R15 GPU1.R17 GPU1.R20 GPU1.R27 GPU1.T6 GPU1.T11 GPU1.T13 GPU1.T16 GPU1.T18 GPU1.T21 GPU1.T25 GPU1.T32 GPU1.U9 GPU1.U15 GPU1.U17 GPU1.U20 GPU1.U25 GPU1.U27 GPU1.V11 GPU1.V13 GPU1.V16 GPU1.V18 GPU1.V32 GPU1.W25 GPU1.W26 GPU1.W27 GPU1.Y10 GPU1.Y15 GPU1.Y17 GPU1.Y20 GPU1.Y25 GPU1.Y32 H1.1 H2.1 H3.1 H4.1 H5.1 H6.1 HCPU1.1 HCPU2.1 HCPU3.1 HCPU4.1 HDA27.49 HDD1.1 HDD1.4 HDD1.7 HDD1.8 HDD1.9 HDD1.18 HDD1.19 HDD1.21 HDD1.22 HDD1.23 HDD1.24 HDD1.31 HDD1.32 HDD1.33 HDD1.34 HDD1.35 HDMI1.2 HDMI1.5 HDMI1.8 HDMI1.11 HDMI1.17 HDMI1.20 HDMI1.21 HDMI1.22 HDMI1.23 HGPU1.1 HGPU2.1 HGPU3.1 IOBD3.1 IOBD3.2 IOBD3.5 IOBD3.8 IOBD3.18 IOBD3.19 IOBD3.20 IOBD4.4 IOBD4.7 IOBD4.10 IOBD4.13 IOBD4.17 IOBD4.18 IRCCD1.5 IRCCD1.6 IRCCD1.7 IRCCD1.8 KB1.1 KB1.31 KB1.32 KBC24.17 KBC24.51 KBC24.64 KBC24.84 KBC24.100 KBC24.124 KBLIT1.5 KBLIT1.6 LCD1.13 LCD1.16 LCD1.19 LCD1.24 LCD1.25 LCD1.29 LCD1.36 LCD1.41 LCD1.42 LCD1.43 LCD1.44 LCD1.45 LCD2.1 LEDBD1.5 LEDBD1.6 LEDBD1.7 LEDBD1.8 LIDSW1.1 LOM31.33 MESW1.1 MESW1.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1031.2 PC1032.2 PC1033.2 PC1034.2 PC1035.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1051.2 PC1052.2 PC1053.2 PC1054.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1061.2 PC1064.2 PC1065.2 PC1066.2 PC1067.2 PC1068.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1091.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC4302.2 PC4303.2 PC4304.2 PC4305.2 PC4306.2 PC4401.1 PC4405.2 PC4407.2 PC4409.2 PC4410.2 PC4411.2 PC4413.2 PC4415.2 PC4416.2 PC4417.2 PC4418.2 PC4419.2 PC4501.2 PC4502.2 PC4504.2 PC4505.2 PC4507.2 PC4508.2 PC4510.2 PC4511.2 PC4512.2 PC4513.2 PC4514.2 PC4515.2 PC4516.2 PC4518.2 PC4610.2 PC4702.2 PC4703.2 PC4704.2 PC4705.2 PC4707.2 PC4708.2 PC4709.2 PC4710.2 PC4802.2 PC4803.2 PC4804.2 PC4805.2 PC4806.2 PC4807.2 PC4808.2 PC4810.2 PC4811.2 PC5001.2 PC5002.2 PC5027.2 PC5029.2 PC5031.2 PC5104.2 PC5105.2 PC5107.2 PC5109.2 PC5110.2 PC5111.2 PC5112.2 PC5115.2 PC5116.2 PC5118.2 PC5119.2 PC5120.2 PC5121.2 PC5122.2 PC5123.2 PC5124.2 PC5301.2 PC5302.2 PC5303.2 PC5305.2 PC5306.2 PC5307.2 PC5308.2 PC5309.2 PC5311.2 PC5401.2 PC5402.2 PC5403.2 PC5404.2 PC5406.2 PC5407.2 PC5408.2 PC5409.2 PC5411.2 PC5412.2 PC8501.1 PC8502.2 PC8503.1 PC8506.2 PC8508.2 PC8509.2 PC8511.2 PC8512.2 PC8516.2 PC8519.2 PC8520.2 PC8521.1 PC8524.2 PC8525.2 PC8526.2 PC8527.2 PC8528.2 PC8529.2 PC8530.1 PC8533.2 PC8534.2 PC8535.2 PC8551.2 PC8552.2 PC8602.2 PC8604.2 PC8605.2 PC8607.2 PC8612.2 PC8621.2 PC8622.2 PC8623.2 PC8625.2 PC8626.2 PC8635.2 PC8636.2 PC8651.2 PC8652.2 PC8653.2 PC8654.2 PC8655.2 PC8657.2 PC8658.2 PC8659.2 PC8660.2 PC8661.2 PD4301.A PD4302.1 PD4303.3 PD4304.A PG4411.2 PG4601.2 PQ4302.E PQ4304.E PQ4306.1 PQ4306.4 PQ4402.1 PQ4402.4 PQ4403.S PQ4405.1 PQ4405.4 PQ8501.1 PQ8501.4 PQ8604.1 PQ8604.4 PQ8608.S PR4302.2 PR4308.2 PR4313.2 PR4409.2 PR4413.1 PR4430.2 PR4432.2 PR4433.2 PR4451.2 PR4505.2 PR4510.2 PR4515.2 PR4517.2 PR4652.2 PR4653.1 PR4656.1 PR4661.2 PR5101.2 PR5105.2 PR5106.1 PR5303.2 PR5304.2 PR5404.2 PR5407.2 PR5408.2 PR5411.2 PR8501.1 PR8502.1 PR8506.1 PR8508.1 PR8516.2 PR8524.1 PR8528.2 PR8531.2 PR8623.2 PR8671.2 PR8672.2 PR8676.2 PT4501.2 PT4502.2 PT4702.2 PT4703.2 PT4704.2 PT4801.2 PT8501.2 PT8506.2 PT8507.2 PU4401.22 PU4405.1 PU4405.2 PU4405.3 PU4501.21 PU4503.1 PU4503.2 PU4503.3 PU4505.1 PU4505.2 PU4505.3 PU4701.3 PU4701.5 PU4701.19 PU4701.20 PU4701.21 PU4701.22 PU4701.23 PU4701.24 PU4701.31 PU4701.37 PU4801.5 PU4801.19 PU4801.20 PU4801.21 PU4801.22 PU4801.23 PU4801.24 PU4801.31 PU4801.37 PU5001.6 PU5001.9 PU5003.1 PU5003.2 PU5003.3 PU5101.7 PU5101.8 PU5101.18 PU5101.21 PU5102.4 PU5102.8 PU5102.11 PU5301.4 PU5301.12 PU5301.13 PU5301.14 PU5301.15 PU5301.19 PU5401.8 PU5401.9 PU5402.8 PU5402.9 PU8501.41 PU8502.5 PU8502.6 PU8502.7 PU8503.5 PU8503.6 PU8503.7 PU8504.5 PU8504.6 PU8504.7 PU8505.5 PU8505.6 PU8505.7 PU8601.4 PU8601.8 PU8601.9 PU8651.7 PU8651.8 PU8651.18 PU8651.21 PWR1.4 PWR1.5 PWR1.6 PWSW2.1 PWSW2.2 PWSW2.5 PWSW2.6 Q501.S Q502.S Q1701.1 Q1701.4 Q1702.1 Q1702.4 Q1802.S Q2408.S Q2505.S Q2702.S Q3101.S Q4001.1 Q4001.4 Q5701.S Q6101.1 Q6101.4 Q6201.1 Q6201.4 Q6301.S Q6501.S Q6505.S Q6701.1 Q6701.4 Q7902.S Q7903.S Q9104.S R402.2 R405.2 R406.2 R407.2 R501.2 R502.2 R503.2 R601.2 R602.2 R604.2 R605.2 R720.2 R722.2 R734.2 R806.2 R1205.1 R1209.2 R1210.1 R1212.1 R1216.2 R1303.1 R1307.2 R1309.2 R1311.1 R1501.2 R1502.2 R1601.2 R1602.2 R1603.2 R1715.2 R1717.2 R1719.2 R1732.1 R1823.2 R1825.2 R1837.2 R1901.2 R1904.1 R2008.2 R2018.2 R2019.2 R2024.2 R2401.2 R2417.2 R2436.2 R2445.1 R2447.2 R2449.1 R2454.2 R2499.2 R2504.2 R2605.1 R2706.2 R2717.2 R2721.2 R2727.2 R2730.2 R3105.2 R3108.2 R3111.2 R3401.2 R3404.2 R3501.2 R3502.2 R4006.2 R4301.1 R5506.1 R5526.2 R5528.2 R5531.2 R5609.1 R5611.1 R5613.1 R5615.1 R5616.2 R5618.2 R5705.2 R5706.1 R5709.1 R5710.2 R6101.2 R6224.2 R6301.1 R6505.2 R6507.2 R6513.2 R6707.2 R7601.2 R7801.2 R7808.1 R7809.1 R7811.1 R7814.2 R7818.2 R7819.2 R7820.2 R7821.2 R7902.1 R7922.2 R7925.1 R7927.2 R7929.2 R7931.2 R7933.2 R7934.1 R7936.2 R7938.1 R7939.1 R7941.1 R7943.1 R8203.1 R8205.1 R8206.2 R9124.2 R9131.2 R9148.2 R9605.1 R9607.1 R9609.1 R9804.2 R9931.2 R9936.2 RJ45.9 RJ45.10 RN401.1(A) RN401.2(A) RN402.1(A) RN402.2(A) RN1201.2(A) RN1301.2(A) RN1703.3(B) RN1703.4(B) RN2009.1(A) RN2009.2(A) RN5502.1(A) RN5502.2(A) RN5502.3(A) RN7904.3(B) RN7904.4(B) RN9601.3(B) RN9601.4(B) RTC1.2 RTC1.3 RTC1.4 SIM1.5 SIM1.GND1 SIM1.GND2 SIM1.GND3 SIM1.GND4 SIM1.GND5 SIM1.GND6 SIM1.GND7 SIM1.GND8 SIM1.GND9 SIM1.GND10 SKT25.4 SPI25.4 SPI241.4 SPI252.4 SPK1.5 SPK1.6 SPR1.1 SPR2.1 SPR3.1 TC3502.2 TC6201.2 THM26.5 THM263.5 TPAD1.4 TPAD1.9 TPAD1.10 U3401.14 U3401.17 U3502.2 U3503.2 U4001.11 U4001.15 U4002.5 U4003.3 U4005.3 U4006.5 U4101.1 U5501.2 U5601.3 U5601.13 U5601.18 U5601.21 U6701.5 U6701.6 U6701.7 U6701.8 U9101.4 U9101.9 U9102.11 U9102.16 U9102.26 U9102.32 U9102.33 U9103.4 U9104.9 U9104.16 U9104.23 U9104.32 U9104.33 U9601.17 U9601.21 USB1.4 USB1.7 USB1.10 USB1.11 USB1.12 USB1.13 USB2.4 USB2.7 USB2.10 USB2.11 USB2.12 USB2.13 VRAM1.A9 VRAM1.B1 VRAM1.B3 VRAM1.B9 VRAM1.D1 VRAM1.D8 VRAM1.E1 VRAM1.E2 VRAM1.E8 VRAM1.F9 VRAM1.G1 VRAM1.G8 VRAM1.G9 VRAM1.J2 VRAM1.J8 VRAM1.M1 VRAM1.M9 VRAM1.P1 VRAM1.P9 VRAM1.T1 VRAM1.T9 VRAM2.A9 VRAM2.B1 VRAM2.B3 VRAM2.B9 VRAM2.D1 VRAM2.D8 VRAM2.E1 VRAM2.E2 VRAM2.E8 VRAM2.F9 VRAM2.G1 VRAM2.G8 VRAM2.G9 VRAM2.J2 VRAM2.J8 VRAM2.M1 VRAM2.M9 VRAM2.P1 VRAM2.P9 VRAM2.T1 VRAM2.T9 VRAM3.A9 VRAM3.B1 VRAM3.B3 VRAM3.B9 VRAM3.D1 VRAM3.D8 VRAM3.E1 VRAM3.E2 VRAM3.E8 VRAM3.F9 VRAM3.G1 VRAM3.G8 VRAM3.G9 VRAM3.J2 VRAM3.J8 VRAM3.M1 VRAM3.M9 VRAM3.P1 VRAM3.P9 VRAM3.T1 VRAM3.T9 VRAM4.A9 VRAM4.B1 VRAM4.B3 VRAM4.B9 VRAM4.D1 VRAM4.D8 VRAM4.E1 VRAM4.E2 VRAM4.E8 VRAM4.F9 VRAM4.G1 VRAM4.G8 VRAM4.G9 VRAM4.J2 VRAM4.J8 VRAM4.M1 VRAM4.M9 VRAM4.P1 VRAM4.P9 VRAM4.T1 VRAM4.T9 WLAN1.1 WLAN1.7 WLAN1.18 WLAN1.23 WLAN1.24 WLAN1.29 WLAN1.30 WLAN1.33 WLAN1.36 WLAN1.39 WLAN1.45 WLAN1.51 WLAN1.57 WLAN1.63 WLAN1.69 WLAN1.75 WLAN1.76 WLAN1.77 WLAN2.1 WWAN1.3 WWAN1.5 WWAN1.11 WWAN1.27 WWAN1.33 WWAN1.39 WWAN1.45 WWAN1.51 WWAN1.57 WWAN1.71 WWAN1.73 WWAN1.76 WWAN1.77 WWAN2.1 X3101.2 X3101.4 X7901.2 X7901.4 XDP1.2 XDP1.7 XDP1.8 XDP1.13 XDP1.14 XDP1.19 XDP1.20 XDP1.25 XDP1.26 XDP1.31 XDP1.32 XDP1.37 XDP1.38 XDP1.49 XDP1.50 XDP1.59
V0.85A_VID0: CPU1.AN11 TP2101.1
V3D3_STB: HDA27.20 R2712.1
