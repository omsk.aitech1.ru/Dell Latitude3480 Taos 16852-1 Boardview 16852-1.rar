# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PWR_DCBATOUT_VGA_CORE2: length 5.4
  TOP w0.508: 214.02,87.84 214.17,87.69 214.24,87.26 214.43,86.03 214.55,85.3 214.55,85.29 EC8537.2
  BOTTOM w0.508: 214.25,87.62 214.55,87.31 EC8537.2
  vias: v2(211.61,90.64) v3(212.98,94.47) v3(212.98,93.58) v3(212.98,92.7) v3(212.98,91.81)
PWR_LED: length 95.6
  TOP w0.508: v1(269.09,27.34) 269.27,27.16 270.89,27.16 v2(271.14,27.42) 271.55,27.82 271.55,29.81 272.46,30.72 274.19,30.72 274.89,31.42 v1(274.89,34.97) ; Q6405.C 203.77,8.33 203.76,8.32 203.76,7.88 203.58,7.71 v1(203.58,7.69)
  L3 w0.508: v1(203.58,7.69) 205.48,7.69 206.63,6.54 211.65,6.54 211.7,6.59 221.23,6.59 221.87,7.22 223.28,7.22 226.3,4.2 234.88,4.2 235.85,5.17 235.87,5.17 236.14,5.43 237.87,5.43 241.77,9.33 244.71,9.33 246.58,11.2 246.58,13.67 247.29,14.38 247.29,16.12 253.53,22.36 255.35,22.36 255.73,22.74 259.71,22.74 260.6,23.63 260.79,23.63 263.29,26.13 264.06,26.13 265.27,27.34 v1(269.09,27.34)
  BOTTOM w0.508: v1(274.89,34.97) R6409.1 274.95,34.34 EC6406.1
PWR_LED#: length 52.2
  TOP w0.127: v1(202.97,32.22) 202.97,32.42 202.25,33.14 KBC24.70 ; Q2418.4 197.14,8.84 197.94,8.04 v1(198.55,8.04) 198.64,7.95 v2(199.52,7.95) 200.09,7.95 200.45,7.59 RN2405.4
  L6 w0.127: v1(202.97,32.22) 202.97,31.56 202.61,31.2 202.24,31.2 200.61,29.57 200.61,27.32 201.06,26.87 201.06,24.77 200.67,24.38 200.67,21.43 200.79,21.31 200.79,20.16 200.01,19.38 200.01,15.96 201.9,14.06 203.8,14.06 205.04,12.82 205.04,11.83 205.74,11.14 208.2,11.14 209,10.33 209,9.85 209.32,9.54 210.13,9.54 210.23,9.44 v1(210.54,9.13)
  BOTTOM w0.127: v1(210.54,9.13) 210.54,9.03 209.8,8.29 200.25,8.29 200,8.04 v1(198.55,8.04)
PWR_LED#_B: length 3
  TOP w0.127: Q6405.B 205.68,8.91 206.4,9.64 v1(206.4,9.66) 206.43,9.66 206.53,9.76 Q6407.D
  BOTTOM w0.127: v2(205.82,9.66) v1(206.4,9.66)
PWR_LED#_R: length 10.4
  TOP w0.305: 267.21,34.54 267.75,34 PWR1.3 268.88,34 269.11,33.77
  TOP w0.381: v1(273.3,33.39) 270.51,33.39 270.13,33.77 269.11,33.77 ; AFTP6105.1 267.21,34.54
  BOTTOM w0.508: R6409.2 EC6404.1 v1(273.3,33.39)
PWR_LED#_S: length 18.3
  TOP w0.127: v2(197.74,12.43) 197.14,11.82 Q2418.3 196.29,11.24 196.16,11.11 v1(196.09,11.11) ; Q6407.S 209.5,10.74 v1(209.5,9.99)
  L4 w0.127: v1(196.09,11.11) 196.16,11.11 196.38,11.33 201.82,11.33 204.25,8.9 207.93,8.9 208.14,9.1 208.14,9.12 208.72,9.7 208.74,9.7 209.03,9.99 v1(209.5,9.99)
PWR_VCCGT_BOOTA: length 2.4
  BOTTOM w0.203: PU4801.35 113.05,117.56 v2(113.39,117.89)
  BOTTOM w0.508: v2(113.39,117.89) 113.39,118.53 PR4802.1
PWR_VCCGT_BOOTA_RC: length 2.5
  BOTTOM w0.508: PC4809.1 PR4802.2 112.93,120.38 113.36,120.81 v2(113.36,121.35)
PWR_VCCGT_COMP: length 5.7
  TOP w0.254: PC4618.2 145.69,107.21 PC4617.2 146.2,107.46 v2(146.2,108.13) 146.2,108.98 147.07,109.84 v1(147.68,109.84)
  BOTTOM w0.203: v1(147.68,109.84) 147.57,109.94 147.57,110.09 147.52,110.14 147.52,110.46 147.5,110.48 147.5,110.51 147.43,110.58 PU4601.4
PWR_VCCGT_COMP_R: length 2
  TOP w0.254: v2(145.8,105.34) 145.62,105.52 PC4618.1 146.38,106.39 PR4631.2
PWR_VCCGT_CSCOMP: length 52.5
  L6 w0.102: v1(120.19,111.67) 119.89,111.36 119.89,103.36 120.54,102.7 140.67,102.7 141.02,103.06 141.02,104.83 140.05,105.8 140.05,106.81 140.56,107.33 145.23,107.33 146.86,105.7 146.86,105.09 v1(147.19,104.76)
  BOTTOM w0.102: v1(147.19,104.76) 147.34,104.9 v2(147.34,105.37) PR4639.2 147.34,107.07 PR4640.1 147.2,107.2 PC4620.1 PC4621.1 146.4,108.79 146.84,109.23 146.84,110.32 146.63,110.53 PU4601.6 ; v1(120.19,111.67) 119.48,110.96 118.87,110.96 118.86,110.97 PR4634.2
PWR_VCCGT_CSNA: length 40.4
  TOP w0.254: v2(113.82,106.92) 114,106.74 v1(114.48,106.74) ; PR4646.2 144.46,106.43 144.4,106.38 v1(144.4,105.8)
  L6 w0.254: v1(114.48,106.74) 114.99,107.25 116.36,107.25 117.2,106.41 117.2,103.32 119.76,100.75 141.65,100.75 144.32,103.42 144.32,105.73 v1(144.4,105.8)
  BOTTOM w0.254: v1(114.48,106.74) 114.45,106.72 PG4809.1
PWR_VCCGT_CSP1: length 4.5
  TOP w0.254: PR4651.2 143.57,107.91 PC4623.2 143.57,108.64 v2(143.87,109.13) 144.07,109.46 v1(144.53,109.46)
  BOTTOM w0.203: v1(144.53,109.46) 144.68,109.61 144.83,109.61 145.11,109.89 145.11,110.29 145.03,110.38 PU4601.10
PWR_VCCGT_CSP2: length 3.1
  BOTTOM w0.203: v2(145.21,109.05) 145.44,109.28 145.44,110.43 145.43,110.44 PU4601.9
  BOTTOM w0.254: PR4603.2 144.7,108.54 v2(145.21,109.05)
PWR_VCCGT_CSPA: length 40.6
  TOP w0.254: v2(114.45,108.44) v1(114.45,107.83) ; v1(143.76,105.8) 143.62,105.94 PR4651.1
  L6 w0.254: v1(114.45,107.83) 114.66,107.63 116.51,107.63 117.58,106.57 117.58,106.25 117.58,103.48 119.92,101.13 141.5,101.13 143.87,103.5 143.87,105.7 v1(143.76,105.8)
  BOTTOM w0.254: v1(114.45,107.83) 114.4,107.88 PG4808.1 ; v1(143.76,105.8) 143.36,105.4 PR4637.1
PWR_VCCGT_CSREF: length 5.3
  TOP w0.254: PR4646.1 144.46,107.85 PC4623.1 144.49,108.25 v2(145.29,109.04) 145.92,109.68 145.92,109.71 v1(145.93,109.71) 145.92,109.72 145.92,110.41 PC4626.1
  BOTTOM w0.203: v1(145.93,109.71) 145.92,109.72 145.92,110.25 145.83,110.34 PU4601.8
PWR_VCCGT_CSSUM: length 8.1
  BOTTOM w0.203: PU4601.7 146.23,110.42 146.43,110.22 146.43,109.52 145.51,108.6 PC4621.2
  BOTTOM w0.254: v2(144.68,103.69) PR4637.2 145.09,105.27 145.09,105.85 PR4638.2 145.62,107.09 PC4620.2 PC4621.2
PWR_VCCGT_DIFFOUT: length 4.2
  TOP w0.254: v1(148.64,109.69) 148.64,109.54 148.82,109.36 v2(148.82,108.85) 148.1,108.13 PR4626.1 148.1,107.34 PR4625.1
  BOTTOM w0.203: v1(148.64,109.69) 148.62,109.71 148.62,110.05 148.23,110.43 PU4601.2
PWR_VCCGT_DISB#_A: length 2.3
  BOTTOM w0.203: PU4801.2 114.43,115.65 114.69,115.91 115.13,115.91 115.42,115.63 115.42,115.57 PR4808.2
PWR_VCCGT_FB: length 6.4
  TOP w0.254: v1(147.83,109.21) 147.32,109.21 v2(147.19,109.08) 147.21,109.06 PR4626.2 147.21,107.34 PC4617.1 PR4631.1 147.34,105.56 PC4614.2
  BOTTOM w0.203: v1(147.83,109.21) 148.16,109.54 148.16,110.04 147.85,110.34 147.85,110.6 147.83,110.62 PU4601.3
PWR_VCCGT_FB_R: length 2.3
  TOP w0.254: PR4625.2 148.62,106.39 149.05,105.95 v2(149.05,105.85) 148.63,105.43 PC4614.1
PWR_VCCGT_ICCMAX: length 4.1
  TOP w0.254: PR4662.1 142.77,113.65 142.49,113.37 141.88,113.37 141.83,113.42 v1(141.5,113.42)
  BOTTOM w0.203: PU4601.18 142.7,113.58 142.21,113.09 v2(141.99,113.09)
  BOTTOM w0.254: v2(141.99,113.09) 141.66,113.42 v1(141.5,113.42)
PWR_VCCGT_ILIM: length 4.2
  BOTTOM w0.203: PU4601.5 147.03,110.51 147.19,110.35 147.19,108.48 v2(147.3,108.37) 147.3,108.08 148.09,107.29 PR4640.2
PWR_VCCGT_ILIM_R: length 45.3
  TOP w0.102: v1(119,111.75) 119.13,111.87 v2(119.13,112.33)
  L6 w0.102: v1(119,111.75) 119.13,111.75 119.53,111.34 119.53,103.21 120.4,102.35 140.81,102.35 141.38,102.91 141.38,104.98 140.4,105.95 140.4,106.67 140.71,106.97 141.64,106.97 141.65,106.98 145.09,106.98 146.43,105.63 v1(146.43,105.52)
  BOTTOM w0.102: v1(119,111.75) 118.88,111.86 PR4634.1 ; PR4638.1 146.41,105.5 v1(146.43,105.52) 146.43,105.73 146.45,105.75 PR4639.1
PWR_VCCGT_IOUT: length 3.5
  TOP w0.254: v1(149.1,110.24) 148.95,110.4 v2(148.95,110.81) 148.81,110.67 PC4615.2 PR4632.2
  BOTTOM w0.203: PU4601.1 148.63,110.69 149.08,110.24 v1(149.1,110.24)
PWR_VCCGT_NTC: length 46.3
  L6 w0.254: v1(141.19,106.54) 141.32,106.41 141.32,106.33 141.35,106.3 141.35,105.74 141.81,105.28 141.81,102.52 141.2,101.92 120.22,101.92 119.1,103.03 119.1,110.65 117.07,112.68 117.07,115.46 117.6,115.99 v1(117.6,116.06)
  BOTTOM w0.254: PR4656.2 117.55,116.01 v1(117.6,116.06) ; v1(141.19,106.54) 141.2,106.53 141.2,106.34 141.51,106.03 141.58,106.03 v2(141.63,105.98) 142.01,105.98 142.33,106.3 142.33,106.49 PR4661.1 PR4655.1
PWR_VCCGT_PHASEDA: length 3.6
  BOTTOM w0.203: PU4801.32 111.85,117.35 112.17,117.66 v2(112.17,117.89) 112.65,117.41 PU4801.34
  BOTTOM w0.508: PC4809.2 111.61,118.88 112.17,118.32 v2(112.17,117.89)
PWR_VCCGT_PWMA: length 53.2
  L6 w0.254: v1(141.82,106.54) 141.73,106.45 141.73,105.9 142.19,105.44 142.19,102.37 141.36,101.53 120.06,101.53 118.62,102.98 118.62,110.59 116.69,112.52 116.69,114.44 116.41,114.72 v1(115.19,114.72)
  BOTTOM w0.203: v1(115.19,114.72) 115.06,114.85 PU4801.4 ; PU4601.16 142.59,112.78
  BOTTOM w0.254: v1(141.82,106.54) 141.82,107.05 v2(141.17,107.7) 140.84,108.03 140.84,109.12 140.34,109.63 140.34,110.38 141.1,111.14 141.1,112.12 141.61,112.63 142.44,112.63 142.59,112.78
PWR_VCCGT_SNUB_1: length 2.8
  BOTTOM w0.508: PC4810.1 107.06,112.08 PR4804.2 106.58,111.19 v2(106.53,111.14)
PWR_VCCGT_SWA: length 2.6
  TOP w0.305: v2(110.24,112.51) v1(109.6,112.51)
  BOTTOM w0.305: PL4801.1 113.59,109.62 PG4808.2
PWR_VCCGT_TSENSE: length 4.2
  TOP w0.254: v1(144.63,110.09) 144.82,110.29 144.85,110.29 145.22,110.67 PC4630.1
  BOTTOM w0.203: PU4601.11 v1(144.63,110.09)
  BOTTOM w0.254: v1(144.63,110.09) 144.5,109.97 144.32,109.97 143.84,109.49 v2(143.84,109.05) 143.84,109 143.87,108.97 PR4655.2
PWR_VCCGT_VCCA: length 3.6
  BOTTOM w0.203: PU4801.6 114.41,114.05 114.83,113.62 114.83,113.24 v2(115.14,112.94)
  BOTTOM w0.254: PC4808.1 PR4803.1 115.43,112.94 v2(115.14,112.94)
PWR_VCCGT_VSN: length 5.1
  BOTTOM w0.203: PU4601.48 149.29,110.79
  BOTTOM w0.254: 149.29,110.79 150.25,109.83 PC4612.2 ; PC4612.2 150.5,109.54 150.88,109.15 v2(151.13,109.15) ; PC4612.2 150.25,109.32 149.48,108.54 PR4619.1
PWR_VCCGT_VSN_R: length 9.2
  TOP w0.254: v1(152.2,107.02) 152.2,107.67 PR4618.2 152.43,107.9 v2(152.43,108.72) 152.43,108.93 151.89,109.46 PC4611.2
  BOTTOM w0.254: PC4612.1 149.31,109.54 PR4619.2 148.32,108.35 149.07,107.6 151.61,107.6 v1(152.2,107.02)
PWR_VCCGT_VSP: length 7.2
  TOP w0.254: v2(153.7,110.67) PR4617.2 PC4611.1 151.89,110.91 151.64,111.16 151.26,111.16 150.98,110.87 v1(150.98,109.87)
  BOTTOM w0.203: v1(150.98,109.87) 150.98,109.99 150.11,110.86 150.11,111.53 149.67,111.98 PU4601.47
PWR_VCCSA_BST: length 3.9
  BOTTOM w0.254: v2(144.91,123.68) 144.55,123.32 PR5013.1
  BOTTOM w0.305: PR5013.1 143.51,123.32 142.77,124.06 142.24,124.06 141.72,123.54 PU5001.1
PWR_VCCSA_BST_RC: length 6.2
  BOTTOM w0.508: PR5013.2 143.31,124.72 140.87,124.72 v2(140.79,124.65) 138.48,124.65 PC5008.1
PWR_VCCSA_COMP: length 5.1
  TOP w0.254: PC4604.2 150.03,112.99 v1(151.2,112.99) 151.82,112.99 v2(151.97,113.14)
  BOTTOM w0.203: PU4601.43 149.83,113.58 150.39,113.02 150.59,113.02 150.61,112.99 v1(151.2,112.99) 151.23,112.99 151.64,113.4 PC4602.2
PWR_VCCSA_COMP_R: length 3.6
  BOTTOM w0.254: PC4602.1 153.84,113.4 PR4602.2 155.32,114.88 v2(155.32,115.3)
PWR_VCCSA_CSN: length 31.8
  TOP w0.254: v1(151.82,114.95) v2(151.28,115.48)
  L6 w0.254: v1(136.25,109.15) 136.68,109.59 139.36,109.59 140.53,110.75 140.53,111.38 141.39,112.25 142.62,112.25 144.19,110.68 145.19,110.68 145.44,110.42 148.36,110.42 150.11,112.17 150.11,113.75 151.31,114.95 v1(151.82,114.95)
  BOTTOM w0.203: PU4601.41 149.8,114.38 149.9,114.48 150.69,114.48 150.95,114.74 150.95,114.74
  BOTTOM w0.254: v1(151.82,114.95) 151.82,115.92 PC4607.1 PC4606.1 151.26,115.05 150.95,114.74 ; PR4606.2 139.81,109.15 v1(136.25,109.15) 136.05,108.95 PG5022.1
PWR_VCCSA_CSN_NTC: length 24
  TOP w0.254: v1(153.29,114.92) v2(153.92,114.92)
  L6 w0.254: v1(153.29,114.92) 153.42,115.05 153.75,115.05 154.31,114.49 154.31,111.62 150.5,107.81 139.83,107.81 v1(139.06,108.57)
  BOTTOM w0.254: PR4606.1 139.51,108.57 v1(139.06,108.57) ; PR4609.2 154.01,115.05 153.42,115.05 v1(153.29,114.92)
PWR_VCCSA_CSP: length 24
  TOP w0.254: v1(152.32,115.53) 152.32,116.19 v2(152.37,116.24)
  L6 w0.254: v1(136.3,110.37) 136.7,109.97 139.2,109.97 140.14,110.91 140.14,111.54 141.24,112.63 142.77,112.63 144.35,111.06 145.34,111.06 145.6,110.81 148.2,110.81 149.73,112.33 149.73,113.9 151.28,115.45 152.25,115.45 v1(152.32,115.53)
  BOTTOM w0.254: v1(136.3,110.37) 136.04,110.63 PG5021.1 ; v1(152.32,115.53) 153.01,115.53 PR4612.2
PWR_VCCSA_CSP1B: length 7.4
  BOTTOM w0.203: v2(150.6,115.02) 150.42,114.85 149.8,114.85 149.73,114.78 PU4601.40
  BOTTOM w0.254: v2(150.6,115.02) 150.78,115.21 150.78,115.75 150.72,115.8 150.72,116.74 151.13,117.14 PC4606.2 PC4607.2 153.12,117.14 PR4612.1 154.04,116.23 PR4609.1
PWR_VCCSA_DRVH: length 16.3
  TOP w1.016: v3(131.19,114.16) 131.09,114.26 131.09,117.88 v2(132.76,119.55) 135.87,122.67 137.92,122.67 v3(138.94,123.68)
  BOTTOM w0.254: v3(138.94,123.68) 139.09,123.68 139.23,123.54 PU5001.8
  BOTTOM w0.381: v3(131.19,114.16) 131.36,114.33 PU5002.4
PWR_VCCSA_DRVL:
  vias: v2(139.78,120.94)
PWR_VCCSA_ICCMAX: length 3.9
  TOP w0.254: v1(141.62,114.49) 141.86,114.49 142.11,114.74 v2(142.11,114.87) 142.51,114.87 PR4660.1
  BOTTOM w0.203: PU4601.20 141.73,114.38 v1(141.62,114.49)
PWR_VCCSA_ILIM: length 4.3
  TOP w0.254: PC4632.1 149.93,113.77 150.36,113.77 v1(150.62,113.51) 151,113.9 v2(151,114.16)
  BOTTOM w0.203: PU4601.42 150.17,113.98 150.62,113.53 150.62,113.52
  BOTTOM w0.254: PR4611.1 151.33,114.23 150.62,113.52 v1(150.62,113.51)
PWR_VCCSA_IOUT: length 3.9
  TOP w0.254: PC4609.1 148.65,115.81 v2(149.66,115.81) 150,115.81 v1(150.28,115.53) 149.92,115.18 PR4613.1
  BOTTOM w0.203: PU4601.39 149.86,115.18 150.22,115.53 v1(150.28,115.53)
PWR_VCCSA_PWM: length 12.9
  TOP w0.254: v1(142.49,123.43) v2(143.1,123.43)
  L4 w0.254: v1(149.4,117.43) 149.4,118.22 149.33,118.3 149.33,118.53 148.08,119.77 146.2,119.77 143.13,122.84 143.13,122.88 142.58,123.43 v1(142.49,123.43)
  BOTTOM w0.203: v1(149.4,117.43) 149.4,117.23 148.81,116.63 PU4601.36
  BOTTOM w0.254: PU5001.2 142.11,123.04 v1(142.49,123.43)
PWR_VCCSA_SNUB: length 1
  BOTTOM w0.508: PR5014.2 PC5031.1
PWR_VCCSA_SW: length 12.2
  TOP w1.016: v3(138.02,121.4) 136.4,121.4 133.63,118.63 v2(133.63,115.68) 133.63,114.39 v3(132.61,113.37)
  BOTTOM w0.305: PU5001.7 138.86,123.04
PWR_VCCSA_VSN: length 4
  BOTTOM w0.203: PU4601.44 149.72,113.18 150.49,112.41 v2(150.85,112.41) 151.1,112.15 151.47,112.15 PR4605.2
  BOTTOM w0.254: PC4603.2 PR4605.2
PWR_VCCSA_VSN_R: length 3.6
  BOTTOM w0.254: PC4603.1 PR4605.1 152.78,112.57 PC4605.2 153.56,112.56 154.24,112.56 PR4604.2 154.37,113.28 v2(154.43,113.35)
PWR_VCCSA_VSP: length 5.3
  BOTTOM w0.203: 151.8,110.75 151.19,111.36 151.19,111.48 150.82,111.85 150.59,111.85 149.66,112.78 PU4601.45
  BOTTOM w0.254: v2(150.88,110.73) 150.9,110.75 151.8,110.75 PR4608.2 PC4608.2
PWR_VCCSA_VSP_R: length 3.7
  BOTTOM w0.254: PR4607.2 154.31,111.68 PC4605.1 PR4616.1 ; PR4616.1 154.27,110.67 v2(154.46,110.48) ; PR4616.1 152.78,110.67 PR4608.1
PWR_VCCSA_VSP_RC: length 1.9
  BOTTOM w0.254: PC4608.1 152.78,109.78 PR4616.2 153.81,109.78 v2(154.38,109.21)
PWR_VCORE_ADDR_BOOT: length 4
  TOP w0.254: v1(141.6,115.25) 141.6,115.94 v2(141.53,116.01) 141.88,116.01 142.32,116.44 PR4663.1
  BOTTOM w0.203: PU4601.21 142.13,114.78
  BOTTOM w0.254: 142.13,114.78 141.66,115.25 v1(141.6,115.25)
PWR_VCORE_ALERT#: length 3.6
  BOTTOM w0.14: PU4601.33 147.43,117.34 148.39,118.3 v2(148.89,118.3) 149.35,118.76 PR4666.1
PWR_VCORE_BOOT: length 3.4
  BOTTOM w0.203: PU4701.35 125.37,121.01 125.6,121.24
  BOTTOM w0.508: 125.6,121.24 125.78,121.24 v2(126.42,121.88) 126.42,122.79 PR4701.1
PWR_VCORE_BOOT_RC:
  vias: v2(124.21,124.95)
PWR_VCORE_COMP: length 4.3
  TOP w0.254: v2(143.26,118.83) 143.31,118.88 PC4601.1 144.23,118.46 144.46,118.23 v1(144.47,118.23) 144.46,118.21 144.46,117.58 PC4619.1
  BOTTOM w0.203: v1(144.47,118.23) 144.46,118.22 144.46,117.88 144.63,117.72 PU4601.26
PWR_VCORE_COMP_R: length 2.3
  TOP w0.254: PC4601.2 143.79,119.77 v2(143.28,120.28) 143.73,120.72 PR4636.1
PWR_VCORE_CSN: length 44.7
  TOP w0.254: v2(124.08,111.06) v1(124.66,111.06)
  L4 w0.254: v1(124.66,111.06) 126.29,111.06 127.69,112.46 127.69,120.49 129.51,122.31 133.73,122.31 136.23,124.81 142.53,124.81 144.93,122.41 145.77,122.41 146.09,122.09 146.09,120.93 v1(145.92,120.76)
  BOTTOM w0.203: PC4616.2 145.79,118.92 145.58,118.71 145.58,117.77 145.43,117.62 PU4601.28
  BOTTOM w0.254: PR4633.1 127.32,112.19 126.19,111.06 v1(124.66,111.06) 123.95,110.35 PG4708.1 ; v1(145.92,120.76) 145.79,120.63 PC4634.2 PC4616.2
PWR_VCORE_CSNNTC: length 29.3
  TOP w0.254: v2(128.42,113.47) v1(128.42,114.03)
  L4 w0.254: v1(145.58,121.88) 145.5,121.96 144.78,121.96 142.3,124.43 136.39,124.43 133.88,121.93 129.72,121.93 128.14,120.35 128.14,114.31 v1(128.42,114.03)
  BOTTOM w0.254: PR4629.2 145.58,122.07 v1(145.58,121.88) ; PR4633.2 128.42,113.1 v1(128.42,114.03)
PWR_VCORE_CSP: length 35.6
  TOP w0.254: v2(124.71,112.38) v1(124.71,111.82)
  L4 w0.254: v1(124.71,111.82) 125.98,111.82 126.19,112.02 126.19,119.61 126.82,120.24 126.82,120.7 129.4,123.29 132.87,123.29 135.16,125.58 142.87,125.58 144.47,123.98 145.96,123.98 146.25,123.7 v1(146.25,123.67)
  BOTTOM w0.254: v1(146.25,123.67) 146.26,123.68 146.94,123.68 147.45,123.18 PR4627.2 ; PG4707.1 v1(124.71,111.82)
PWR_VCORE_CSP_1A: length 7.1
  BOTTOM w0.203: PC4616.1 145.91,118.38 145.91,117.63 145.83,117.56 PU4601.29
  BOTTOM w0.254: PR4629.1 146.33,121.93 PR4627.1 147.44,121.74 v2(146.67,120.97) 146.68,120.97 PC4634.1 PC4616.1
PWR_VCORE_DISB#: length 2.4
  BOTTOM w0.203: PU4701.2 126.74,119.2 127.41,119.87 v2(127.51,119.87)
  BOTTOM w0.254: PR4704.2 127.7,119.87 v2(127.51,119.87)
PWR_VCORE_DRVON: length 47.5
  TOP w0.254: v2(118.36,115.35) v1(117.68,115.35)
  L4 w0.254: v1(148.59,117.46) 148.59,118.53 147.85,119.26 145.98,119.26 142.62,122.63 v1(142.62,122.67)
  L6 w0.254: v1(117.68,115.35) 118.34,116.02 118.34,119.6 120.29,121.55 122.94,121.55 123.53,122.14 125.77,122.14 126.59,121.32 127.23,121.32 128.49,120.06 v1(128.78,120.06) 128.78,122.36 129.34,122.92 139.22,122.92 140.11,123.81 141.1,123.81 142.24,122.67 v1(142.62,122.67)
  BOTTOM w0.203: v1(148.59,117.46) 148.23,117.1 PU4601.35
  BOTTOM w0.254: v1(117.68,115.35) 117.42,115.1 PR4808.1 ; v1(142.62,122.67) 142.5,122.54 PU5001.3 ; v1(128.78,120.06) 129.22,119.62 PR4704.1
PWR_VCORE_EN: length 4.2
  BOTTOM w0.127: PR4630.1 151.13,118.73 150.37,117.97 v2(150.24,117.97) 150.08,117.8 150.08,116.53 149.52,115.98 PU4601.37
PWR_VCORE_ICCMAX: length 3.6
  TOP w0.254: v2(141.3,113.95) 142.05,113.95 v1(142.11,113.89) 142.11,113.9 142.75,114.54 PR4658.1
  BOTTOM w0.203: v1(142.11,113.89) 142.2,113.98 PU4601.19
PWR_VCORE_ILIM: length 4
  TOP w0.254: PC4633.1 145.09,117.46 v1(145.09,118.1) PR4635.1 v2(146.1,118.88)
  BOTTOM w0.203: v1(145.09,118.1) 145.09,117.97 145.03,117.91 PU4601.27
PWR_VCORE_IOUT: length 4.6
  TOP w0.254: v1(146.56,118.22) 146.94,117.84 PR4628.1 ; PR4628.1 147.36,117.4 v2(147.8,117.84) ; PR4628.1 PC4613.1
  BOTTOM w0.203: v1(146.56,118.22) 146.24,117.9 146.24,117.49 146.23,117.49 PU4601.30
PWR_VCORE_NTC: length 22.8
  L6 w0.254: v1(139.4,112.1) 140.79,113.5 140.79,119.42 139.42,120.79 137.77,120.79 137.16,121.4 v1(130,121.4)
  BOTTOM w0.254: v1(130,121.4) 130,121.02 v2(129.79,120.81) 128.79,120.81 PR4653.2 ; PR4650.1 140.06,112.9 PR4652.1 140.02,112.1 v1(139.4,112.1)
PWR_VCORE_PHASED: length 4.5
  BOTTOM w0.203: PU4701.34 124.97,121.19 124.69,121.47 124.49,121.47 124.28,121.27 124.28,120.94 124.17,120.83 PU4701.32
  BOTTOM w0.508: PC4706.2 125.4,122.29 v2(124.99,121.88) 124.59,121.47
PWR_VCORE_PWM: length 27.4
  TOP w0.254: v1(127.1,118.3) 127.69,118.3 128.09,118.7 v2(128.27,118.7)
  L6 w0.254: v1(127.1,118.3) 128.47,118.3 129.41,119.24 129.41,121.8 129.62,122.01 139.6,122.01 139.8,121.8 141.07,121.8 142.27,120.61 142.27,115.61 142.29,115.58 v1(142.29,115.5)
  BOTTOM w0.203: PU4601.22 142.62,115.18 v1(142.29,115.5) ; PU4701.4 127,118.4 v1(127.1,118.3)
PWR_VCORE_ROSC_COREGT: length 3.3
  TOP w0.254: PR4664.1 142.37,111.87 v1(142.24,111.75) 142.24,111.59 141.76,111.11 v2(141.63,111.11)
  BOTTOM w0.203: v1(142.24,111.75) 142.44,111.95 142.73,111.95 142.76,111.98 PU4601.14
PWR_VCORE_ROSC_SAUS: length 4.6
  TOP w0.254: PR4659.1 142.94,112.63 142.11,112.63 v2(141.83,112.35) 141.6,112.13 v1(141.6,111.75)
  BOTTOM w0.203: PU4601.15 142.69,112.38 142.59,112.28 141.76,112.28 141.6,112.13 v1(141.6,111.75)
PWR_VCORE_SCLK: length 4.6
  TOP w0.14: v2(150.44,118.53) v1(149.83,118.53)
  BOTTOM w0.14: PU4601.34 147.83,117.31 148.41,117.89 149.2,117.89 v1(149.83,118.53) 150.24,118.93 PR4665.2
PWR_VCORE_SDIO: length 3.8
  TOP w0.14: v2(147.47,119.03) 147.88,118.63 v1(147.88,118.5)
  BOTTOM w0.14: PR4667.2 148.46,119.09 v1(147.88,118.5) 147.88,118.27 147.03,117.42 PU4601.32
PWR_VCORE_SNUB: length 1.3
  BOTTOM w0.508: PR4703.2 118.55,115.56 PC4709.1
PWR_VCORE_SW:
  vias: v2(119.38,112.2)
PWR_VCORE_TSENSE: length 7.9
  TOP w0.254: v1(141.3,116.55) 141.35,116.6 141.69,116.6 PC4628.1
  BOTTOM w0.203: v1(141.3,116.55) 141.88,115.96 142.62,115.96 143.01,115.58 PU4601.23
  BOTTOM w0.254: v1(141.3,116.55) 140.97,116.22 140.97,114.21 v2(140.84,114.08) 140.88,114.04 PR4650.2
PWR_VCORE_VCC: length 4.4
  BOTTOM w0.203: 127.71,117.36 127.53,117.18 126.87,117.18 PU4701.6
  BOTTOM w0.305: PC4708.1 128.02,118.4 v2(127.58,117.97)
  BOTTOM w0.508: 127.71,117.36 128.44,117.36 PR4702.1 128.5,117.56 128.5,118.39 PC4708.1
PWR_VCORE_VCC_R: length 4.3
  TOP w0.254: v2(141.68,109.81) 141.68,110.3 v1(142.37,110.98) PC4631.1
  BOTTOM w0.203: v1(142.37,110.98) 142.96,111.58 PU4601.13
  BOTTOM w0.254: v1(142.37,110.98) 141.72,110.98 PR4657.2
PWR_VCORE_VR_RDY: length 4.9
  BOTTOM w0.203: PU4601.38 149.66,115.58 149.86,115.78 149.86,115.82 150.37,116.33 150.37,117.21 150.56,117.4
  BOTTOM w0.254: PR4670.1 151.96,118.54 v2(151.51,118.1) 151.26,117.84 151,117.84 150.56,117.4
PWR_VCORE_VRHOT#: length 2.9
  BOTTOM w0.203: PR4668.1 147.24,118.87 v2(147.24,118.27) 147.24,118.22 147.04,118.02 147.04,118.02 146.63,117.61 PU4601.31
PWR_VCORE_VRMP: length 5.1
  TOP w0.254: v2(142.6,109) 143.07,109.47 PC4629.1 v1(142.37,110.09)
  BOTTOM w0.203: PU4601.12 143.19,110.92 v1(142.37,110.09)
  BOTTOM w0.254: v1(142.37,110.09) 142.56,109.9 PR4601.2
PWR_VCORE_VSN: length 4.9
  BOTTOM w0.203: PR4644.1 143.97,119.12 143.97,117.33 144.23,117.07 PU4601.25
  BOTTOM w0.254: PC4622.2 144.93,118.78 v2(144.91,118.76) 144.7,118.76 144.28,119.17 PR4644.1
PWR_VCORE_VSN_R: length 4
  BOTTOM w0.254: PC4622.1 144.79,120.97 v2(143.92,120.97) 143.92,120.17 PR4644.2 143.48,120.06 143.22,119.8 PR4645.2 143.04,119.76 PC4625.1
PWR_VCORE_VSP: length 4.2
  BOTTOM w0.203: PR4649.1 PR4647.1 143.17,117.31 143.57,116.9 PU4601.24
  BOTTOM w0.254: v2(142.19,116.37) 142.19,117.28 PR4647.1
PWR_VCORE_VSP_R: length 3.5
  BOTTOM w0.254: PC4627.2 142.11,119.87 PR4648.2 142.15,119.77 PC4625.2 142.22,118.93 PR4647.2 142.95,118.2 v2(143.15,117.99)
PWR_VCORE_VSP_RC: length 2.1
  BOTTOM w0.254: PR4649.2 141.4,118.93 PC4627.1 141.33,118.98 140.44,119.87 v2(140.44,119.9)
PWR_VDDQ:
  vias: v1(69.65,59.09) v1(69.65,58.33) v1(69.65,57.31) v1(69.65,56.42) v1(70.41,59.09) v1(70.41,58.33) v1(70.41,57.31) v1(70.41,56.42) v2(68.12,55.33)
PWR_VDDQ_BOOT: length 4.1
  TOP w0.203: PR5102.1 65,71.61 v2(64.49,71.11) 63.9,70.51 63.85,70.51 63.5,70.09 63.13,69.72 PU5101.1
PWR_VDDQ_BOOT_A: length 2.9
  TOP w0.635: v2(66.01,70.75) 66.89,70.75 PC5114.1 66.95,70.95 66.93,70.97 66.93,71.84 PR5102.2
PWR_VDDQ_EN: length 5.9
  TOP w0.254: PG5112.2 58.57,63.26 v2(58.24,63.59) 58.24,64.47 PR5105.1 59.16,65.39 59.56,65.39 60.46,66.29 PU5101.11
PWR_VDDQ_FB: length 3.9
  TOP w0.254: PR5107.2 PC5113.2 62.69,64.42 PR5101.1 62.34,64.88 62.36,64.88 62.68,65.21 PU5101.14
PWR_VDDQ_FB_A: length 10.1
  TOP w0.254: PG5113.1 66.01,56.35 66.01,62.29 v2(65.91,62.39) 65.46,62.85 64.14,62.85 63.58,63.41 PR5107.1 PC5113.1
PWR_VDDQ_ILMT: length 4.5
  TOP w0.254: PU5101.13 62.23,65.67 62.01,65.45 61.49,65.45 61.01,64.97 PR5106.2 PR5103.1 59.28,64.45 v2(59.21,64.37)
PWR_VDDQ_PG: length 5
  TOP w0.254: v2(59.49,67.14) 59.46,67.17 58.62,67.17 PG5114.2 58.5,66.73 59.02,66.21 PR5104.2 ; v2(59.49,67.14) 59.82,66.81 PU5101.10 ; v2(59.49,67.14) 59.61,67.26 PU5101.9
PWR_VDDQ_PH: length 6.2
  TOP w0.203: PU5101.6 59.9,68.61 v1(59.82,68.69)
  BOTTOM w0.508: v3(64.95,68.82) 64.82,68.69 v1(59.82,68.69)
  vias: v2(67.31,69.84) v3(65.89,68.79) v3(66.52,67.78) v3(66.5,66.81) v3(66.88,68.82) v3(67.51,67.8) v3(67.51,66.84) v3(68,68.87)
PWR_VDDQ_VCC: length 13.3
  TOP w0.254: 65,66.81 64.55,67.26 PU5101.17 ; 65,66.81 v2(65.19,66.62) 65.56,66.25 v1(65.56,65.9) PC5112.1 ; 65,66.81 PU5101.16 ; PR5103.2 v1(60.12,62.72)
  BOTTOM w0.254: v1(65.56,65.9) 65.15,65.9 63.65,64.4 60.66,64.4 60.12,63.87 v1(60.12,62.72)
PWR_VGA_CORE__BOOT1_1: length 2.4
  TOP w0.508: PR8515.2 PC8510.1 206.86,70.09 v2(206.86,71.03)
PWR_VGA_CORE__BOOT2_1: length 2.6
  TOP w0.508: PR8507.2 200.84,67.73 PC8507.1 200.84,70.06 v2(200.84,70.06)
PWR_VGA_CORE_BOOT1: length 3.6
  TOP w0.203: PU8501.21 207.58,66.04 208.25,66.71
  TOP w0.508: PR8515.1 208.25,68.44 v2(208.25,67.57) 208.25,66.71
PWR_VGA_CORE_BOOT2: length 4.1
  TOP w0.203: PU8501.30 203.06,66.04 202.79,65.77 202.27,65.77 201.83,66.21
  TOP w0.508: v2(199.82,66.76) 200.13,66.76 200.68,66.21 PR8507.1 201.83,66.21
PWR_VGA_CORE_COMP: length 7.1
  TOP w0.203: PU8501.19 208.46,64.89
  TOP w0.254: 208.46,64.89 209.37,65.8 211.24,65.8 PC8514.2 211.52,65.52 PR8528.1 PC8515.1 212.41,66.55 212.88,67.02 v2(212.88,67.3)
PWR_VGA_CORE_COMP_1: length 1.8
  TOP w0.254: v2(217.23,61.88) PC8516.1 PR8527.2
PWR_VGA_CORE_EN_R#: length 4
  TOP w0.254: PQ8501.6 211.22,53.59 211.68,54.06 v2(212.09,54.06) 212.15,54 PR8539.1 212.03,52.94 PQ8501.5
PWR_VGA_CORE_ENABLE: length 3.7
  TOP w0.203: PU8501.8 206.23,60.14
  TOP w0.254: PR8514.2 208.28,58.43 207.49,59.22 v2(207.49,59.24) 207.47,59.24 207.16,59.55 206.82,59.55 206.23,60.14
PWR_VGA_CORE_FB: length 15.8
  TOP w0.203: PU8501.18 208.77,64.49
  TOP w0.254: v1(216.05,61.76) 216.05,61.58 215.46,60.98 PR8527.1 215.1,61.3 214.72,61.3 PR8526.2 PR8525.1 ; PR8523.2 211.52,64.63 PC8514.1 211.14,65.01 v1(210.39,65.01) 210.13,65.01 209.88,65.26 v2(209.68,65.26) 209.55,65.26 208.77,64.49
  BOTTOM w0.254: v1(216.05,61.76) 215.93,61.88 213.51,61.88 v1(210.39,65.01)
PWR_VGA_CORE_FB2_R: length 6.3
  TOP w0.254: PC8515.2 214.12,66.41 v2(214.27,66.26) 214.76,66.26 v1(214.88,66.38) ; PR8526.1 215.07,62.35 v1(214.91,62.52)
  BOTTOM w0.254: v1(214.88,66.38) 214.88,66.23 214.91,66.2 v1(214.91,62.52)
PWR_VGA_CORE_FB_R: length 4.4
  TOP w0.254: PR8523.1 v1(214.12,64.63) 214.53,64.63 v2(214.83,64.93) ; PC8513.2 v1(214.12,62.72)
  BOTTOM w0.254: v1(214.12,62.72) v1(214.12,64.63)
PWR_VGA_CORE_IMON: length 7.9
  TOP w0.203: PU8501.10 207.13,60.93
  TOP w0.254: v1(209.71,57.55) 209.71,57.7 209.8,57.8 209.8,58.55 v2(209.52,58.84) 207.42,60.93 207.13,60.93
  BOTTOM w0.254: PC8511.1 PR8516.1 209.68,55.95 209.55,56.08 209.55,56.42 209.68,56.54 209.68,57.51 v1(209.71,57.55)
PWR_VGA_CORE_IMON_NB: length 3.8
  TOP w0.203: 203.56,60.18 203.83,60.46 PU8501.2
  TOP w0.254: 203.56,60.18 203.07,60.18 203,60.26 v1(202.69,60.26)
  BOTTOM w0.254: PR8508.2 203.48,61.24 v2(203.48,60.56) 203.17,60.26 v1(202.69,60.26)
PWR_VGA_CORE_ISEN1: length 15.4
  TOP w0.203: PU8501.13 208.47,62.49 208.84,62.11 208.84,61.78
  TOP w0.254: v1(215.18,56.75) 215.18,57.32 v2(215.12,57.38) 214.68,57.82 212.8,57.82 208.84,61.78
  BOTTOM w0.254: v1(215.18,56.75) 215.3,56.88 216.65,56.88 216.7,56.93 217.04,56.93 217.09,56.98 217.97,56.98 PR8519.1 PC8518.1 218.95,57.45 219.33,57.83 PR8543.1
PWR_VGA_CORE_ISEN2: length 8.9
  TOP w0.203: 208.45,61.41 208.45,61.95 208.31,62.08 PU8501.12
  TOP w0.254: 208.45,61.41 v2(210.85,59.01) 211.33,58.53 PC8517.1 212.34,57.07 PR8538.1 213.13,57.1 PR8522.1
PWR_VGA_CORE_ISUMN: length 6.3
  TOP w0.203: 210.59,61.63 210.28,61.63 208.62,63.29 PU8501.15
  TOP w0.254: PR8536.2 211.35,61.11 v2(211.35,61.63) 210.59,61.63
PWR_VGA_CORE_ISUMP: length 14.7
  TOP w0.203: PU8501.14 208.59,62.89 209.93,61.54 209.93,61.45
  TOP w0.254: 209.93,61.45 v2(211.18,60.2) 213.04,58.34 PC8522.1 PC8523.1 PR8532.1 216.28,58.34 PR8529.1 216.41,58.09 216.41,57.36 216.73,57.05 PR8517.1 216.66,56.03 216.66,55.88 PR8537.1
PWR_VGA_CORE_LGATE1: length 27.6
  TOP w0.203: PU8501.24 205.83,66.82 205.97,66.95 205.97,67.8 v3(205.46,68.31)
  TOP w0.508: PU8502.8 209.19,79.66 v3(208.25,79.66)
  L4 w1.016: v3(213.97,79.77) 213.13,79.77 213.03,79.66 v3(208.25,79.66) 204.47,79.66 203.84,79.03 203.84,74.92 205.61,73.14 205.61,68.46 v3(205.46,68.31)
  BOTTOM w0.508: v3(205.46,68.31) 204.8,68.97 v2(204.8,69.12) ; PU8503.8 213.82,79.61 v3(213.97,79.77)
PWR_VGA_CORE_LGATE2: length 30.8
  TOP w0.203: v3(203.94,67.6) 203.94,67.5 204.63,66.8 PU8501.27
  TOP w0.635: v3(213.97,83.2) PU8505.8
  L4 w1.016: v3(203.94,67.6) 203.94,68.44 202.56,69.81 202.56,79.72 203.78,80.93 206.91,80.93 208.18,82.2 v3(208.18,83.2) v3(213.97,83.2)
  BOTTOM w0.508: v2(203.33,68.21) v3(203.94,67.6)
  BOTTOM w0.635: v3(208.18,83.2) PU8504.8
PWR_VGA_CORE_LGATE_NB: length 2.8
  TOP w0.203: PU8501.34 201.89,64.08 201.47,63.66 201.24,63.66 v2(201.22,63.64) 200.44,63.64 PR8501.2
PWR_VGA_CORE_NTC: length 4.7
  TOP w0.254: PR8524.2 210.44,58.7 209.14,59.99 209.14,59.99 v2(209.14,60) 207.78,61.35 PU8501.11
PWR_VGA_CORE_NTC_NB: length 3.6
  TOP w0.203: v1(202.17,60.87) 202.23,60.93 PU8501.1
  BOTTOM w0.254: v1(202.17,60.87) 201.52,60.87 201.29,61.1 v2(201.29,61.35) 201.46,61.52 PR8506.2
PWR_VGA_CORE_PGOOD: length 16.7
  TOP w0.203: PU8501.20 207.78,65.4 208.79,66.41
  TOP w0.254: PC8512.1 v1(209.93,66.41) v2(209.17,66.41) 208.79,66.41
  BOTTOM w0.254: PR8520.1 PR8518.2 207.43,55.26 207.43,57 207.53,57.1 PR8544.2 207.53,57.78 209.42,59.68 209.42,65.31 209.93,65.82 v1(209.93,66.41)
PWR_VGA_CORE_PH1: length 34.9
  TOP w0.254: v1(215.13,56.07) 215.16,56.09 PR8517.2
  L6 w0.254: v1(215.13,56.07) 215.02,56.18 214.48,56.18 210.4,60.26 209.37,60.26 209.34,60.28 208.92,60.28 205.09,60.28 202.31,63.06 202.31,64.11 201.29,65.13 201.29,66.09 199.94,67.44 v1(199.87,67.44)
  BOTTOM w0.254: v1(199.87,67.44) 200.34,67.92 200.34,68.27 200.36,68.29 200.36,69.02 202.97,71.64 202.97,74.38 203.66,75.07 PG8507.1 ; v1(215.13,56.07) 215.25,56.18 v2(215.87,56.18) 216.07,56.37 216.86,56.37 216.91,56.42 217.25,56.42 217.27,56.45 217.79,56.45 PR8519.2
PWR_VGA_CORE_PH2: length 52.5
  TOP w0.254: PR8537.2 v2(213.77,54.77) 213.68,54.77 213.48,54.98 213.46,54.98 213.21,55.23 v1(213.11,55.23) PR8538.2
  L6 w0.254: v1(199.01,85.63) 198.6,85.63 197.61,84.65 197.61,82.03 196.98,81.39 196.98,70.39 198.31,69.05 198.31,65.73 200.53,63.5 200.53,61.07 201.29,60.31 201.29,59.34 202.84,57.8 203.94,57.8 204.34,58.2 210.13,58.2 v1(213.11,55.23)
  BOTTOM w0.254: PG8509.1 203.58,83.4 203.58,84.06 202.87,84.77 202.87,84.8 202.44,85.23 202.41,85.23 202.01,85.63 v1(199.01,85.63)
PWR_VGA_CORE_PHASE1: length 11.1
  TOP w0.203: PU8501.23 206.23,66.77 206.63,67.17 v3(206.63,67.68)
  TOP w0.508: v3(206.63,67.68) 206.76,67.8 PC8510.2
  L4 w1.016: v3(206.63,67.68) 206.88,67.93 206.88,75.75
  vias: v2(206.43,75.98) v3(205.46,77.2) v3(206.35,78.32) v3(206.35,77.2) v3(207.19,78.34) v3(207.19,77.2) v3(208.03,78.32) v3(208.03,77.18) v3(214.3,77.86) v3(214.3,76.97) v3(214.3,76.11) v4(208.05,76.13) v4(214.27,78.65)
PWR_VGA_CORE_PHASE2: length 22.5
  TOP w0.203: PU8501.28 204.23,66.54 203.76,67.02 203.35,67.02 v3(202.69,67.68)
  TOP w0.508: PC8507.2 202.69,68.17 v3(202.69,67.68)
  L4 w1.016: v3(202.69,67.68) 201.27,69.1 201.27,81.88 203.42,84.03 204.27,84.03
  vias: v2(205.27,83.71) v3(205.26,85.84) v3(205.26,84.95) v3(206.15,86.73) v3(206.15,85.84) v3(206.15,84.95) v3(207.04,86.73) v3(207.04,85.84) v3(207.04,84.95) v3(207.92,86.73) v3(207.92,85.84) v3(207.92,84.95)
PWR_VGA_CORE_PWROK: length 6.5
  TOP w0.203: PU8501.9 206.63,60.31
  TOP w0.254: v1(209.17,56.75) 209.17,57.31 v2(209.19,57.34) 209.17,57.36 209.17,58.34 207.45,60.06 206.88,60.06 206.63,60.31
  BOTTOM w0.254: v1(209.17,56.75) 208.74,57.19 PR8544.1
PWR_VGA_CORE_RTN: length 5.1
  TOP w0.203: PU8501.17 v2(209.09,64.08)
  TOP w0.254: PR8530.1 PC8501.2 210.76,64.37 209.38,64.37 v2(209.09,64.08)
PWR_VGA_CORE_SVC: length 4
  TOP w0.203: PU8501.3 204.23,60.26 v1(203.64,59.68)
  BOTTOM w0.254: PR8509.2 201.61,59.93 202.13,59.93 v2(202.26,59.8) 202.41,59.65 203.62,59.65 v1(203.64,59.68)
PWR_VGA_CORE_SVD: length 5.8
  TOP w0.203: PU8501.5 205.03,59.46
  TOP w0.254: v1(203.23,58.35) 203.4,58.53 204.04,58.53 204.06,58.55 v2(204.07,58.55) 204.08,58.56 204.13,58.56 205.03,59.46
  BOTTOM w0.254: PR8512.2 202.18,57.9 202.64,58.35 v1(203.23,58.35)
PWR_VGA_CORE_SVT: length 3.4
  TOP w0.203: 206.5,59.17 v2(206.03,59.64) 205.83,59.84 PU8501.7
  TOP w0.254: PR8513.2 207.39,58.53 206.76,59.17 206.5,59.17
PWR_VGA_CORE_UGATE1: length 17.9
  TOP w0.203: PU8501.22 206.63,66.56 206.91,66.84 v3(207.52,66.84)
  TOP w0.508: v2(207.65,72.63) 208.31,73.29 v3(208.31,73.7) 208.41,73.59 PU8502.1
  L4 w1.016: v3(207.52,66.84) 207.58,66.84 208.31,67.56 v3(208.31,73.7) v3(214.07,73.7)
  BOTTOM w0.508: PU8503.1 213.97,73.59 v3(214.07,73.7)
PWR_VGA_CORE_UGATE2: length 38.8
  TOP w0.203: PU8501.29 203.83,66.49 203.61,66.71 202.74,66.71 v3(202.56,66.53)
  TOP w0.635: v3(213.87,89.19) 213.84,89.22 PU8505.1
  L4 w1.016: v3(213.87,89.19) 208.18,89.19 v3(208.15,89.16) 206.4,89.16 200,82.77 200,68.58 200.21,68.37 200.21,68.36 202.04,66.53 v3(202.56,66.53)
  BOTTOM w0.508: v3(202.56,66.53) v2(201.75,66.53)
  BOTTOM w0.635: v3(208.15,89.16) 208.2,89.22 PU8504.1
PWR_VGA_CORE_UGATE_LX_NB: length 1.9
  TOP w0.203: 201.82,64.49 PU8501.33 ; PU8501.32 201.68,64.89
  vias: v2(201.17,64.86)
PWR_VGA_CORE_VDD: length 5
  TOP w0.203: PU8501.25 205.43,66.85 205.56,66.98 205.56,67.36 204.85,68.07
  TOP w0.254: 204.85,68.07 204.6,68.32 PC8509.1 ; PR8510.2 PC8509.1 ; PC8509.1 204.81,68.63 205.21,69.02 v2(205.49,69.02)
PWR_VGA_CORE_VDDIO: length 53.3
  TOP w0.203: PU8501.6 205.43,59.42
  TOP w0.254: 205.43,59.42 205.43,58.75 v1(205.42,58.74) 205.49,58.67 205.49,58.21 PR8546.2 205.8,58.09 206.06,58.34 PR8505.2 ; v1(176.2,64.76) 176.66,64.3 v2(176.78,64.3) 176.91,64.17 180.37,64.17 180.96,64.76 183.6,64.76 184,64.35 v1(184,63.48)
  L3 w0.254: v1(176.2,64.76) 176.07,64.88 175.51,64.88 175.01,65.39 172.8,65.39 v1(172.06,64.65)
  L4 w0.254: v1(205.42,58.74) 207.14,57.02 207.14,55.98 206.38,55.23 204.22,55.23 204.05,55.41 204.05,55.51 203.58,55.97 203.58,56.98 201.64,58.93 201.17,58.93 200.13,59.97 200.13,59.98 199.83,60.27 199.82,60.27 199.78,60.31 197.25,60.31 194.84,62.71 194.84,63.21 193.47,64.58 185.1,64.58 v1(184,63.48)
  BOTTOM w0.254: R7940.2 172.63,64.65 v1(172.06,64.65) ; v1(205.42,58.74) 205.61,58.54 PR8546.2 ; R7924.2 176.53,64.5 176.28,64.76 v1(176.2,64.76) 175.95,64.5 R7923.2
PWR_VGA_CORE_VO1: length 37.4
  TOP w0.254: PR8522.2 214.5,55.73 v1(214.5,55.48)
  L6 w0.254: v1(214.5,55.48) 214.46,55.48 210.19,59.75 209.16,59.75 209.13,59.78 204.88,59.78 201.68,62.98 201.68,64.03 200.66,65.04 200.66,65.93 199.36,67.23 199.36,67.97 v1(199.32,68)
  BOTTOM w0.254: PR8521.2 219.84,56.01 219.31,55.48 218.16,55.48 218.15,55.49 217.54,55.49 v2(217.12,55.92) 216.56,55.36 214.63,55.36 v1(214.5,55.48) ; v1(199.32,68) 199.83,68.51 199.83,69.22 202.41,71.8 PG8508.1
PWR_VGA_CORE_VO2: length 56.1
  L6 w0.254: v1(198.63,84.95) 198.12,84.44 198.12,81.82 197.49,81.18 197.49,70.6 198.82,69.27 198.82,68.21 198.82,67.79 198.85,67.75 198.85,67.02 200.15,65.72 200.15,64.83 201.04,63.94 201.04,61.28 201.8,60.52 201.8,60.18 202.41,59.57 202.65,59.57 203.05,59.17 203.86,59.17 203.93,59.24 209.98,59.24 214.38,54.85 214.71,54.85 215.77,55.91 v1(215.77,57.49)
  BOTTOM w0.254: v1(215.77,57.49) v2(216.85,57.49) 217.3,57.49 218.4,58.6 PR8540.2 219,58.85 PR8543.2 ; PG8510.1 203.07,83.3 203.07,83.83 201.83,85.08 198.75,85.08 v1(198.63,84.95)
PWR_VGA_CORE_VR_HOT#: length 4.9
  TOP w0.203: PU8501.4 204.63,59.96
  TOP w0.254: 204.63,59.96 204.63,59.94 203.86,59.17 v2(203.02,59.17) 202.67,59.17 v1(202.44,58.94)
  BOTTOM w0.254: PR8511.2 201.61,59.04 202.34,59.04 v1(202.44,58.94)
PWR_VGA_CORE_VSEN: length 7.4
  TOP w0.203: PU8501.16 208.85,63.68 208.9,63.63 208.93,63.63
  TOP w0.254: PR8534.1 PR8525.2 PC8513.1 211.58,62.72 PC8524.1 211.51,62.7 210.99,62.18 210.34,62.18 209.75,62.76 209.75,62.81 v2(209.72,62.85) 208.93,63.63
PWR_VGA_CORE_VSUM-: length 27.6
  TOP w0.254: PC8517.2 211.33,56.25 213.11,54.47 213.27,54.47 213.9,53.83 v2(215.29,53.83) 215.46,53.83 217.42,55.79 217.42,55.92 218.39,56.88 v1(220.6,56.88) ; v1(215.6,59.88) 215.62,59.88 215.85,60.11 PC8525.1 216.6,59.98 PR8533.2 216.53,59.23 PR8532.2 PC8523.2 PC8522.2 213.74,59.59 213.54,59.79 213.54,59.81 PR8536.1
  BOTTOM w0.254: 220.47,57.01 220.41,57.07 PR8521.1 PC8518.2 ; 220.47,57.01 220.47,58.28 220.12,59.11 220.12,59.22 219.97,59.37 218.86,59.37 PR8540.1 215.99,59.48 v1(215.6,59.88) ; 220.47,57.01 v1(220.6,56.88)
PWR_VGA_SNUB1: length 2.4
  TOP w0.508: v2(203.76,79.41) 203.91,79.56 PR8541.2 205.08,79.66 PC8506.1
PWR_VGA_SNUB2: length 2.4
  TOP w0.508: v2(203.76,81.01) 204.39,80.66 PR8542.2 205,80.63 PC8533.1
PWRGOOD_TEST: length 3
  TOP w0.102: v1(182.51,84.19) 182.51,83.49 182.75,83.25 182.75,82.92 182.18,82.34 R7601.1
  BOTTOM w0.102: GPU1.N10 v1(182.51,84.19)
PX_EN: length 2
  TOP w0.102: v1(176.78,75.3) 176.4,74.92 TP7904.1
  BOTTOM w0.102: v1(176.78,75.3) 177.03,75.54 177.03,76.04 177.32,76.33 GPU1.AB16
Q502_G: length 7.1
  TOP w0.127: Q501.D 79.7,52.24 78.99,52.94 77.18,52.94 Q502.G 76.52,51.45 R507.2 76.52,50.29 76.53,50.28 v2(76.53,49.44)
Q4009_G: length 5.9
  BOTTOM w0.102: R2728.2 R2729.2 41.93,7.66 v2(41.27,7.66) 39.9,7.66 38.64,6.4 Q2702.G
Q6204_G: length 9.4
  TOP w0.254: v1(128.84,9.36) 129.38,9.89 v2(129.39,9.89)
  L3 w0.254: v1(128.84,9.36) 130.68,7.52 v1(130.68,5.83)
  BOTTOM w0.254: R6512.1 128.84,9.19 v1(128.84,9.36) 129.01,9.36 129.08,9.43 130.58,9.43 130.81,9.21 Q6503.5 ; Q6503.2 130.81,5.95 v1(130.68,5.83)
Q6205_Q: length 9.3
  TOP w0.381: R6522.2 193.88,11.62 v2(193.93,11.67) 193.93,12 194.63,12.7 194.63,14.4 195.86,15.63 v1(196.34,15.63)
  BOTTOM w0.381: Q6505.D 194.56,14.34 194.97,14.74 195.78,14.74 196.34,15.31 v1(196.34,15.63)
Q9102.G: length 2.6
  TOP w0.127: R9129.1 257.44,29.84 v2(257.43,29.83) 257.08,29.48 Q9102.G
QSAN_0: length 45.9
  TOP w0.152: v1(163.47,89.27) 163.47,89.11 163.81,88.78 164.03,88.78 164.12,88.87 164.12,89.53 163.17,90.48 ; 163.17,90.48 162.44,91.21 161.63,91.21 161.32,90.9 161.32,88.65 160.68,88.02 160.68,85.81 160.4,85.53 158.23,85.53 157.94,85.81 157.94,87.9 154.82,91.03 154.82,93.11 155.57,93.86 155.57,97.99 155.68,98.11 156.2,98.63 158.52,98.63 158.91,99.02 162.14,99.02 164.16,101.04 164.16,101.98 163.63,102.51 163.45,102.51 163.32,102.39 VRAM1.B7 ; 163.17,90.48 v2(163.02,90.33)
  BOTTOM w0.089: v1(163.47,89.27) 163.47,89.1 163.81,88.76 164.71,88.76 165.37,88.1 165.44,88.1 165.7,88.1 165.72,88.12 166.34,88.12 166.39,88.08 166.65,88.08 166.7,88.12 167.14,88.12 167.19,88.08 167.45,88.08 167.5,88.12 167.84,88.12 167.84,88.12 168,88.12 168.2,87.92 168.2,87.69 168.29,87.6 GPU1.H27
QSAN_1: length 37.9
  TOP w0.152: VRAM1.G3 166.26,105.84 v1(165.95,105.84)
  L6 w0.127: v1(163.46,93.99) 163.44,93.97 163.2,93.97 163.03,94.14 163.03,95.61 163.18,95.76 164.12,95.76 164.24,95.63 164.24,95.36 164.59,95.01 165.64,95.01 166.07,95.44 166.07,96.65 165.79,96.93 163.71,96.93 163.58,97.05 163.58,97.52 163.7,97.64 165.78,97.64 166.09,97.95 166.09,98.51 165.82,98.78 163.73,98.78 163.62,98.89 163.62,99.25 163.73,99.37 166.2,99.37 166.46,99.63 166.46,100.65 166.14,100.97 164.62,100.97 164.5,101.08 164.5,101.97 164.64,102.11 166.6,102.11 166.87,102.38 166.87,102.76 166.5,103.13 166.5,103.42 166.25,103.67 165.95,103.67 165.84,103.78 165.84,104.01 165.95,104.12 166.14,104.12 166.41,104.4 166.41,105.09 166.39,105.12 166.39,105.4 v1(165.95,105.84)
  BOTTOM w0.102: GPU1.A27 168.52,91.75 167.13,93.14 166.03,93.14 166.01,93.12 165.86,93.12 165.41,92.66 165.01,92.66
  BOTTOM w0.152: v1(163.46,93.99) 163.52,93.99 163.78,93.73 164.01,93.73 164.31,93.43 164.31,93 164.63,92.68 164.65,92.68 164.67,92.66 165.01,92.66
QSAN_2: length 45.6
  BOTTOM w0.089: 169.04,95.92 169.19,95.78 169.19,94.82 169.6,94.41 170.39,94.41 171.53,93.26 171.64,93.15 171.93,92.87 172.04,92.76 172.04,91.74 172.04,91.73 172.04,91.47 171.72,91.14 GPU1.C23
  BOTTOM w0.152: 169.04,95.92 168.88,96.08 168.36,96.6 168.36,97.09 173.23,101.96 173.23,102.49 172.83,102.9 172.3,102.9 171.41,102 170.87,102 170.47,101.6 170.47,101.06 167.92,98.51 167.06,98.51 ; VRAM2.B7 166.26,102.36 166.04,102.36 165.58,101.89 165.58,101.21 165.21,100.84 164.98,100.84 163.39,99.25 162.7,99.25 162.15,98.7 160.79,98.7 159.99,97.9 159.53,97.9 159.23,97.6 159.23,97.14 158.54,96.45 158.54,96.27 158.89,95.93 159.07,95.93 160.51,97.37 160.51,97.37 161.28,98.14 162.46,98.14 162.83,98.51 167.06,98.51 ; 167.06,98.51 v2(167.06,98.69)
QSAN_3: length 39.5
  L4 w0.14: v1(175.31,95.33) 175.09,95.11 174.79,95.11 173.94,95.96 173.94,97.22 173.48,97.67 170.05,97.67 169.74,97.36 169.74,94.87 169.6,94.73 169.26,94.73 169.08,94.91 169.08,97.4 168.79,97.68 168.18,97.68 167.86,97.36 167.86,95.73 167.74,95.61 167.32,95.61 167.21,95.72 167.21,97.28 166.81,97.69 164.68,97.69 164.55,97.82 164.55,98.46 164.23,98.78 162.97,98.78 162.74,99.01 162.74,99.28 162.86,99.41 164.25,99.41 164.53,99.69 164.53,102.21 163.73,103 163.73,104.99 163.47,105.26 163.2,105.26 162.92,105.55 v1(162.92,105.7)
  BOTTOM w0.102: GPU1.C19 174.99,90.94 175.08,91.13 175.08,91.15 175.32,91.62 175.33,91.66 175.33,93.17 174.42,94.07 174.42,94.75 174.73,95.06 175.04,95.06 v1(175.31,95.33)
  BOTTOM w0.152: VRAM2.G3 163.32,106.1 v1(162.92,105.7)
QSAN_4: length 40.2
  TOP w0.152: VRAM4.G3 188.76,105.84 v1(188.45,105.84)
  L4 w0.14: v1(178.98,97.59) 179.13,97.74 179.51,97.74 179.72,97.53 179.72,95.76 180.33,95.15 180.44,95.03 180.44,94.07 180.4,94.03 180.4,93.19 180.52,93.08 180.99,92.61 182.79,92.61 183.68,93.5 185.07,93.5 188,96.42 192.29,96.42 192.32,96.45 192.33,96.45 193.36,97.47 193.36,97.49 193.36,97.5 193.36,97.54 193.38,97.56 193.38,99.22 193.36,99.24 193.36,100.96 191.54,102.77 191.22,102.77 189.96,104.03 189.95,104.03 189.94,104.05 189.58,104.05 189.01,104.61 189.01,104.7 188.99,104.72 188.99,105.09 188.98,105.11 188.98,105.39 188.54,105.84 v1(188.45,105.84)
  BOTTOM w0.102: 179.47,94.44 178.27,93.24 178.27,92.12 178.45,91.94 178.45,91.46 178.42,91.39 178.25,91.06 178.25,91.05 GPU1.C15
  BOTTOM w0.152: v1(178.98,97.59) 179.35,97.59 179.55,97.39 179.55,94.52 179.47,94.44
QSAN_5: length 45.7
  BOTTOM w0.102: GPU1.E9 182.5,90.42 182.5,90.68 182.63,90.98 182.65,91 182.65,91.39 182.58,91.56 182.58,91.71 182.73,91.91 182.73,92.6 183.33,93.2 183.6,93.2 185.05,94.65 185.33,94.65 185.58,94.41 185.97,94.41 186.22,94.66 186.22,94.91 186.22,94.91 186.22,95.62 186.37,95.77 186.41,95.77 186.46,95.77 186.5,95.81
  BOTTOM w0.152: 186.5,95.81 186.77,96.08 187.45,96.08 ; v2(187.45,95.92) 187.45,96.08 ; 187.45,96.08 192,96.08 192.63,95.46 193.73,95.46 194.3,94.88 194.3,94.42 195.87,92.85 197.18,92.85 197.46,93.14 197.46,93.8 197.18,94.08 196.73,94.08 196.61,94.19 196.61,94.56 196.74,94.69 196.91,94.69 196.91,94.69 197.23,94.69 197.64,95.11 197.64,97.91 198.52,98.79 199.19,99.46 199.19,101.28 198.91,101.57 193.48,101.57 193.27,101.36 192.41,101.36 192.04,100.98 192.04,100.26 191.67,99.89 189.91,99.89 189,100.79 188.74,100.79 188.61,100.92 188.61,102.02 188.74,102.15 188.97,102.15 VRAM3.B7
QSAN_6: length 38.1
  L6 w0.127: v1(189.22,92.78) 189.22,93.05 189.24,93.08 189.24,95.58 189.24,95.79 188.91,96.12 187.59,96.12 187.58,96.13 187.37,96.13 186.97,95.72 186.97,95 187.24,94.73 187.71,94.73 187.84,94.6 187.84,94.13 187.73,94.01 187.46,94.01 187.25,94.01 186.97,93.74 186.97,92.65 186.86,92.54 186.47,92.54 186.3,92.71 186.3,96.03 187.09,96.83 188.57,96.83 188.83,97.09 188.83,98.1 188.57,98.36 187.19,98.36 186.92,98.63 186.92,99.26 187.04,99.37 188.17,99.37 188.44,99.65 188.44,100.24 188.17,100.52 187.04,100.52 186.92,100.63 186.92,101.97 186.5,102.39 185.6,102.39 185.23,102.75 185.23,103.23 185.34,103.35 185.88,103.35 186.2,103.67 186.2,105.14 185.93,105.41 185.7,105.41 v1(185.42,105.7)
  BOTTOM w0.102: GPU1.C5 185.88,91.04 185.88,91.29 185.75,91.53 185.75,91.73 186,91.99 186.48,92.22 186.68,92.32 186.88,92.42 187.84,92.42 188.1,92.16 188.72,92.16 188.96,92.4 188.96,92.7 189.03,92.78 v1(189.22,92.78)
  BOTTOM w0.152: v1(185.42,105.7) 185.82,106.1 VRAM3.G3
QSAN_7: length 45.3
  TOP w0.152: v2(188.26,88.17) 188.26,88.35 ; 188.26,88.35 188,88.35 187.58,88.77 187.58,90.76 186.9,91.44 186.9,92.09 187.31,92.49 187.55,92.49 187.77,92.71 187.77,93.1 188.18,93.51 190.18,93.51 190.74,94.07 191.34,94.07 192.06,93.36 192.94,93.36 193.36,92.93 193.36,91.97 193.49,91.84 194.08,91.84 194.4,92.17 196.98,92.17 197.11,92.3 197.11,97.33 197.11,98.21 196.98,98.34 196.35,98.34 196.22,98.21 196.22,97.89 195.95,97.61 192.37,97.61 191.64,98.33 188.3,98.33 188.02,98.62 188.02,98.92 187.14,99.81 187.14,101.9 186.4,102.63 186.11,102.63 185.82,102.34 VRAM4.B7 ; 188.26,88.35 189.04,88.35 189.24,88.16 189.24,87.76 189.11,87.64 v1(188.86,87.64)
  BOTTOM w0.102: GPU1.H4 186.52,87.48 186.67,87.33 186.88,87.33 186.99,87.44 186.99,87.81 187.06,87.88 187.21,87.94 187.38,87.94 187.53,87.87 187.57,87.87 187.58,87.87 187.95,87.87 188.19,88.1 189.15,88.1 189.27,87.99 189.27,87.76 189.15,87.64 v1(188.86,87.64)
QSAP_0: length 45.5
  TOP w0.152: 160.41,87.89 160.41,85.92 160.29,85.8 158.34,85.8 158.21,85.92 158.21,88.02 155.08,91.14 155.08,93 155.83,93.75 155.83,97.88 156.31,98.37 158.63,98.37 159.02,98.75 162.25,98.75 164.43,100.93 164.43,102.09 163.62,102.9 VRAM1.C7 ; 160.41,87.89 160.41,88.13 161.05,88.76 161.05,91.01 161.52,91.48 162.55,91.48 164.39,89.64 164.39,88.76 164.14,88.51 163.52,88.51 v1(163.49,88.48) ; 160.41,87.89 v2(160.2,87.89)
  BOTTOM w0.089: v1(163.49,88.48) 163.58,88.57 164.63,88.57 165.29,87.91 165.52,87.91 165.78,87.91 165.8,87.93 166.26,87.93 166.31,87.89 166.39,87.89 166.65,87.89 166.73,87.89 166.78,87.93 167.06,87.93 167.11,87.89 167.53,87.89 167.58,87.93 167.92,87.93 168.01,87.84 168.01,87.69 167.93,87.62 167.74,87.62 GPU1.H28
QSAP_1: length 38.3
  TOP w0.152: VRAM1.F3 166.04,105.3 v1(165.94,105.2)
  L6 w0.127: v1(163.42,93.32) 163.42,93.42 163.3,93.55 163.28,93.55 163.11,93.72 163.09,93.72 162.78,94.03 162.78,95.72 163.07,96.01 164.22,96.01 164.5,95.73 164.5,95.46 164.7,95.26 165.53,95.26 165.81,95.54 165.81,96.55 165.69,96.67 163.6,96.67 163.33,96.95 163.33,97.62 163.6,97.89 165.68,97.89 165.84,98.06 165.84,98.4 165.71,98.53 163.63,98.53 163.37,98.79 163.37,99.36 163.63,99.62 166.09,99.62 166.21,99.74 166.21,100.54 166.04,100.71 164.51,100.71 164.25,100.98 164.25,102.07 164.54,102.36 166.49,102.36 166.62,102.49 166.62,102.65 166.25,103.02 166.25,103.31 166.15,103.41 165.84,103.41 165.58,103.67 165.58,104.12 165.84,104.38 166.03,104.38 166.16,104.5 166.16,104.99 v1(165.94,105.2)
  BOTTOM w0.102: 165.01,92.4 165.07,92.4 165.13,92.46 165.49,92.46 165.95,92.91 166.09,92.91 166.12,92.94 167.04,92.94 168.17,91.81 168.17,91.48 168.52,91.13 GPU1.C27
  BOTTOM w0.152: v1(163.42,93.32) 163.57,93.46 163.9,93.46 164.04,93.32 164.04,92.89 164.17,92.76 164.17,92.76 164.54,92.4 165.01,92.4
QSAP_2: length 45.2
  BOTTOM w0.089: GPU1.A23 171.85,91.73 171.85,92.68 171.57,92.96 171.53,92.99 171.45,93.07 170.31,94.22 169.52,94.22 169,94.74 169,95.59 168.83,95.76
  BOTTOM w0.152: VRAM2.C7 166.52,102.84 166.31,102.62 165.93,102.62 165.31,102.01 165.31,101.32 165.1,101.11 164.87,101.11 163.28,99.51 162.59,99.51 162.04,98.96 160.68,98.96 159.88,98.16 159.42,98.16 158.96,97.71 158.96,97.25 158.7,96.98 158.28,96.56 158.28,96.16 158.78,95.66 159.18,95.66 160.7,97.18 160.78,97.26 161.4,97.87 162.57,97.87 162.94,98.24 165.18,98.24 ; 165.18,98.24 v2(165.18,98.08) ; 165.18,98.24 168.03,98.24 170.74,100.95 170.74,101.49 170.98,101.74 171.52,101.74 172.41,102.63 172.72,102.63 172.97,102.38 172.97,102.08 168.09,97.2 168.09,96.49 168.69,95.9 168.83,95.76
QSAP_3: length 39.8
  L4 w0.14: v1(175.31,94.57) 175.03,94.85 174.68,94.85 173.67,95.85 173.67,97.11 173.37,97.41 170.17,97.41 170.01,97.25 170.01,94.76 169.71,94.46 169.15,94.46 168.81,94.8 168.81,97.29 168.68,97.41 168.29,97.41 168.13,97.25 168.13,95.62 167.85,95.35 167.21,95.35 166.95,95.61 166.95,97.17 166.7,97.42 164.57,97.42 164.28,97.71 164.28,98.35 164.12,98.51 162.86,98.51 162.47,98.9 162.47,99.39 162.75,99.68 164.14,99.68 164.26,99.8 164.26,102.1 163.47,102.89 163.47,104.88 163.36,104.99 162.97,104.99 v1(162.89,104.91)
  BOTTOM w0.102: GPU1.E19 175.28,90.79 175.28,91.1 175.51,91.55 175.53,91.64 175.53,93.25 174.62,94.16 174.62,94.67 174.81,94.85 175.02,94.85 v1(175.31,94.57)
  BOTTOM w0.152: v1(162.89,104.91) 163.28,105.3 VRAM2.F3
QSAP_4: length 40.9
  TOP w0.152: VRAM4.F3 188.54,105.3 v1(188.44,105.2)
  L4 w0.14: v1(178.98,98.42) 179.39,98.01 179.62,98.01 179.98,97.64 179.98,95.87 180.71,95.14 180.71,93.96 180.67,93.92 180.67,93.3 181.1,92.87 182.68,92.87 183.57,93.76 184.96,93.76 187.89,96.69 192.18,96.69 192.21,96.71 192.22,96.71 193.09,97.59 193.09,97.6 193.1,97.61 193.1,97.66 193.11,97.67 193.11,99.11 193.09,99.13 193.09,100.85 191.43,102.51 191.11,102.51 190.95,102.66 189.85,103.76 189.8,103.76 189.78,103.78 189.47,103.78 188.75,104.5 188.75,104.59 188.73,104.61 188.73,104.98 188.51,105.2 v1(188.44,105.2)
  BOTTOM w0.102: 179.61,94.21 179.56,94.21 179.52,94.17 179.48,94.17 178.48,93.16 178.48,92.21 178.65,92.03 178.65,91.41 178.6,91.3 178.45,91.01 178.45,90.64 178.44,90.64 GPU1.E15
  BOTTOM w0.152: 179.81,95.62 179.81,97.69 179.09,98.42 v1(178.98,98.42) ; 179.81,95.62 v2(179.96,95.62) ; 179.81,95.62 179.81,94.41 179.61,94.21
QSAP_5: length 45.7
  BOTTOM w0.102: GPU1.D10 182.16,90.44 182.3,90.74 182.45,91.08 182.45,91.34 182.37,91.51 182.37,91.78 182.53,91.98 182.53,92.69 183.24,93.4 183.51,93.4 184.96,94.86 185.42,94.86 185.66,94.61 185.88,94.61 186.02,94.74 186.02,94.83 186.02,95.7 186.31,96
  BOTTOM w0.152: 186.31,96 186.66,96.35 190.55,96.35 ; v2(190.55,96.48) 190.55,96.35 ; 190.55,96.35 192.11,96.35 192.74,95.72 193.84,95.72 194.57,94.99 194.57,94.53 195.98,93.12 197.07,93.12 197.2,93.25 197.2,93.68 197.07,93.81 196.62,93.81 196.35,94.08 196.35,94.67 196.63,94.96 196.8,94.96 196.8,94.96 197.12,94.96 197.38,95.22 197.38,98.02 198.41,99.05 198.92,99.57 198.92,101.17 198.8,101.3 193.59,101.3 193.38,101.09 192.52,101.09 192.3,100.87 192.3,100.15 191.78,99.62 189.8,99.62 188.89,100.53 188.63,100.53 188.34,100.81 188.34,102.22 VRAM3.C7
QSAP_6: length 38.4
  L6 w0.127: v1(188.47,92.81) 188.62,92.81 188.99,93.18 188.99,95.69 188.8,95.87 187.48,95.87 187.22,95.61 187.22,95.11 187.35,94.98 187.82,94.98 188.09,94.7 188.09,94.02 187.83,93.76 187.35,93.76 187.22,93.63 187.22,92.54 186.96,92.28 186.36,92.28 186.04,92.6 186.04,96.14 186.98,97.08 188.47,97.08 188.58,97.19 188.58,97.99 188.47,98.11 187.09,98.11 186.67,98.52 186.67,98.73 186.67,99.37 186.93,99.63 188.06,99.63 188.19,99.75 188.19,100.13 188.06,100.26 186.93,100.26 186.67,100.52 186.67,101.86 186.4,102.13 185.49,102.13 184.98,102.65 184.98,103.34 185.24,103.6 185.77,103.6 185.95,103.78 185.95,105.03 185.82,105.16 185.64,105.16 v1(185.39,104.91)
  BOTTOM w0.102: v1(188.47,92.81) 188.66,92.81 188.76,92.71 188.76,92.48 188.64,92.36 188.18,92.36 187.93,92.62 186.84,92.62 186.6,92.5 185.88,92.16 185.73,92 185.55,91.82 185.55,91.47 185.68,91.24 185.68,90.76 GPU1.D6
  BOTTOM w0.152: v1(185.39,104.91) 185.78,105.3 VRAM3.F3
