# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PEG_RX_CPU_P3: length 59.4
  TOP w0.127: v2(153.8,78.7) 153.96,78.7 ; 153.96,78.7 153.96,77.75 154.26,77.46 C7307.2 ; 153.96,78.7 153.96,78.95 155.51,80.5 155.51,86.1 154,87.62 153.38,87.62 152.96,88.03 151.74,89.25 151.74,90.22 149.13,92.83 148.2,92.83 147.74,93.29 146.86,94.17 146.86,95.71 144.3,98.27 130.89,98.27 125.6,92.99 125.6,86.98 124.08,85.45 124.08,83.83 v1(124.24,83.67)
  BOTTOM w0.127: CPU1.F15 123.79,83.54 123.91,83.67 v1(124.24,83.67)
PEG_RX_GPU_N0: length 13.5
  TOP w0.127: v2(158.32,72.86) 158.19,72.99 ; 158.19,72.99 159.75,74.55 161.57,74.55 162.06,74.05 162.06,73.16 162.83,72.4 163.51,72.4 v1(164.22,73.11) ; 158.19,72.99 157.95,72.74 157.15,72.74 C7302.1
  BOTTOM w0.127: GPU1.AG31 166.33,72.21 164.41,72.21 164.03,72.59 164.03,72.93 v1(164.22,73.11)
PEG_RX_GPU_N1: length 15
  TOP w0.127: v2(159.79,72.88) 159.79,73.06 ; 159.79,73.06 160.72,73.06 162.07,71.72 162.15,71.64 165.07,71.64 165.31,71.88 165.65,71.88 165.9,71.64 167.34,71.64 167.78,72.08 v1(168.03,72.08) ; 159.79,73.06 159.39,73.06 157.41,71.08 157.11,71.08 157.05,71.02 C7304.1
  BOTTOM w0.102: v1(168.03,72.08) 168.18,72.23 168.18,72.54 168.22,72.58 168.22,72.82 167.84,73.2 GPU1.AF28
PEG_RX_GPU_N2: length 16.5
  TOP w0.127: v1(168.92,72.8) 168.64,73.08 168.35,73.08 168.34,73.08 168.24,73.08 164.95,76.38 159.07,76.38 158.22,75.52 ; 158.22,75.52 157.42,74.72 156.68,74.72 156.57,74.62 155.98,74.62 C7306.1 ; 158.22,75.52 v2(158.34,75.4)
  BOTTOM w0.127: GPU1.AF26 169.32,72.95 169.17,72.8 v1(168.92,72.8)
PEG_RX_GPU_N3: length 17
  TOP w0.127: v2(166.27,77.43) 166.14,77.3 ; 166.14,77.3 168.52,74.93 168.64,74.92 168.65,74.92 v1(168.92,75.19) ; 166.14,77.3 165.42,78.02 161.93,78.02 161.8,78.15 161.8,78.71 161.54,78.98 161.08,78.98 160.81,78.71 160.81,78.15 160.69,78.02 155.96,78.02 C7308.1
  BOTTOM w0.127: GPU1.AD26 v1(168.92,75.19)
PEG_RX_GPU_P0: length 13.9
  TOP w0.127: 158.9,74.03 159.65,74.79 161.67,74.79 162.31,74.15 162.31,73.26 162.93,72.64 163.41,72.64 163.58,72.82 v1(163.58,73.16) ; 158.9,74.03 157.85,72.98 157.06,72.98 C7301.1 ; 158.9,74.03 v2(158.78,74.15)
  BOTTOM w0.127: GPU1.AH30 166.64,71.6 166.27,71.97 164.31,71.97 163.79,72.49 163.79,72.95 v1(163.58,73.16)
PEG_RX_GPU_P1: length 14.9
  TOP w0.127: C7303.1 156.9,71.32 157.31,71.32 157.73,71.74 ; v2(157.61,71.87) 157.73,71.74 ; 157.73,71.74 159.29,73.31 160.82,73.31 162.25,71.88 164.97,71.88 165.21,72.12 165.75,72.12 166,71.88 167.24,71.88 167.36,72 167.36,72.26 167.07,72.55 167.07,72.73 167.31,72.96 167.49,72.96 v1(167.78,72.67)
  BOTTOM w0.102: GPU1.AG29 167.51,72.4 v1(167.78,72.67)
PEG_RX_GPU_P2: length 16.3
  TOP w0.127: 156.95,74.97 157.32,74.97 158.97,76.62 165.05,76.62 168.34,73.32 168.35,73.32 168.65,73.32 v1(168.92,73.59) ; 156.95,74.97 156.58,74.97 156.47,74.86 155.95,74.86 C7305.1 ; 156.95,74.97 v2(156.95,75.12)
  BOTTOM w0.127: GPU1.AF27 168.91,73.59 v1(168.92,73.59)
PEG_RX_GPU_P3: length 17.2
  TOP w0.127: 167.75,75.35 168.42,74.68 168.64,74.68 v1(168.92,74.4) ; 167.75,75.35 v2(167.61,75.22) ; 167.75,75.35 165.32,77.78 161.83,77.78 161.56,78.05 161.56,78.61 161.44,78.74 161.18,78.74 161.05,78.61 161.05,78.05 160.79,77.78 155.96,77.78 C7307.1
  BOTTOM w0.127: v1(168.92,74.4) 168.84,74.33 168.71,74.33 168.52,74.52 GPU1.AD27
PEG_TX_CPU_N0: length 11.5
  BOTTOM w0.089: CPU1.B17 122.61,86.34 122.61,87.1 123.05,87.55 123.05,88.38 123.09,88.41 123.09,88.42
  BOTTOM w0.127: C1606.2 124.13,96.03 124.13,93.37 124.07,93.31 ; 123.09,88.42 123.09,89.31 123.25,89.47 123.25,92.49 124.07,93.31 ; v2(124.21,93.18) 124.07,93.31
PEG_TX_CPU_N1: length 10.6
  BOTTOM w0.089: 123.66,88.44 123.66,88.34 123.63,88.31 123.63,87.58 123.42,87.38 123.42,87.25 123.08,86.9 123.08,86.05 123.19,85.94 123.19,85.63 CPU1.D16
  BOTTOM w0.127: v2(125.73,92.82) 125.59,92.96 ; 125.59,92.96 125.66,93.02 125.66,93.64 C1608.2 ; 125.59,92.96 125.27,92.64 124.94,92.64 124,91.7 124,89.06 123.66,88.72 123.66,88.44
PEG_TX_CPU_N2: length 10
  BOTTOM w0.089: 122.32,88.41 122.32,88.39 122.36,88.35 122.36,87.74 121.89,87.27 121.89,86.58 121.93,86.49 121.93,86.29 121.89,86.2 121.89,85.93 121.94,85.79 121.94,85.15 CPU1.D17
  BOTTOM w0.127: 122.26,88.94 122.26,91.92 121.72,92.47 C1610.2 ; 122.26,88.94 v2(122.07,88.94) ; 122.26,88.94 122.26,88.47 122.32,88.41
PEG_TX_CPU_N3: length 9.5
  BOTTOM w0.089: 120.7,88.73 120.71,88.72 120.71,86.55 120.72,86.54 CPU1.B19
  BOTTOM w0.127: v2(117.81,92.97) 117.98,92.97 ; 117.98,92.97 117.98,91.53 118.21,91.3 118.69,91.3 120.7,89.29 120.7,88.73 ; 117.98,92.97 C1612.2
PEG_TX_CPU_P0: length 10.7
  BOTTOM w0.089: CPU1.A17 122.42,86.8 122.42,87.18 122.86,87.63 122.86,88.39 122.84,88.41 122.84,88.42
  BOTTOM w0.127: 123.89,95.44 123.89,96.2 C1605.2 ; 123.89,95.44 123.89,93.47 123.01,92.59 123.01,89.57 122.84,89.41 122.84,88.42 ; 123.89,95.44 v2(123.72,95.44)
PEG_TX_CPU_P1: length 10.6
  BOTTOM w0.089: CPU1.C16 122.89,85.61 122.79,85.5 122.65,85.5 122.55,85.61 122.55,85.88 122.89,86.22 122.89,86.98 123.23,87.32 123.23,87.46 123.44,87.66 123.44,88.42 123.42,88.43 123.42,88.44
  BOTTOM w0.127: 123.83,91.88 124.84,92.88 125.17,92.88 125.42,93.12 125.42,93.7 C1607.2 ; 123.83,91.88 123.76,91.8 123.76,89.16 123.42,88.82 123.42,88.44 ; 123.83,91.88 v2(123.7,92.01)
PEG_TX_CPU_P2: length 10
  BOTTOM w0.089: CPU1.C17 122.12,85.62 122.12,85.83 122.07,85.96 122.07,86.16 122.1,86.25 122.1,86.52 122.09,86.55 122.07,86.6 122.07,86.61 122.07,87.2 122.53,87.66 122.53,88.35 122.56,88.39 122.56,88.41
  BOTTOM w0.127: C1609.2 122.69,93.84 122.69,93.46 122.57,93.33 122.09,93.33 121.96,93.21 121.96,92.57 122.3,92.23 ; 122.3,92.23 122.5,92.02 122.5,88.57 122.56,88.51 122.56,88.41 ; 122.3,92.23 v2(122.43,92.36)
PEG_TX_CPU_P3: length 9.1
  BOTTOM w0.089: 120.94,88.98 120.91,88.95 120.91,86.79 CPU1.A19
  BOTTOM w0.127: 118.59,91.54 118.79,91.54 120.94,89.39 120.94,88.98 ; 118.59,91.54 118.31,91.54 118.22,91.63 118.22,93.33 118.8,93.9 C1611.2 ; 118.59,91.54 v2(118.59,91.7)
PEG_TX_GPU_N0: length 65.4
  BOTTOM w0.127: v2(124.64,98.84) 124.49,98.99 ; 124.49,98.99 125.58,100.07 135.9,100.07 136.52,99.45 140.18,99.45 141.96,97.68 141.96,97.37 140.23,95.64 140.23,95.26 140.55,94.94 140.93,94.94 142.79,96.8 143.05,96.8 144.79,95.05 144.79,94.79 148.67,90.92 152.61,90.92 152.83,91.13 153.92,91.13 158.79,86.26 158.79,80.62 164.6,74.81 164.6,74.66 165.13,74.14 166.38,74.14 GPU1.AE31 ; 124.49,98.99 123.89,98.39 123.89,98.13 124.02,98 124.67,98 124.79,97.87 124.79,97.59 124.54,97.34 C1606.1
PEG_TX_GPU_N1: length 66.4
  BOTTOM w0.089: 164.83,73.53 164.9,73.53 165.13,73.29 165.43,72.99 165.58,72.99 165.89,72.69 166.35,72.69 166.39,72.72 166.65,72.72 166.71,72.67 167.12,72.67 167.41,72.95 167.41,73.35 167.72,73.66 GPU1.AD28
  BOTTOM w0.127: 164.83,73.53 157.73,80.62 157.73,86.26 153.72,90.28 153.03,90.28 152.93,90.17 148.36,90.17 144.44,94.08 140.34,94.08 138.95,95.48 138.95,96.11 140.51,97.68 140.51,97.86 140.33,98.04 140.15,98.04 138.59,96.47 138.21,96.47 135.51,99.17 131.72,99.17 ; C1608.1 125.85,95.01 125.85,97.32 127.71,99.17 131.72,99.17 ; 131.72,99.17 v2(131.72,98.99)
PEG_TX_GPU_N2: length 67.3
  BOTTOM w0.127: C1610.1 122.02,95.17 122.02,96.4 ; GPU1.AC31 166.38,75.46 165.36,75.46 159.91,80.91 159.91,86.55 154.33,92.12 152.42,92.12 152.2,91.91 149.08,91.91 145.92,95.06 145.92,95.32 143.61,97.63 143.61,97.81 144.67,98.87 144.67,99.25 144.35,99.57 143.97,99.57 142.91,98.51 142.73,98.51 140.8,100.44 136.93,100.44 136.3,101.08 124.28,101.08 122.02,98.82 122.02,96.4 ; 122.02,96.4 v2(121.84,96.4)
PEG_TX_GPU_N3: length 71.3
  BOTTOM w0.102: 165.4,76.34 165.41,76.33 165.41,76.3 165.78,75.94 165.92,75.94 166.12,76.04 166.41,76.15 166.68,76.15 166.83,76.06 166.98,76.06 167.22,76.17 GPU1.AB28
  BOTTOM w0.127: v2(118.03,95.82) 118.21,95.82 ; 118.21,95.82 118.21,96.4 119.71,97.9 120.09,97.9 120.43,97.57 120.61,97.57 120.79,97.75 120.79,97.93 120.45,98.26 120.45,98.64 123.69,101.88 136.57,101.88 137.08,101.37 143.85,101.37 146.69,98.54 146.69,95.36 149.39,92.66 151.89,92.66 152.11,92.87 154.64,92.87 160.66,86.86 160.66,81.22 164.85,77.03 164.85,76.9 165.4,76.34 ; 118.21,95.82 118.21,95.02 C1612.1
PEG_TX_GPU_P0: length 66.2
  BOTTOM w0.127: GPU1.AF30 166.92,74.08 166.63,74.38 165.23,74.38 164.85,74.76 164.85,74.91 159.03,80.72 159.03,86.36 154.02,91.37 152.73,91.37 152.51,91.16 148.77,91.16 145.03,94.89 145.03,95.15 143.15,97.04 142.69,97.04 140.83,95.18 140.65,95.18 140.47,95.36 140.47,95.54 142.2,97.27 142.2,97.78 140.28,99.7 136.62,99.7 136,100.32 125.48,100.32 125.27,100.11 ; v2(125.15,100.24) 125.27,100.11 ; 125.27,100.11 123.65,98.49 C1605.1
PEG_TX_GPU_P1: length 66.5
  BOTTOM w0.089: GPU1.AE29 167.44,74 167.53,73.91 167.53,73.74 167.23,73.44 167.23,73.04 167.05,72.86 166.79,72.86 166.73,72.91 166.31,72.91 166.27,72.88 165.97,72.88 165.66,73.18 165.51,73.18 164.95,73.74
  BOTTOM w0.127: v2(133.68,99.58) 133.68,99.41 ; 133.68,99.41 135.61,99.41 138.31,96.72 138.49,96.72 140.05,98.28 140.43,98.28 140.75,97.96 140.75,97.58 139.19,96.01 139.19,95.58 140.44,94.33 144.54,94.33 148.46,90.41 152.82,90.41 152.93,90.52 153.82,90.52 157.98,86.36 157.98,80.72 164.95,73.74 ; 133.68,99.41 127.61,99.41 125.61,97.42 125.61,95.8 125.43,95.62 125,95.62 124.87,95.49 124.87,95.13 C1607.1
PEG_TX_GPU_P2: length 67.4
  BOTTOM w0.127: 122.26,97.93 122.26,98.72 124.38,100.84 136.2,100.84 136.83,100.2 140.7,100.2 142.63,98.27 143.01,98.27 144.07,99.33 144.25,99.33 144.43,99.15 144.43,98.97 143.37,97.91 143.37,97.53 145.68,95.22 145.68,94.96 148.98,91.67 152.3,91.67 152.52,91.88 154.23,91.88 159.66,86.45 159.66,80.81 165.26,75.22 166.5,75.22 GPU1.AD30 ; 122.26,97.93 122.26,95.16 C1609.1 ; 122.26,97.93 v2(122.43,97.93)
PEG_TX_GPU_P3: length 71.5
  BOTTOM w0.102: 165.23,76.17 165.26,76.17 165.69,75.74 165.97,75.74 166.2,75.85 166.45,75.95 166.62,75.95 166.75,75.87 166.76,75.86 166.76,75.86 166.77,75.86 167.03,75.86 167.3,75.98 167.61,75.98 167.72,75.87 167.72,75.71 167.61,75.6 GPU1.AC29
  BOTTOM w0.127: C1611.1 118.45,95.21 118.45,96.3 119.26,97.11 ; 119.26,97.11 119.81,97.66 119.99,97.66 120.33,97.33 120.71,97.33 121.03,97.65 121.03,98.03 120.69,98.37 120.69,98.54 123.79,101.64 136.47,101.64 136.98,101.13 143.75,101.13 146.44,98.44 146.44,95.26 149.29,92.42 151.99,92.42 152.21,92.63 154.54,92.63 160.41,86.76 160.41,81.12 164.6,76.93 164.6,76.8 165.23,76.17 ; 119.26,97.11 v2(119.38,96.99)
PERN0/SATA_B-: length 7.3
  TOP w0.127: v2(103,114.92) 102.4,114.92 v1(102.39,114.93) 102.11,115.21 102.11,115.5 101.68,115.92 ED6201.7 ED6201.4 99.4,115.92 99.33,115.85 98.7,115.85 R6207.2
  BOTTOM w0.127: WWAN1.43 103.32,114.75 103.07,114.49 102.83,114.49 v1(102.39,114.93)
PERP0/SATA_B+: length 8.2
  TOP w0.127: R6205.2 98.92,115.61 99.29,115.61 99.45,115.44 ED6201.5 ED6201.6 101.23,115.44 101.46,115.68 101.58,115.68 101.87,115.4 101.87,114.85 v1(101.6,114.58) 101.33,114.31 v2(100.99,114.31)
  BOTTOM w0.127: v1(101.6,114.58) 101.75,114.43 102.55,114.43 102.73,114.25 WWAN1.41
PETN0/SATA_A-: length 7.3
  TOP w0.127: C6205.2 98.7,117.08 99.29,117.08 99.41,116.96 ED6201.2 ED6201.9 101.37,116.96 101.61,117.2 101.79,117.2 v1(102.27,116.72) 102.79,116.72 v2(102.9,116.62)
  BOTTOM w0.127: WWAN1.47 103.48,115.75 103.21,116.02 103.21,116.13 102.62,116.72 v1(102.27,116.72)
PETP0/SATA_A+: length 7.3
  TOP w0.127: C6204.2 98.93,117.33 99.29,117.33 99.41,117.44 ED6201.1 ED6201.10 102.09,117.44 v1(102.23,117.59) 102.11,117.71 v2(102.11,118.22)
  BOTTOM w0.127: WWAN1.49 103.43,116.25 102.23,117.45 v1(102.23,117.59)
PIRQA#: length 17.9
  TOP w0.102: RN2001.3 136.35,51.65 135.43,52.57 v2(135.43,52.77) 135.43,53.65 131.9,57.19 131.89,57.19 v1(127.91,61.17)
  BOTTOM w0.102: v1(127.91,61.17) 127.91,61.19 127.86,61.23 127.86,61.74 126.65,62.96 126.07,62.96 125.97,63.05 125.93,63.05 125.73,63.25 125.73,64.01 CPU1.BB11
PLL_ANALOG_IN: length 4.6
  BOTTOM w0.102: GPU1.AA1 187.9,77.02 187.9,76.92 189.32,75.5 190.86,75.5 TP7902.1
PLT_RST#: length 531.4
  TOP w0.102: v1(39.17,57.87) 39.56,58.27 R6116.1 39.56,60.73 41.53,62.7 v1(41.53,63.41) ; v1(55.27,94.96) 54.69,94.96 53.73,94 53.73,93.42 54.04,93.11 54.04,89.6 53.54,89.09 52.85,89.09 51.71,87.95 48.19,87.95 47.57,87.34 47.57,87.31 47.32,87.06 47.29,87.06 46.51,86.28 v1(42.8,86.28) ; Q9101.S 238.46,29.35 238.43,29.32 v1(238.38,29.32) ; R6215.2 90.6,115.82 90.11,116.3 v1(90.11,116.35) ; R2410.2 204.47,42.43 202.29,44.61 202.29,46.93 202.49,47.13 202.49,47.64 198.93,51.19 v1(198.93,55.08)
  L3 w0.102: v1(58.04,117.46) 56.39,119.11 52.58,119.11 51.56,120.13 49.2,120.13 48.9,119.82 48.9,111.36 55.5,104.76 55.5,102.42 54.99,101.92 54.99,100.7 55.27,100.42 v1(55.27,94.96) ; v1(30.48,26.78) 30.48,27.2 26.09,31.59 26.09,44.1 32.47,50.48 32.47,52.8 v1(32.89,53.22) ; v1(41.53,63.41) 41.12,63.41 38.15,66.38 38.15,70.95 37.08,72.02 37.08,77.07 36.12,78.04 36.12,79.97 35.03,81.06 34.95,81.06 33.55,82.46 33.55,84.01 34.88,85.33 37.34,85.33 38.29,86.28 v1(42.8,86.28) ; v1(238.38,29.32) 238,29.32 237.01,30.31 237.01,33.94 233.99,36.97 233.99,38.87 231.91,40.95 229.9,40.95 226.81,44.04 215.17,44.04 212.6,46.61 212.6,47.38 211.53,48.45 210.11,48.45 209.4,49.16 209.4,50.07 207.23,52.23 201.78,52.23 v1(198.93,55.08)
  L4 w0.102: v1(279.78,22.1) 279.55,22.34 279.17,22.34 278.08,23.43 278.08,27.32 277.01,28.39 269.92,28.39 269.49,28.81 268.86,28.81 266.95,30.72 266.95,32.75 265.3,34.4 263.91,34.4 263.8,34.5 261.29,34.5 260.5,33.72 258.49,33.72 257.12,32.35 257.12,31.51 254.63,29.01 251.62,29.01 250.7,29.93 241.02,29.93 240.44,29.35 238.4,29.35 v1(238.38,29.32) ; v1(198.93,55.08) 198.02,55.08 196.22,56.88 194.18,56.88 193.32,57.74 186.69,57.74 186.03,57.08 184.85,57.08 184.55,56.79 180.65,56.79 179.59,57.85 179.59,60.4 178.16,61.83 173.6,61.83 169.48,65.96 165.55,65.96 164.44,67.07 164.44,67.35 164.41,67.38 164.41,68.44 163.83,69.02 163.83,69.09 162.02,70.91 159.55,70.91 159.17,71.28 159.01,71.28 158,72.3 158,73.59 v1(156.29,75.3) ; v1(58.04,117.46) 68.2,117.46 68.96,116.7 75.56,116.7 78.86,113.4 82.94,113.4 85.88,116.35 v1(90.11,116.35) 90.41,116.35 90.84,116.77 91.51,116.77 92.28,116.01 98.83,116.01 101.8,118.98 102.74,118.98 104.27,117.46 104.27,111.1 105.49,109.88 105.49,108.6 106.4,107.69 106.4,103.82 108.31,101.92 121.62,101.92 122.2,101.33 140.72,101.33 150.09,91.96 150.09,86.11 149.43,85.45 149.43,84.75 150.04,84.14 150.04,83.17 149.86,82.99 149.86,81.75 149.99,81.62 149.99,79.16 149.63,78.8 149.34,78.8 v1(147.93,77.39)
  L6 w0.102: v1(66.07,2.45) 64.59,0.98 62.41,0.98 61.76,1.62 48.02,1.62 42.8,6.84 42.8,8.11 41.91,9 39.74,9 37.08,11.66 37.08,15.07 36.42,15.73 34.29,15.73 32.99,17.03 32.99,18.35 32.81,18.54 31.48,18.54 31.21,18.81 30.51,18.81 29.11,20.2 29.11,22.24 30.48,23.61 v1(30.48,26.78) ; v1(32.89,53.22) 32.89,53.54 35.09,55.74 35.09,55.74 37.56,58.2 38.03,58.2 38.36,57.87 v1(39.17,57.87)
  BOTTOM w0.102: v1(156.29,75.3) 156.15,75.3 156.08,75.23 R1715.1 C1701.1 EC1703.1 R1713.1 152.29,75.73 152.17,75.73 152.1,75.8 150.38,75.8 148.79,77.39 v1(147.93,77.39) D7601.1 ; v1(42.8,86.28) 42.8,86.22 42.55,85.96 42.55,85.53 RN5501.3 ; Q9103.D 69.82,5.56 R9125.1 68.81,6.49 68.02,7.27 67.11,7.27 66.93,7.1 66.93,4.05 v2(66.65,3.77) 66.07,3.19 v1(66.07,2.45) ; v1(55.27,94.96) 55.05,95.17 R3112.1 ; v1(238.38,29.32) 238.44,29.26 R9110.1 ; v1(279.78,22.1) 280.65,22.1 281.11,21.64 R6802.1
PLT_RST#_DEBUG: length 14.1
  TOP w0.127: DB1.7 287.23,29.5 288.67,29.5 v1(288.72,29.45)
  BOTTOM w0.127: R6802.2 v2(283.08,21.45) 283.39,21.45 284,22.06 285.6,22.06 288.04,24.5 288.04,27.04 288.72,27.72 v1(288.72,29.45)
PLT_RST#_LAN: length 13.4
  L4 w0.127: v1(48.01,96.38) 48.2,96.19 48.47,96.19 48.72,95.94 49.08,95.94 49.91,96.77 49.91,97.51 v1(52.24,99.84)
  BOTTOM w0.127: v1(52.24,99.84) 52.24,97.5 v2(52.83,96.92) 53.36,96.92 54.15,96.12 R3112.2 ; v1(48.01,96.38) 47.21,95.58 LOM31.19
PLT_RST#_Q: length 33.3
  TOP w0.102: v1(241.43,33.26) 242,32.69 242,31.86 241.24,31.1 Q9101.D 241.68,30.34 242.19,30.85 243.98,30.85 244.45,31.31 244.45,31.38 244.68,31.61 245.13,31.61 245.44,31.3 245.8,31.3 246,31.51 v1(246.3,31.51) ; v1(258.9,34.53) 258.9,34.78 258.52,35.16 R9114.2 R9113.1
  L3 w0.102: v1(258.9,34.53) 258.86,34.53 258.05,35.34 246.99,35.34 246.13,34.48 246.13,34.12 246.33,33.92 246.33,31.53 v1(246.3,31.51)
  BOTTOM w0.102: R9136.1 246.06,31.75 v1(246.3,31.51) ; v1(241.43,33.26) 241.8,32.89 241.8,31.6 241.43,31.23 v2(241.43,31.23) 241.43,31.23 240.35,30.15 R9110.2
PLT_RST#_Q_TPM1: length 3.2
  TOP w0.102: U9101.3 255.88,34.78 v2(256.44,34.22) 256.72,34.5 256.72,35.15 R9113.2
PLT_RST#_Q_TPM2: length 3.3
  TOP w0.102: v1(246.89,31.23) 247.13,30.98 U9104.17
  BOTTOM w0.102: v1(246.89,31.23) 246.95,31.29 R9136.2 246.95,32.85 246.39,33.41 v2(246.39,33.41)
PLT_RST_NGFF#: length 4.3
  TOP w0.102: R6116.2 38.67,57.58 AFTP5805.1 37.97,56.88 37.88,56.88 v1(37.85,56.85)
  BOTTOM w0.102: v1(37.85,56.85) 37.72,56.72 37.72,56.12 37.6,56 WLAN1.52
PM_LAN_ENABLE: length 319.8
  TOP w0.127: v1(33.76,94.47) 33.76,93.94 33.27,93.46 31.97,93.46 R3111.1 31.38,94.71 31.93,95.27 Q3101.G ; v1(51.97,26.73) 52.15,26.73 v2(52.98,27.56) 56.9,31.49 120.58,31.49 126.61,37.53 148.27,37.53 156.43,29.36 165.82,29.36 167.33,27.85 169.71,27.85 169.86,28 v1(170.41,28)
  L3 w0.127: v1(51.97,26.73) 49.78,26.73 42.83,19.78 42.1,19.78 41.97,19.66 29.22,19.66 v1(26.29,22.59) ; v1(170.41,28) 171.34,28.93 182.35,28.93 182.51,28.78 187.54,28.78 190.28,26.03 190.28,24.06 191.03,23.31 191.03,21.99 192.86,20.17 193.89,20.17 194.85,19.2 201.09,19.2 201.75,19.86 202.11,19.86 202.68,20.43 204.91,20.43 206.83,22.36 v1(206.83,22.92)
  L4 w0.127: v1(26.29,22.59) 26.06,22.82 26.06,26.1 25.02,27.14 25.02,28.31 20.57,32.76 20.57,33.89 21.54,34.85 21.54,36.1 20.57,37.07 20.57,41.01 22.48,42.91 22.48,47.86 21.97,48.37 21.97,48.88 22.23,49.13 22.23,54.6 22.1,54.72 22.1,55.23 22.23,55.36 22.23,56.16 23.28,57.22 25.13,57.22 26.23,58.33 27.62,58.33 28.36,59.07 28.36,60.93 28.1,61.19 26.02,61.19 24.19,63.03 24.19,72.31 32,80.12 32,82.41 31.88,82.54 31.88,92.31 33.76,94.19 v1(33.76,94.47)
  L6 w0.127: v1(215.01,9.33) 214.96,9.38 214.96,10.44 213.87,11.53 213.76,11.53 213.5,11.79 213.5,12.62 210.97,15.15 210.97,15.52 210.18,16.32 209.02,16.32 209.02,16.32 208.89,16.32 206.31,18.9 206.31,20.11 206.25,20.17 206.25,20.78 206.38,20.91 206.38,20.91 206.6,21.14 206.61,21.14 206.76,21.29 206.76,22.85 v1(206.83,22.92)
  BOTTOM w0.127: v1(215.01,9.33) 215.01,8.49 215.33,8.18 219.52,8.18 220.41,7.29 R2491.2
PM_LAN_ENABLE_C: length 3.3
  TOP w0.127: v2(35.26,96.71) 35.26,97.64 ; 35.26,97.64 R3110.2 ; 35.26,97.64 35.31,97.58 C3122.2 37.43,97.58 Q3104.G
PM_PCH_PWROK: length 17.1
  BOTTOM w0.127: v2(118.59,49.29) 118.76,49.45 R1706.2 R1732.2 EC1713.2 119.38,52.63 119.72,52.63 120.05,52.96 120.05,52.97 121.27,54.19 121.27,60.74 120.88,61.13 120.88,63.73 120.69,63.93 120.69,64.46 CPU1.BA20
PM_RSMRST#: length 285.8
  TOP w0.127: v1(159.25,72.19) 157.4,70.34 157.13,70.34 156.83,70.04 155.5,70.04 155.29,69.84 v1(154.94,69.84) ; v1(64.34,101.74) 64.34,101.66 64.36,101.64 64.36,100.85 64.59,100.62 R9904.1 ; v1(122.14,54.85) 122.14,51.17 121.77,50.8 RN1703.1 121.4,50.62 121.6,50.41 123.01,50.41 123.19,50.59 124.4,50.59 124.82,50.17 v2(124.82,49.4) 125.48,48.75 v1(125.48,47.61)
  L3 w0.127: v1(179.8,42.02) 179.8,42.02 179.59,42.02 179.13,41.55 174.46,41.55 171.89,44.12 171.02,44.12 170.23,44.9 169.17,44.9 167.47,46.61 166.57,46.61 159.94,53.23 159.94,56 158.14,57.81 158.14,63.67 154.94,66.87 v1(154.94,69.84)
  L6 w0.127: v1(71.75,102.98) 72.17,103.4 72.17,103.9 74.05,105.78 79.5,105.78 80.39,106.67 81.92,106.67 82.55,106.03 83.57,106.03 84.2,106.67 85.98,106.67 86.87,105.78 89.28,105.78 89.6,105.46 93.81,105.46 96.08,107.72 96.08,111.73 98.18,113.84 99.5,113.84 99.81,113.53 99.81,109.83 98.49,108.51 98.49,107.12 98.99,106.61 100.1,106.61 101.95,104.76 105.61,104.76 109.63,100.73 116.37,100.73 119.26,97.84 125.28,97.84 127.13,95.99 127.13,95.9 129.48,93.55 129.48,92.87 129.74,92.61 130.42,92.61 132.02,91.01 133.36,91.01 135.57,88.8 136.41,88.8 142.15,83.06 142.18,83.06 145.61,79.62 145.61,74.7 146.8,73.51 148.14,73.51 150.53,71.13 150.53,70.76 150.79,70.5 151.15,70.5 152.04,71.38 153.39,71.38 v1(154.94,69.84) ; v1(179.8,42.02) 179.81,42.02 179.81,40.9 180.58,40.13 180.58,35.12 180.53,35.07 180.53,34.59 181.05,34.07 v1(181.05,32.5)
  BOTTOM w0.089: CPU1.AY17 121.79,64.59 121.79,64.32 121.78,64.28 121.61,63.85 121.61,63.74 121.54,63.67
  BOTTOM w0.127: v1(125.48,47.61) 128.1,47.61 150.28,25.44 173.99,25.44 v1(181.05,32.5) ; v1(64.34,101.74) 65.68,103.08 71.65,103.08 v1(71.75,102.98) ; v1(159.25,72.19) 159.18,72.12 R1720.2 ; 121.54,63.67 121.31,63.44 121.31,61.31 121.99,60.64 121.99,55.01 122.14,54.86 v1(122.14,54.85) 122.14,54.84 121.95,54.65 121.95,51.76 R1704.1 ; v1(154.94,69.84) 154.71,70.06 154.59,70.06 Q1701.3 153.2,69.34 153.18,69.33 R1702.1
PM_RSMRST#_M: length 4
  BOTTOM w0.127: Q1702.6 153.1,72.75 v2(152.96,72.6) 152.96,71.73 R1737.2 153.34,71.59 153.85,72.1 Q1702.5
PM_RSMRST#_R: length 2.6
  BOTTOM w0.127: v2(158.14,73.04) 157.67,72.57 R1720.1 157.65,72.1 Q1702.2
PM_RSMRST_PWRGD_XDP: length 7.5
  TOP w0.127: XDP1.39 61,97.88 61.28,98.16 61.63,98.16 62.33,98.87 64.85,98.87 65.53,99.55 v2(65.53,99.71) 65.58,99.76 65.58,100.53 R9904.2
PM_SLP_S0_STG#: length 4
  BOTTOM w0.127: R4019.2 217,42.94 v2(216,42.94) 215.05,42.94 R9937.2 215.92,43.88 U4003.1
PM_SLP_S3_STG#: length 4.4
  BOTTOM w0.127: R4020.2 213.3,41.51 R4018.1 213.68,42.57 v2(213.94,42.83) 214.05,42.83 215.26,44.05 U4003.2
POWER_SW_IN#: length 5.2
  TOP w0.102: v2(218.69,19.67) 218.49,19.47 217.69,19.47 R2432.2 C2426.1 215.95,19.48 R2451.1 215.37,20.06 215.13,20.06 214.72,20.47 KBC24.127
PQ3802_1: length 3.8
  TOP w0.508: PR4309.2 30.31,65.96 29.69,66.58 v2(29.54,66.58)
  TOP w0.635: PR4309.2 30.48,65.07 PR4302.1 30.42,63.83 PQ4302.B
PQ3809_D: length 15.2
  TOP w0.254: v1(47.75,110.73) 48.36,110.73 v2(48.44,110.81) 48.39,110.86 48.39,111.82 47.75,112.46 PR4314.2 ; PQ4306.3 54.04,101.75 54.45,102.16 v1(54.63,102.16)
  L3 w0.254: v1(47.75,110.73) 47.75,109.04 v1(54.63,102.16)
PQ4405_2: length 16.5
  TOP w0.102: v1(245.03,17.31) 245.21,17.13 v2(245.21,16.62) 245.03,16.44 PQ4405.2 ; v1(236.32,9.74) 236.4,9.82 PR4462.1 236.97,10.58 PR4463.1
  L4 w0.102: v1(245.03,17.31) 244.25,17.31 241.2,14.26 241.2,13.34 240.95,13.09 238.76,13.09 236.32,10.65 v1(236.32,9.74)
PQ4405_3: length 2.6
  TOP w0.14: PR4455.1 243.38,16.19 v2(243.97,16.77) 244.38,16.36 PQ4405.3
PQ4405_5: length 4
  TOP w0.102: PQ4405.5 245.03,12.29 PR4413.2 244.84,11.17 PC4426.1 243.61,10.91 v2(243.46,11.06)
PQ4405_6: length 4.2
  TOP w0.102: PQ4405.6 246.33,13.57 v2(246.86,13.04) 246.38,12.56 246.18,12.56 245.73,12.11 PR4450.1 245.73,11.07 PC4426.2
PQ4408_C: length 3.8
  TOP w0.102: PQ4408.C 236.14,7.91 237.13,8.9 v2(237.16,8.9) 237.16,8.93 237.86,9.62 PR4462.2 238.7,9.82 PR4451.1
PQ4408_E: length 8.2
  TOP w0.102: PQ4408.E 237.15,5.71 239.47,8.04 239.47,9.31 v2(239.7,9.54) 240.08,9.15 240.87,9.15 241.66,9.94 PR4431.2 PR4433.1
PQ8206_3: length 3.7
  TOP w0.254: PQ8501.3 207.25,52.29 v2(206.86,51.91) 206.38,51.42 PR8545.1
PROC_SELECT#: length 5.5
  BOTTOM w0.089: 95.23,88.32 95.52,88.03 95.52,85.85 CPU1.C64
  BOTTOM w0.102: 95.23,88.32 94.17,89.37 93.58,89.37 R603.1
PROJECT_ID2: length 25.5
  TOP w0.102: R2017.2 145.15,58.9 v2(144.84,59.21) 145.42,59.79 R2018.1 145.74,60.37 145.44,60.67 145.44,61.15 145.14,61.44 143.36,61.44 139.88,64.91 136.4,64.91 134.32,62.82 131.37,62.82 130.85,63.35 v1(128.18,63.35)
  BOTTOM w0.102: CPU1.BA8 127.58,65.04 127.58,63.95 v1(128.18,63.35)
PS_0: length 7
  TOP w0.102: v2(169.67,74.03) 169.72,74.08 170.68,74.08 R7927.1 170.7,74.08 171.56,74.08 C7918.1 171.64,74.09 172.72,75.17 v1(173.35,75.17) 173.55,75.36 R7926.2
  BOTTOM w0.102: v1(173.35,75.17) 174.62,75.17 175.06,75.6 GPU1.AC19
PS_1: length 6
  TOP w0.102: C7919.1 172.4,72.16 R7929.1 172.4,73.96 v2(172.72,74.28) 173.23,74.28 v1(173.35,74.15) 173.99,74.79 R7928.2
  BOTTOM w0.102: v1(173.35,74.15) 173.67,74.47 174.06,74.47 174.39,74.8 GPU1.AD19
PS_2: length 13.9
  TOP w0.102: v1(176.98,74.69) 176.98,74.79 177.18,74.99 178.64,74.99 179.03,74.59 181.47,74.59 182.07,75.19 182.07,77.48 181.54,78.01 v2(181.54,78.39) 181.99,78.85 182.77,78.85 R7931.1 182.95,79.02 R7930.2 184.33,79.58 C7920.1
  BOTTOM w0.102: v1(176.98,74.69) 176.89,74.69 176.52,74.32 176.52,74.32 176.32,74.12 GPU1.AE17
PS_3: length 5.2
  TOP w0.102: C7921.1 R7933.1 174.42,72.34 v1(174.42,73.03) 173.59,73.03 v2(173.43,73.19) 173.43,73.54 173.79,73.9 R7932.2
  BOTTOM w0.102: v1(174.42,73.03) 174.42,73.5 GPU1.AE20
PS_ID: length 272.6
  TOP w0.203: v1(214.25,35.55) 214.24,35.55 213.91,35.87 KBC24.36
  TOP w0.635: PD4302.3 33.53,63.87 v1(34.04,64.37) 34.23,64.18 PR4305.2 35.75,64.18 36.07,63.87 v2(36.2,63.87) 36.2,63.04 PR4304.2 ; v1(54.02,32.41) 54.13,32.41 54.31,32.59 54.9,32.59 54.91,32.59 56.33,32.59 56.58,32.34 117.56,32.34 120.71,32.34 126.4,38.03 148.48,38.03 156.64,29.87 166.03,29.87 167.55,28.35 169.5,28.35 169.65,28.51 169.93,28.51 v1(170.02,28.6)
  L3 w0.635: v1(183.18,35.3) 184.28,36.39 188.55,36.39 189.68,37.53 192.89,37.53 193.54,36.88 200.01,36.88 201.16,38.03 201.73,38.03 202.63,37.13 212.66,37.13 v1(214.25,35.55) ; v1(183.54,29.53) 183.5,29.56 170.98,29.56 v1(170.02,28.6) ; v1(54.02,32.41) 54.02,31.68 42.62,20.29 41.54,20.29 41.41,20.17 29.79,20.17 29.27,20.68 29.27,23.34 29.31,23.38 v1(29.31,23.48)
  L4 w0.635: v1(29.31,23.48) 29.31,28.59 27.94,29.96 24.31,29.96 23.39,30.87 23.39,35.52 21.34,37.58 21.34,40.22 23.39,42.28 23.39,46.25 27.24,50.09 32.94,50.09 33.48,50.62 33.71,50.78 33.83,50.83 33.84,50.85 33.87,50.85 33.98,50.89 34.46,50.99 34.7,50.99 35.67,51.96 35.67,52.54 35.52,52.7 35.52,56.62 35.83,56.92 35.83,62.58 34.04,64.37 v1(34.04,64.37)
  L6 w0.635: v1(183.54,29.53) 183.54,30.82 183.18,31.18 v1(183.18,35.3)
PS_ID_R: length 62.1
  TOP w0.508: AFTP4304.1 31.31,71.23 v1(31.19,71.11)
  L3 w0.508: v1(31.19,71.11) 30.29,72 30.29,75.23 29.72,75.8 29.72,83.3 30.54,84.12 30.54,94.26 34.19,97.9 43.74,97.9 46.25,100.41 v1(46.25,101.31)
  BOTTOM w0.508: v1(31.19,71.11) 31.14,71.15 PR4317.1 ; DCIN1.4 51.06,111.5 49.28,109.71 49.28,106.03 49.91,105.4 49.91,103.54 47.75,101.38 46.35,101.38 46.27,101.31 v1(46.25,101.31)
PS_ID_R1: length 6.2
  TOP w0.102: PR4306.2 33.02,68.82 33.53,68.31 33.53,65.8 PQ4301.S 34.8,65.45 PR4305.1 35.27,65.07 v2(35.92,65.72)
PS_ID_R2: length 11.5
  TOP w0.635: PR4309.1 29.91,67.42 PD4303.1 ; PD4303.1 31.46,68.22 PR4306.1 32.07,68.18 PQ4301.D ; PD4303.1 PD4303.2 v2(29.91,71.2) 29.31,71.2 29.09,70.98 28.95,70.98 28.91,71.03 v4(28.83,71.03)
  BOTTOM w0.635: PR4317.2 29.82,71.72 29.13,71.03 v4(28.83,71.03)
PS_S3CNTRL: length 5.1
  TOP w0.127: Q4001.6 50.94,54.15 50.83,54.26 50.42,54.26 50.29,54.14 Q4001.5 50.29,52.41 49.81,51.93 v2(49.68,51.93) 48.88,51.93 R4004.2
PSID_DISABLE#_R_C: length 6.6
  TOP w0.635: PR4303.2 29.52,61.07 29.77,61.33 29.77,61.59 PQ4302.C 30.61,62.53 31.27,62.53 31.53,62.79 31.53,62.88 31.91,63.26 v2(31.91,64.07) PQ4301.G
PSYS: length 4.9
  TOP w0.102: PR4671.2 149.73,110.35 v2(150.19,110.81) v1(150.69,111.3)
  BOTTOM w0.102: v1(150.69,111.3) 150.69,111.35 149.66,112.38 PU4601.46
PTP_DIS#: length 37.6
  TOP w0.127: KBC24.90 202.33,25.14 202.89,24.58 203.2,24.58 203.47,24.31 203.47,23.69 v1(203.35,23.57) ; v1(190.25,9.89) 189.99,9.64 v2(189.36,9.64) 187.83,9.64 187.2,10.27 184.15,10.27 v1(184.02,10.15)
  L4 w0.127: v1(203.35,23.57) 203.35,19.31 202.81,18.77 202.81,17.58 202.55,17.32 202.19,17.32 200.9,16.04 200.9,15.96 200.64,15.69 200.27,15.69 199.73,16.24 199.28,16.24 198.84,16.69 198.47,16.69 198.02,16.24 194.44,16.24 193.01,14.82 193.01,12.45 193.05,12.41 193.05,11.94 192.66,11.54 192.66,10.65 191.52,9.51 190.63,9.51 v1(190.25,9.89)
  BOTTOM w0.127: D2405.K 184.02,10.02 v1(184.02,10.15)
PTP_INT#_EC: length 3.5
  TOP w0.127: KBC24.33 216.33,37.9 v2(216.33,38.31) 216.33,39.22 R2431.1
PU8201_36: length 4.2
  TOP w0.203: 201.8,62.85 201.84,62.89 PU8501.37 ; 201.8,62.85 201.8,63.1 201.98,63.29 PU8501.36 ; 201.8,62.85 201.8,62.6 201.91,62.49 ; 201.91,62.49 201.23,62.49 v2(201.12,62.37) ; 201.91,62.49 PU8501.38
PU8201_39: length 3.1
  TOP w0.203: PU8501.40 201.87,61.68 ; 201.87,61.68 201.75,61.8 201.75,61.97 201.87,62.08 PU8501.39 ; 201.87,61.68 201.65,61.68 v2(201.12,61.15)
PURE_HW_SHUTDOWN#: length 328.5
  TOP w0.102: v1(164.47,36.56) 163.58,35.68 157.5,35.68 156.62,36.55 156.3,36.88 156.21,36.97 155.8,37.38 150.59,42.57 147.22,42.57 123.66,42.57 122.43,41.34 117.97,36.88 117.63,36.88 63.56,36.88 62.53,37.91 62.53,38.34 v1(62.23,38.64) 61.24,38.64 61.04,38.44 61.04,37.75 60.53,37.25 59.39,37.25 59.3,37.33 58.58,37.33 57.89,36.64 D4001.K
  L3 w0.102: v1(164.47,36.56) 164.68,36.56 165.59,35.65 v1(177.01,35.65) ; v1(62.23,38.64) 62.15,38.72 61.85,38.72 59.87,40.7 59.87,42.86 59.74,42.99 59.74,44.59 59.82,44.66 59.82,47.05 58.99,47.88 54.88,47.88 52.57,50.19 50.94,50.19 49.96,51.17 46.42,51.17 45.8,51.79 41.46,51.79 39.29,53.96 39.29,54.22 39.29,54.62 37.41,56.5 37.41,61.5 35.69,63.23 35.69,63.74 33.27,66.15 33.27,70.22 32.89,70.6 32.89,74.03 33.78,74.92 v1(34.67,74.92) ; v1(173.58,55.71) 173.79,55.71 174.68,56.6 175.59,56.6 177.98,58.99 179.01,58.99 179.5,59.48 182.37,59.48 183.9,61.01 183.9,61.9 182.25,63.55 182.25,65.41 183.64,66.81 183.64,67.35 184.74,68.44 185.19,68.44 185.93,69.18 185.93,69.18 188.56,71.81 188.74,71.99 188.74,73.78 191.5,76.55 191.5,81.02 192.03,81.55 192.03,82.05 195.26,85.28 195.26,90.81 199.15,94.7 199.15,95.12 204.34,100.32 v1(207.01,100.32)
  L6 w0.102: v1(177.01,35.65) 177.01,40.88 177.32,41.18 v1(177.32,42.09) ; v1(34.67,74.92) 35.43,74.92 39.27,78.75 52.56,78.75 55.45,81.64 55.45,85.76 57.2,87.51 58.92,87.51 60.01,88.6 60.01,88.72 60.5,89.22 62.55,89.22 62.71,89.37 64.77,89.37 68.13,86.01 68.91,86.01 69.03,86.13 70.86,86.13 71.23,85.76 v1(71.75,85.76)
  BOTTOM w0.102: Q2606.D 206.63,100.7 v1(207.01,100.32) ; R2612.1 75.49,85.95 75.49,86.02 74.83,86.68 73.44,86.68 73.28,86.51 Q2602.D 72.7,86.51 71.96,85.76 v1(71.75,85.76) 71.68,85.84 71.51,85.84 C2610.1 ; v1(177.32,42.09) 176.16,42.09 174.84,43.41 174.84,43.41 173.88,44.37 173.88,46.27 173.73,46.42 173.73,54.47 173.45,54.75 ; 173.45,54.75 173.43,54.77 173.43,55.56 v1(173.58,55.71) ; 173.45,54.75 v2(173.43,54.75)
PWR_0D6V_S3EN: length 4.2
  TOP w0.254: PR5125.2 60.34,47.28 PR5126.2 61.27,47.17 PC5120.1 62.05,47.84 v2(62.28,48.07) 62.33,48.12 62.33,48.46 62.33,48.46 PU5102.7
PWR_0D6V_S5EN: length 3.3
  TOP w0.254: PU5102.9 63.33,48.46 v2(63.73,48.07) 63.77,48.03 PC5119.1 63.77,46.42 PR5114.2
PWR_0D6V_VCNTL: length 3.5
  TOP w0.305: PU5102.10 64.7,49.45 64.97,49.72 PC5121.1
  TOP w0.508: PR5118.1 65.41,48.09 v2(65.41,48.8) 65.41,49.71 PC5121.1
PWR_0D95V: length 12.9
  L3 w0.508: v1(180.77,61.17) 180.71,61.17 179.78,60.25 178.47,60.25 178.36,60.13 177.54,60.13 177.16,60.5 177.16,60.74 176.5,61.4 174.59,61.4 174.49,61.5 172.74,61.5 172.05,62.2 v1(170.94,62.2)
  BOTTOM w0.508: PR8622.1 PC8624.1 180.39,61.52 180.73,61.17 v1(180.77,61.17)
  vias: v2(171.35,62.8)
PWR_0D95V_FB: length 4.4
  BOTTOM w0.254: v2(180.72,59.68) 180.11,60.28 PC8624.2 PR8622.2 PR8623.1 178.44,60.58 178.44,60.49 177.95,60.01 177.83,60.01 177.74,59.92 PU8601.1
PWR_0D95V_PHASE:
  vias: v2(173.76,59.14)
PWR_0D95V_PVDD:
  vias: v2(177.93,57.14)
PWR_1D0V_BT: length 3.2
  TOP w0.305: v2(42.98,23.51) 42.93,23.56 42.93,24.56 PC5304.2 43.53,25.17 PU5301.20
PWR_1D0V_EN: length 180
  TOP w0.127: v1(168.53,30.27) 168.21,29.96 v2(167.89,29.96) 167.69,29.96 166.52,31.13 156.98,31.13 148.94,39.16 145.81,39.16 145.81,39.16 145.45,39.16 125.45,39.16 119.76,33.47 118.03,33.47 57.05,33.47 56.84,33.68 56.84,33.68 56.79,33.73 54.27,33.73 v1(53.9,34.1) ; PR5308.2 v1(47.37,27.42) 47.12,27.42 46.84,27.7 PU5301.2
  L3 w0.127: v1(168.53,30.27) 169.28,30.27 169.94,30.93 184.17,30.93 184.43,30.68 187.54,30.68 191.63,26.59 191.63,24.62 192.38,23.87 192.38,22.57 193.41,21.54 199.97,21.54 202.55,24.12 v1(203.03,24.12) ; v1(47.37,27.42) 49.78,29.83 49.78,34.04 50.65,34.9 51.22,34.9 51.29,34.83 53.16,34.83 v1(53.9,34.1)
  BOTTOM w0.127: v1(203.03,24.12) 203.03,24.39 202.48,24.94 PR5306.2 202.37,25 EC5312.1
PWR_1D0V_PFM: length 3.6
  TOP w0.254: PR5303.1 48.78,28 47.29,28 v2(47.14,28.15) 47.1,28.2 PU5301.3
PWR_1D0V_PG: length 7.1
  TOP w0.127: PU5301.1 46.7,27.2 47.04,26.86 v2(47.42,26.86) 48.06,26.86 48.32,26.59 PR5305.2 48.32,26.34 48.77,25.89 48.77,25.16 48.36,24.75 48.36,24.27 48.69,23.94 48.69,23.58 48.2,23.09 PR5307.2
PWR_1D0V_PH: length 3.8
  TOP w0.508: PC5304.1 42.04,24.62 41.4,25.26 40.13,25.26 39.29,26.1 v1(39.29,26.45)
  vias: v2(39.09,27.44) v3(37.19,28.69) v3(37.16,27.62) v3(37.19,26.5) v3(38.23,28.69) v3(38.25,27.57) v3(38.33,26.5)
PWR_1D0V_SS: length 3.8
  TOP w0.254: PU5301.22 46.3,26.4 PC5311.1 47.31,24.89 v2(47.73,24.47)
PWR_1D0V_TON: length 2.3
  TOP w0.254: PU5301.6 46.91,29.7 v2(46.99,29.78) 47.14,29.78 47.42,30.06 PR5301.1
PWR_1D0V_VFB: length 5.6
  TOP w0.254: PU5301.5 46.61,29.2 46.71,29.3 47.92,29.3 PR5304.1 48.13,29.83 48.46,30.16 v2(48.95,30.16) 49,30.21 49.85,30.21 PR5302.2 49.85,29.58 PC5310.2
PWR_1D0V_VFB_A: length 18.9
  TOP w0.254: PG5310.1 42.34,19.8 v2(42.7,20.15) 42.7,20.97 42.19,21.47 v1(42.16,21.47) ; v1(51.46,30.24) 51.44,30.21 50.74,30.21 PR5302.1 50.74,29.58 PC5310.1
  L4 w0.254: v1(51.46,30.24) 50.69,30.24 50.2,29.75 50.2,27.06 44.62,21.47 v1(42.16,21.47)
PWR_1D5V:
  vias: v2(192.15,126.35) v3(192.86,123.84) v3(192.89,122.95) v3(192.89,122.06) v3(196.85,121.73) v3(196.88,123.76) v3(196.88,122.74)
PWR_1D8V_EN: length 11.3
  TOP w0.127: PR5412.2 169.8,40.18 PC5411.1 PR5408.1 PR5413.2 167.07,40.18 166.5,40.75 164.21,40.75 v2(162.31,42.66) 161.93,42.66 161.05,43.53 PU5401.2
PWR_1D8V_POK: length 4.1
  TOP w0.127: v2(161.54,41.64) 160.72,41.64 PR5414.2 PR5409.2 159.78,43.46 PU5401.1
PWR_1D35V_BOOT: length 3.3
  BOTTOM w0.254: 203.95,123.43 PU8651.1
  BOTTOM w0.508: 203.95,123.43 203.58,123.8 203.58,124.09 PR8674.1 204.27,124.09 v2(204.85,124.67)
PWR_1D35V_BOOT_A: length 2.2
  BOTTOM w0.508: PC8656.1 202.7,125.41 PR8674.2 203.63,126.22 v2(203.4,126.45)
PWR_1D35V_EN: length 8
  BOTTOM w0.127: PU8651.11 205.75,118.97 206.5,118.23 207.2,118.23 PR8672.1 208.67,117.52 PG8655.2 208.74,115.99 v2(208.36,115.61) 207.77,115.02 D8602.1
PWR_1D35V_FB: length 5.3
  BOTTOM w0.254: PU8651.14 204.4,118.14 205.16,117.38 PR8676.1 PC8662.2 PR8675.2 203.45,118.04 v2(203.61,118.2)
PWR_1D35V_FB_A: length 12.1
  BOTTOM w0.254: PC8662.1 PR8675.1 203.45,115.89 202.59,115.02 200.13,115.02 199.01,116.14 v2(199.01,116.75) 199.01,117.51 197.03,119.49 PG8653.1
PWR_1D35V_ILMT: length 3.6
  BOTTOM w0.254: PU8651.13 204.85,118.6 v2(205.26,118.2) 205.93,117.52 PR8671.1 PR8677.1
PWR_1D35V_PG: length 4.9
  BOTTOM w0.127: 207.56,120.28 207.56,120.39 207.38,120.57 PU8651.9 ; 207.56,120.28 208,119.84 v2(208,119.29) 208,119.23 208.01,119.21 PR8673.2 ; 207.56,120.28 207.39,120.12 PU8651.10
PWR_1D35V_PH: length 6.9
  TOP w0.508: v2(203.63,122.92) v3(202.82,122.92)
  L6 w0.508: v3(202.82,122.92) 203.82,121.92 207.35,121.92 v3(207.37,121.93)
  BOTTOM w0.254: v3(207.37,121.93) 207.35,121.92 PU8651.6
PWR_1D35V_VCC: length 16.3
  TOP w0.254: v1(201.42,118.1) 201.4,118.12 200.89,118.12 200.89,118.12 v2(200.86,118.12)
  L3 w0.254: v1(207.01,115.99) 206.71,115.99 206.27,116.42 203.94,116.42 202.9,115.38 201.98,115.38 201.17,116.19 201.17,117.84 v1(201.42,118.1)
  BOTTOM w0.254: 202.31,120.25 202.31,118.37 202.16,118.22 201.55,118.22 v1(201.42,118.1) 201.14,117.82 PC8654.1 ; 202.31,120.25 202.62,120.57 PU8651.17 ; 202.31,120.25 202.45,120.12 PU8651.16 ; PR8677.2 v1(207.01,115.99)
PWR_2D5V:
  vias: v2(60.83,8.37) v2(62.99,6.21)
PWR_2D5V_FB:
  vias: v2(64.11,3.41)
PWR_2D5V_PG: length 94.2
  TOP w0.127: PR5114.1 64.09,45.52 v1(64.57,45.04) ; v2(57.53,61.96) 58.55,61.96 PG5112.1 59.08,61.98 59.46,62.38 v1(59.46,62.93)
  L3 w0.127: v1(64.57,45.04) 64.57,45.61 64.17,46 64.17,46.73 63.68,47.23 63.68,51.05 64.04,51.41 64.04,51.78 63.68,52.14 63.68,53.48 61.63,55.52 61.63,55.55 59.46,57.72 v1(59.46,62.93)
  L6 w0.127: v1(64.57,45.04) 64.77,44.84 64.77,39.32 54.8,29.35 54.8,24.43 53.15,22.78 44.49,22.78 38.66,16.94 38.66,16.63 38.66,13.48 47.47,4.67 52.08,4.67 v1(54.33,2.42)
  BOTTOM w0.127: PR5415.2 54.33,2.74 v1(54.33,2.42) 54.66,2.75 PU5402.1
PWR_3D3V:
  vias: v2(30.58,43.09) v3(27.05,43.5) v3(27.05,42.66) v3(27.94,43.5) v3(27.94,42.66) v3(28.96,44.56) v3(28.96,43.55) v3(28.96,42.61) v3(28.96,41.64)
PWR_3D3V_BOOT: length 5.1
  TOP w0.203: 50.92,45.96 50.92,45.89 51.74,45.07 PU4501.9
  TOP w0.508: v2(48.39,46.98) 48.57,47.16 PR4503.2 49.8,47.08 50.92,45.96
PWR_3D3V_BOOT_A: length 2.6
  TOP w0.508: v2(48.64,48.75) 48.9,48.5 49.79,48.5 PR4503.1 49.83,48.46 PC4503.2
PWR_3D3V_CS: length 5.2
  TOP w0.203: PU4501.5 53.69,43.87
  TOP w0.254: 53.69,43.87 54.99,45.17 54.99,46.44 55.45,46.9 PR4505.1 55.56,47.17 56.13,47.74 v2(56.13,47.81)
PWR_3D3V_EN: length 3.8
  TOP w0.127: PC4505.1 53.11,46.99 PR4502.2 53.92,45.88 53.82,45.78 v2(53.82,45.65) 52.94,44.77 PU4501.6
PWR_3D3V_FB: length 4.8
  TOP w0.203: PU4501.4 54.31,43.24 54.48,43.42
  TOP w0.254: 54.48,43.42 54.62,43.56 54.62,43.94 v2(54.84,44.16) 55.94,44.16 PC4506.2 55.99,44.64 55.99,44.64 PR4516.2 55.61,45.92 PR4517.1
PWR_3D3V_FB_A: length 1.9
  TOP w0.254: PC4506.1 57.72,44.21 v2(57.78,44.28) 57.84,44.33 57.84,45.16 PR4506.2
PWR_3D3V_FB_B: length 34.5
  TOP w0.254: v2(37.95,48.58) 37.94,48.57 37.25,48.57 v1(37.24,48.58) ; v1(57.84,46.8) 57.84,46.11 PR4506.1 57.53,46.08 56.5,45.04 PR4516.1
  L6 w0.254: v1(37.24,48.58) 39.32,50.66 44.83,50.66 46.3,49.18 52.27,49.18 54.03,47.43 57.28,47.43 57.81,46.9 57.81,46.82 v1(57.84,46.8)
  BOTTOM w0.254: v1(37.24,48.58) 35.53,48.58 33.88,46.92 PG4506.2
PWR_3D3V_HG: length 26.9
  TOP w0.203: v3(50.7,45.1) 51.34,44.45 PU4501.10
  TOP w0.406: v3(35.15,40.17) 35.26,40.17 35.31,40.22 PU4502.4
  TOP w0.635: v2(34.14,40.17) v3(35.15,40.17)
  L6 w0.635: v3(35.15,40.17) 38.4,40.17 39.24,41.01 39.24,46.85 40.49,48.09 43.21,48.09 44.77,46.53 49.54,46.53 50.7,45.37 v3(50.7,45.1)
PWR_3D3V_LG: length 13.3
  TOP w0.203: v3(49.96,44.44) 49.96,44.38 50.59,43.76 PU4501.11
  TOP w0.406: PU4503.4 40.75,46.61 v3(40.77,46.59) 41.3,47.13 v2(41.3,47.18)
  L6 w0.635: v3(40.77,46.59) 41.1,46.92 42.6,46.92 44.13,45.39 49.01,45.39 v3(49.96,44.44)
PWR_3D3V_PH: length 21.9
  TOP w0.203: PU4501.8 52.14,45.51 v3(52.07,45.58)
  L6 w0.635: v3(52.07,45.58) 52.07,46.34 50.65,47.76 45.29,47.76 43.79,49.26 39.88,49.26 36.32,45.71 v3(34.8,45.71)
  vias: v2(51.64,46.11) v3(34.75,44.74) v3(34.75,43.77) v3(34.75,42.86) v3(34.75,41.95) v3(34.75,41.08)
PWR_3D3V_VREG: length 4.4
  TOP w0.203: v2(54.84,42.86) 54.82,42.84 PU4501.3
  TOP w0.254: PG4507.2 56,40.81 56,42.81 PC4510.1 v2(54.84,42.86)
PWR_5V:
  vias: v2(25.07,32.07) v3(27.81,34.4) v3(27.81,33.39) v3(28.83,35.42) v3(28.83,34.4) v3(28.83,33.39) v3(28.83,32.37) v3(29.84,31.35) v3(30.86,31.35)
PWR_5V_BOOT: length 4.2
  TOP w0.203: 51.31,40.14 51.74,40.58 PU4501.17
  TOP w0.508: 51.31,40.14 50.62,39.45 PR4509.1 50.33,39.08 v2(49.43,38.19)
PWR_5V_BOOT_A: length 2.4
  TOP w0.508: PC4509.1 50.64,37.74 ; 50.64,37.74 50.93,37.45 v2(50.93,36.69) ; 50.64,37.74 PR4509.2
PWR_5V_CS: length 3.9
  TOP w0.254: PR4510.1 55.24,39.08 v2(54.53,39.79) 54.13,39.79 53.69,40.22 PU4501.1
PWR_5V_EN: length 3.4
  TOP w0.203: PC4508.1 52.94,39.06 52.94,39.72 v2(53.21,39.99) 52.94,40.26 PU4501.20
  TOP w0.254: PC4508.1 53.01,38.99 PR4507.1
PWR_5V_FB: length 6.8
  TOP w0.203: PU4501.2 54.41,42.44 55.04,41.81 v2(55.04,41.08) 55.04,40.73 55.88,39.89 PR4515.1
  TOP w0.254: PR4515.1 56.13,39.8 PC4517.2 56.18,38.97 57.15,38.97 57.58,39.41 PR4514.2
PWR_5V_FB_A: length 2.2
  TOP w0.254: PC4517.1 56.73,38.15 v2(57.1,37.78) 57.77,38.45 PR4512.2
PWR_5V_HG: length 21.5
  TOP w0.203: PU4501.16 51.34,41.29 50.62,40.57 v3(50.6,40.57)
  TOP w0.305: v3(50.6,40.57) 49.81,39.79 v2(49.58,39.79)
  TOP w0.406: PU4504.4 36.35,35.31 36.96,34.71 38.68,34.71 v3(38.86,34.53)
  L6 w0.635: v3(38.86,34.53) 38.86,33.77 39.5,33.13 40.69,33.13 43.1,35.54 44.14,35.54 48.61,40.01 50.05,40.01 50.6,40.55 v3(50.6,40.57)
PWR_5V_LG: length 16.6
  TOP w0.203: PU4501.15 50.24,42.04 49.76,41.56 v3(49.73,41.56)
  TOP w0.305: v3(49.73,41.56) 49.07,40.9 v2(49.05,40.9)
  TOP w0.381: PU4505.4 39.69,34.06 v3(40.03,34.4)
  L6 w0.635: v3(49.73,41.56) 49.68,41.51 48.31,41.51 44.55,37.75 42.24,37.75 40.08,35.6 40.08,34.45 v3(40.03,34.4)
PWR_5V_PH: length 23.8
  TOP w0.203: PU4501.18 52.14,40.17 v3(52.32,39.99) 52.32,39.86 51.89,39.43 PC4509.2
  L6 w0.635: v3(35.31,31.1) 35.81,31.61 44.68,31.61 50.36,37.29 50.36,38.37 51.92,39.93 52.27,39.93 v3(52.32,39.99)
  vias: v2(34.21,37.42) v3(34.29,36.05) v3(34.29,34.91) v3(34.29,33.89) v3(34.29,32.75) v3(34.29,31.61) v3(35.2,37.4) v3(35.18,36.43)
PWR_5V_VO: length 69.8
  TOP w0.203: PU4501.14 v1(49.74,42.44)
  L4 w0.381: v1(57.91,41.08) 57.77,40.94 55.64,40.94 55.19,41.39 51.84,41.39 50.14,43.09 48.41,43.09 44.3,38.97 32.97,38.97 31.65,37.65 v1(31.65,30.21)
  L6 w0.381: v1(49.74,42.44) 49.53,42.66 47.98,42.66 44.3,38.97 32.97,38.97 31.65,37.65 v1(31.65,30.21)
  BOTTOM w0.381: v1(31.65,30.21) 31.11,30.21 30.18,29.27 v2(29.59,29.27) 29.46,29.4 PG4509.2
PWR_CHG_1: length 17.6
  TOP w0.254: v1(231.14,24.24) PD4405.K 232.45,24.24 PD4402.K 234.57,25.57 234.56,25.58 v2(234.56,25.61) ; v1(228.54,15.55) 228.84,15.25 PR4407.1
  BOTTOM w0.254: v1(228.54,15.55) 229.08,16.09 229.08,18.53 227.58,20.03 227.58,22.04 229.79,24.24 v1(231.14,24.24)
PWR_CHG_ACDET: length 7.8
  TOP w0.203: PU4401.6 233.97,14.48 234.62,13.83 ; PR4408.2 PC4413.1 PR4409.1
  TOP w0.254: 234.62,13.83 v2(236.55,13.83) 237.21,13.83 238.07,12.96 PR4409.1
PWR_CHG_ACN: length 374.4
  TOP w0.203: 63.83,103.74 65.11,103.74 PG4403.2 ; 63.83,103.74 v2(63.83,103.57) ; 63.83,103.74 63.63,103.74 v1(63.12,104.25) ; PU4401.1 231.97,14.15 231.78,13.96 231.78,12.65 PC4404.2 231.38,11.43 PR4404.1 PC4402.1 231.75,10.25 231.75,9.2 v1(231.47,8.93)
  L4 w0.203: v1(214.37,5.55) 214.14,5.32 213.79,5.32 212.45,6.67 203.21,6.67 200.61,9.26 191.85,9.26 191.69,9.09 189.7,9.09 186.99,6.39 186.99,3.93 186.68,3.62 180.1,3.62 178.19,5.52 176.03,5.52 174.38,7.17 142.85,7.17 139.82,4.15 136.52,4.15 134.65,2.27 84.2,2.27 83.73,1.8 81.55,1.8 81.08,2.27 68.11,2.27 67.4,1.56 63.35,1.56 62.74,2.17 56.37,2.17 54.97,3.57 39.55,3.57 35.79,7.33 34.73,7.33 33.35,8.71 33.35,9.99 29.13,14.2 29.13,16.19 26.54,18.78 22.86,18.78 20.88,20.76 19.3,20.76 18.52,21.54 18.52,23.63 19.51,24.61 19.51,30.22 18.62,31.11 18.62,41.27 16.46,43.43 16.46,46.39 20.76,50.69 20.76,55.98 18.64,58.1 15.88,58.1 14.43,59.56 14.43,64.24 17.65,67.46 17.65,70.4 18.68,71.42 19.38,72.12 19.37,72.12 20.44,73.19 22.71,73.19 23.76,74.24 23.76,76.19 31.37,83.81 31.37,94.82 34.83,98.28 42.45,98.28 49.77,105.6 62.18,105.6 63.16,104.62 63.16,104.29 v1(63.12,104.25)
  BOTTOM w0.203: v1(214.37,5.55) 214.66,5.27 215.4,5.27 217.23,3.44 229.43,3.44 231.75,5.76 231.75,8.24 231.47,8.52 v1(231.47,8.93)
PWR_CHG_ACOK: length 109.6
  TOP w0.102: PR4432.1 236.21,11.59 PR4435.2 ; PR4463.2 PR4435.2 ; PR4435.2 PR4416.2 v2(235.26,12.46) 235.26,12.71 v1(234.75,13.22) 234.59,13.22 233.57,14.24 PU4401.5 ; v1(217.09,20.48) 218.43,20.48 R2469.1
  L3 w0.102: v1(182.75,43.17) 183.01,42.91 183.57,42.91 184.63,43.98 190.12,43.98 190.73,43.37 191.47,43.37 191.69,43.14 192.85,43.14 193.32,43.61 197.18,43.61 200.13,46.55 201.91,46.55 202.51,45.96 203.32,45.96 204.21,46.85 204.57,46.85 205.28,46.14 208.37,46.14 208.63,46.39 208.63,46.92 206.69,48.85 v1(206.69,48.86)
  L4 w0.102: v1(234.75,13.22) 234.75,13.42 233.95,14.22 226.99,14.22 226.53,14.22 226.53,14.22 226.02,14.22 225.65,14.59 220.82,14.59 219,16.41 219,17.06 217.09,18.96 v1(217.09,20.48)
  L6 w0.102: v1(217.09,20.48) 216.89,20.48 214.91,18.5 214.25,18.5 213.92,18.83 213.92,19.95 214.55,20.58 214.55,23.15 212.5,25.21 212.5,27.09 211.07,28.51 211.07,34.26 211.45,34.63 212.88,34.63 213.26,35.01 213.26,39.23 211.96,40.52 211.96,43.92 207.21,48.66 206.89,48.66 v1(206.69,48.86)
  BOTTOM w0.102: D1703.K 181.86,44.71 182.75,43.83 v1(182.75,43.17)
PWR_CHG_ACP: length 375.7
  TOP w0.203: 64.8,104.13 v2(64.8,104.33) ; 64.8,104.13 65.3,104.13 65.75,104.58 PG4402.2 ; 64.8,104.13 64.09,104.13 v1(63.9,104.31) ; v1(232.36,8.93) 232.08,9.21 232.08,10.25 PC4402.2 PR4404.2 232.3,11.41 PC4403.2 232.11,12.42 232.11,13.75 232.37,14.01 PU4401.2
  L4 w0.203: v1(63.9,104.31) 63.9,104.35 62.32,105.93 49.63,105.93 42.31,98.61 34.69,98.61 31.04,94.96 31.04,83.94 23.43,76.33 23.43,74.37 22.57,73.52 20.3,73.52 17.32,70.54 17.32,67.6 14.1,64.37 14.1,59.42 15.75,57.77 18.51,57.77 20.43,55.84 20.43,50.83 16.13,46.52 16.13,43.29 18.29,41.13 18.29,30.97 19.18,30.08 19.18,24.75 18.19,23.76 18.19,21.41 19.17,20.43 20.74,20.43 22.72,18.45 26.41,18.45 28.8,16.05 28.8,14.06 33.02,9.85 33.02,8.57 34.59,7 35.66,7 39.42,3.24 54.83,3.24 56.23,1.84 62.61,1.84 63.22,1.23 67.54,1.23 68.25,1.94 80.95,1.94 81.41,1.47 83.87,1.47 84.34,1.94 134.78,1.94 136.66,3.82 139.96,3.82 142.99,6.84 174.24,6.84 175.9,5.19 178.05,5.19 179.96,3.29 186.54,3.29 186.54,3.29 186.82,3.29 187.32,3.8 187.32,6.25 189.84,8.76 191.83,8.76 191.99,8.93 200.48,8.93 203.07,6.34 212.31,6.34 213.71,4.94 214.09,4.94 v1(214.37,4.65)
  BOTTOM w0.203: v1(232.36,8.93) 232.36,8.52 232.08,8.24 232.08,5.62 229.57,3.11 217.09,3.11 215.26,4.94 214.66,4.94 v1(214.37,4.65)
PWR_CHG_BATPRES#: length 5.3
  TOP w0.203: PU4401.15 234.82,19.04
  TOP w0.254: 234.82,19.04 235.31,19.52 237.36,19.52 v2(237.46,19.62) 237.64,19.8 PG4416.2
PWR_CHG_BATSRC: length 3
  TOP w0.203: PR4414.1 234.09,21.62 v2(234.09,20.64) 234.06,20.43 233.57,19.94 PU4401.17
PWR_CHG_BTST: length 3.1
  TOP w0.203: PC4414.1 228.61,17.33 229.13,17.33 v2(229.13,17.33) 229.99,17.33 230.32,17 PU4401.25
PWR_CHG_CMPIN: length 6.1
  TOP w0.203: 237.13,18.55 236.39,17.8 PU4401.13
  TOP w0.254: PR4424.1 PR4421.2 238.68,20.47 v2(238.68,19.62) 238.66,19.59 238.66,19.52 237.69,18.55 237.13,18.55
PWR_CHG_CMPOUT: length 1.7
  TOP w0.203: TP4404.1 236.55,18.65 236.1,18.2 PU4401.14
PWR_CHG_CMSRC: length 4.1
  TOP w0.203: PU4401.3 232.77,14.46 233.79,13.43 v2(233.79,13.07) 233.79,12.57 234.37,12 PR4410.2
PWR_CHG_HIDRV: length 19.8
  TOP w0.203: PU4401.26 230.02,16.6 229.87,16.75 v3(229.74,16.75)
  TOP w0.406: v2(220.89,29.35) PU4404.4 220.57,28.04 v3(220.21,27.67)
  L6 w0.762: v3(229.74,16.75) 228.7,17.79 228.7,18.67 227.34,20.03 225.07,20.03 223.01,22.08 223.01,24.87 v3(220.21,27.67)
PWR_CHG_IADP: length 5.7
  TOP w0.203: 237.36,14.54 234.8,14.54 PU4401.7
  TOP w0.254: PG4401.1 238.78,13.12 v2(238.17,13.74) 237.36,14.54
PWR_CHG_IDCHG: length 4.8
  TOP w0.203: PG4414.1 238.76,14.13 237.62,15.28 v2(236.68,15.28) 235.73,15.28 PU4401.8
PWR_CHG_ILIM: length 3.8
  TOP w0.203: PU4401.21 231.54,19.47
  TOP w0.254: 231.54,19.47 231.14,19.47 230.86,19.75 v2(230.86,20.2) 230.86,20.53 231.33,21 PR4420.2 PR4423.1
PWR_CHG_LODRV: length 11.2
  TOP w0.203: PU4401.23 230.59,17.8 230.02,18.38 v3(229.97,18.38)
  TOP w0.305: v2(228.5,23.53) 228.35,23.68 v3(228.35,24.77)
  TOP w0.406: PU4405.4 v3(228.35,24.77)
  L4 w0.762: v3(228.35,24.77) 230.38,22.74 230.38,22.07 230.38,22.07 230.38,21.33 230.38,18.78 v3(229.97,18.38)
PWR_CHG_PHASE: length 18.3
  TOP w0.203: PC4414.2 228.79,16.38 229.16,16.01 230.28,16.01 230.47,16.2 PU4401.27
  TOP w0.508: v3(227.2,17.41) 227.2,16.7 227.53,16.37 228.21,16.37 PC4414.2
  L4 w0.762: v3(227.2,17.41) 226.85,17.77 226.85,19.77 227.63,20.56 227.63,23.53 225.81,25.36 225.81,28.08 v3(224.82,29.07)
  vias: v1(223.47,27.8) v2(222.76,27.54) v3(224.13,28.26) v3(224.1,27.16) v3(224.79,30.21)
PWR_CHG_PHASE_1:
  vias: v3(222,32.75) v3(223.14,32.75) v3(224.41,32.75)
PWR_CHG_PMON: length 4.6
  TOP w0.203: PU4401.9 236.13,16.2 236.47,15.86 236.6,15.86
  TOP w0.254: PG4415.1 238.76,15.15 238.38,15.53 v2(238.38,15.56) 238.35,15.56 238.05,15.86 236.6,15.86
PWR_CHG_PROCHOT#: length 4.2
  TOP w0.14: PR4418.2 238.82,16.6 v2(237.74,16.6) PU4401.10
PWR_CHG_REGN: length 20.8
  TOP w0.203: PU4401.24 230.49,17.4 230.1,17.79 229.73,17.79 229.15,18.38 PC4401.2
  TOP w0.254: PC4401.2 v1(227.74,18.38) 227.74,19.02 v2(227.74,19.03) ; PR4435.1 236.14,10.35 v1(235.64,9.84)
  BOTTOM w0.254: v1(235.64,9.84) 235.64,11.52 234.65,12.51 229.07,12.51 227.51,14.07 227.51,15.21 227.81,15.51 227.81,18.3 v1(227.74,18.38)
PWR_CHG_SCL: length 5.1
  TOP w0.203: v2(236.98,17.61) 236.77,17.4 PU4401.12
  TOP w0.254: v2(236.98,17.61) 237.44,18.07 238.23,18.07 239.19,19.04 PG4410.1
PWR_CHG_SDA: length 4.9
  TOP w0.203: PU4401.11 237.24,17 237.54,17.31
  TOP w0.254: PG4409.1 239.14,18.02 238.66,17.54 v2(238.66,17.49) 238.48,17.31 237.87,17.31 237.54,17.31
PWR_CHG_SRN: length 2.3
  TOP w0.203: PU4401.19 232.77,19.91 232.76,19.92 232.76,19.97
  TOP w0.254: 232.76,19.97 232.76,20.65 PR4419.1
PWR_CHG_SRN_1: length 15.3
  TOP w0.254: v2(226.22,30.66) 226.39,30.82 v1(226.39,31.3) 227.05,31.96 PG4413.1 ; PC4422.1 PC4420.2 ; PC4420.2 233.24,23.54 v1(233.27,23.58) ; PC4420.2 233.22,22.58 PR4419.2
  L6 w0.254: v1(233.27,23.58) 233.24,23.62 233.24,24.56 227.73,30.07 227,30.07 226.24,30.83 226.24,31.15 v1(226.39,31.3)
PWR_CHG_SRP: length 2.3
  TOP w0.203: PU4401.20 232.37,19.91 232.38,19.92 232.38,19.97
  TOP w0.254: 232.38,20.2 232.38,21.06 PR4417.1 ; 232.38,20.2 v2(232.16,20.2) ; 232.38,20.2 232.38,19.97
PWR_CHG_SRP_1: length 15.5
  TOP w0.254: v2(224.54,31.89) 225.4,31.89 PG4412.1 v1(225.58,31.3) ; PR4417.2 232.33,22.58 PC4420.1 ; v1(232.33,23.56) 232.35,23.54 PC4420.1 ; PC4420.1 PC4421.1
  L6 w0.254: v1(225.58,31.3) 225.73,31.15 225.73,30.62 226.81,29.54 227.55,29.54 232.36,24.72 232.36,23.58 v1(232.33,23.56)
PWR_CHG_STAT#: length 2.4
  TOP w0.203: PU4401.16 233.97,19.58 235,20.61 TP4405.1
PWR_CHG_VCC: length 4.4
  TOP w0.203: 230.76,15.23 231.14,15.61 PU4401.28
  TOP w0.508: v2(229.41,12.38) 229.41,12.46 229.64,12.69 PC4412.2 229.64,14.41 229.73,14.5 PR4407.2 229.87,14.86 230.39,14.86 230.76,15.23
PWR_DCBATOUT_1D0V:
  vias: v2(46.81,33.06)
PWR_DCBATOUT_1D35V:
  vias: v2(206.02,124.29)
PWR_DCBATOUT_3D3V: length 2.6
  BOTTOM w0.508: PC4502.1 40.51,41.44 v1(40.51,41.26) ; PC4501.1 41.33,41.72 v1(41.53,41.51)
  vias: v2(41.22,40.75)
PWR_DCBATOUT_5V:
  vias: v2(43.79,38.21)
PWR_DCBATOUT_VDDQ:
  vias: v2(59.61,71.31)
PWR_DCBATOUT_VGA_CORE1:
  vias: v2(208.46,71.71) v3(213.49,72.48) v3(214.25,74.92) v3(214.33,72.48)
