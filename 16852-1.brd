# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
M_B_DQS_DP7: length 105.2
  TOP w0.14: v2(119.02,68.82) 119.59,68.82 v1(119.67,68.9)
  L6 w0.114: v1(119.67,68.9) 119.67,68.83 120.7,67.81 120.7,65.94 121.96,64.68 125.54,64.68 125.91,64.31 128.43,64.31 130.46,62.28 130.46,62.23 132.93,59.77 132.93,55.29 133.54,54.68 133.54,50.41 138.14,45.81 138.35,45.6 160.86,45.6 164.87,41.58 166.43,41.58 169.29,38.72 169.64,38.37 169.64,37.86 170.6,36.9 171.79,36.9 180.06,28.63 180.06,26.73 180.06,25.97 183.03,23.01 183.03,19.09 185.34,16.77 185.34,14.36 185.09,14.11 184.76,14.11 v1(184.48,13.83)
  BOTTOM w0.14: CPU1.AR21 120.07,68.5 119.78,68.79 119.78,68.79 v1(119.67,68.9) ; DM2.242 183.98,11.4 183.98,12.42 183.87,12.53 183.87,13.22 184.23,13.58 v1(184.48,13.83)
M_B_PARITY: length 103.4
  TOP w0.216: v2(157.45,18.45) 157.45,18.45 v1(157.45,17.89)
  L6 w0.178: v1(157.45,17.89) 157.68,18.12 157.68,21.47 151.16,27.99 125.78,27.99 106.17,47.59 106.17,51.38 105.72,51.83 105.72,62.22 106.17,62.67 106.17,63.64 106.44,63.91 108.46,63.91 108.58,64.03 108.58,64.49 108.46,64.62 106.73,64.62 106.6,64.75 106.6,65.2 106.73,65.33 108.15,65.33 108.33,65.51 108.33,65.95 108.2,66.08 107.01,66.08 106.78,66.3 106.78,66.76 107.31,67.29 107.31,69 106.89,69.43 v1(106.89,69.49)
  BOTTOM w0.216: v1(157.45,17.89) 157.67,17.89 158.98,19.2 158.98,20.81 158.85,20.94 157.53,20.94 157.22,20.63 DM2.143 ; CPU1.AP43 107.23,69.15 v1(106.89,69.49)
M_VREF_CA_DIMMA: length 7.8
  TOP w0.305: RN1201.3 85.72,11.22 R1206.1 86.35,11.87 RN1201.4
  TOP w0.508: v1(87.43,13.06) 87.11,12.75 C1229.1 R1206.1 86.38,11.88 v2(87.28,11.88)
  BOTTOM w0.305: DM1.164 87.48,11.4 87.48,13.02 v1(87.43,13.06)
M_VREF_CA_DIMMB: length 207.6
  L4 w0.508: v1(41.48,21.27) 41.48,21.24 41.33,21.09 41.33,13.14 43.9,10.56 44.71,10.56 45.61,9.66 50.31,9.66 50.72,9.26 52.08,9.26 52.33,9.51 59.21,9.51 59.59,9.13 68.24,9.13 68.62,9.51 70.49,9.51 71.04,10.06 76.12,10.06 76.79,9.38 79.38,9.38 79.4,9.36 83.48,9.36 83.63,9.51 85.99,9.51 86.5,9 89.61,9 91.59,10.98 110.37,10.98 111.08,10.27 114.42,10.27 114.52,10.37 116.99,10.37 117.88,11.26 117.88,11.28 118.84,12.24 121.53,12.24 121.69,12.41 154.72,12.41 154.76,12.37 162.14,12.37 162.58,12.81 162.58,12.99 163.27,13.68 163.5,13.68 v1(163.52,13.7)
  BOTTOM w0.305: RN1301.3 83.59,55.32 C1301.1 ; v1(163.52,13.7) 163.65,13.7 164.47,12.88 DM2.164 ; RN1301.4 85.42,56.38 85.76,56.73 85.76,56.75
  BOTTOM w0.508: C1301.1 83.57,56.12 ; 83.57,56.12 84.2,56.75 R1305.1 ; 83.57,56.12 82.8,56.88 80.13,56.88 79.06,55.82 79.06,51.36 v2(74.85,47.15) 69.98,42.28 66.5,42.28 65.81,41.58 64,39.78 64,39.77 63.88,39.65 63.88,38.37 52.96,27.45 50.43,27.45 49.02,26.05 49.02,25.59 48.06,24.62 47.68,24.62 46.67,23.61 42.8,23.61 42.65,23.76 41.67,23.76 40.89,22.98 40.89,21.69 41.32,21.27 v1(41.48,21.27)
MAA0: length 72.6
  TOP w0.127: VRAM1.N3 166.36,111.06 165.86,111.06 v1(165.3,111.62) ; v1(187.8,111.62) 188.21,111.62 188.77,111.06 188.86,111.06 VRAM4.N3
  L4 w0.127: v1(165.3,111.62) 165.36,111.67 166.02,111.67 166.2,111.49 166.2,110.68 166.54,110.35 167.14,110.35 167.27,110.47 167.27,111.08 167.56,111.37 168.02,111.37 168.33,111.06 169.57,111.06 169.87,110.75 171.88,110.75 172.6,110.03 172.6,109.07 172.73,108.94 173.15,108.94 173.28,108.81 173.28,108.56 173.15,108.43 172.73,108.43 172.6,108.31 172.6,107.98 172.8,107.78 173.99,107.78 174.12,107.91 174.12,109.18 174.24,109.31 174.5,109.31 174.62,109.18 174.62,107.99 174.75,107.86 175.23,107.86 175.36,107.99 175.36,108.85 175.49,108.98 v1(175.64,108.98) 176.37,108.98 176.5,108.85 176.5,108.49 176.63,108.36 176.88,108.36 177.01,108.49 177.01,108.85 177.13,108.98 177.75,108.98 178.1,109.33 178.1,109.94 177.68,110.37 177.68,110.71 177.9,110.93 178.15,110.93 178.46,110.63 178.99,110.63 179.12,110.5 179.12,109.53 179.25,109.41 179.71,109.41 179.83,109.53 179.83,110.7 180.24,111.11 182.17,111.11 182.33,111.28 183.85,111.28 184.11,111.53 184.11,111.73 184.23,111.85 185,111.85 185.13,111.73 185.13,110.91 185.27,110.77 185.27,110.76 185.39,110.64 185.68,110.64 186.77,111.73 187.69,111.73 v1(187.8,111.62)
  L6 w0.127: v1(175.74,86.33) 175.74,86.33 176.17,86.76 176.17,86.78 176.2,86.8 176.2,87.3 176.19,87.31 176.19,88.22 176.2,88.23 176.2,88.4 176.2,88.41 176.2,88.91 175.94,89.17
  L6 w0.229: v1(175.64,108.98) 175.64,108.29 175.06,107.71 175.06,102.63 174.65,102.22 174.65,99.81 175.08,99.38 175.08,98.73 174.75,98.39 174.75,93.92 175.67,93 175.67,89.44 175.94,89.17
  BOTTOM w0.127: VRAM3.N3 185.96,110.9 186.79,111.73 187.69,111.73 v1(187.8,111.62) ; VRAM2.N3 163.46,110.9 164.29,111.73 165.19,111.73 v1(165.3,111.62)
  BOTTOM w0.14: GPU1.K17 176.28,86.04 176.28,86.04 175.99,86.33 v1(175.74,86.33)
  BOTTOM w0.279: v2(175.08,108.98) v1(175.64,108.98)
MAA1: length 67
  TOP w0.127: v1(164.5,112.99) 163.93,112.43 163.93,112.3 163.56,111.93 163.55,111.93 VRAM1.P7 ; VRAM4.P7 186.05,111.93 186.06,111.93 186.43,112.3 186.43,112.43 v1(187,112.99)
  L4 w0.127: v1(187,112.99) 186.65,112.65 186.38,112.65 186.25,112.77 186.25,112.99 186.13,113.12 185.87,113.12 185.74,112.99 185.74,112.77 185.62,112.65 185.36,112.65 185.24,112.77 185.24,113.02 185.11,113.14 184.86,113.14 184.73,113.02 184.73,112.77 184.6,112.65 178.19,112.65 177.54,112 176.72,112 176.59,111.87 176.59,111.69 176.46,111.57 176.21,111.57 176.08,111.69 176.08,111.87 175.95,112 v1(175.26,112) 175.03,112.23 173.15,112.23 173.02,112.1 173.02,111.92 172.9,111.8 171.73,111.8 171.6,111.92 171.6,112.1 171.48,112.23 170.57,112.23 170.15,112.65 168.36,112.65 168.14,112.88 167.91,112.88 167.78,112.75 167.78,112.33 167.65,112.2 167.4,112.2 167.27,112.33 167.27,112.91 167.14,113.04 166.89,113.04 166.76,112.91 166.76,112.44 166.64,112.31 166.38,112.31 166.26,112.44 166.26,112.75 166.13,112.88 164.62,112.88 v1(164.5,112.99)
  L6 w0.229: v1(173.35,86.62) 173.13,86.62 172.75,87.01 172.75,88.25 173.08,88.58 173.08,91.15 170.99,93.23 170.99,94.98 171.5,95.49 171.5,96.1 170.99,96.61 170.99,98.51 172.49,100.01 172.49,106.06 172.98,106.54 172.98,109.33 173.37,109.72 173.4,109.72 175.26,111.58 v1(175.26,112)
  BOTTOM w0.127: v1(164.5,112.99) 164.62,112.88 165.43,112.88 165.95,112.35 165.95,112.26 166.4,111.81 166.41,111.81 VRAM2.P7 ; VRAM3.P7 188.91,111.81 188.9,111.81 188.45,112.26 188.45,112.35 187.93,112.88 187.12,112.88 v1(187,112.99)
  BOTTOM w0.14: GPU1.J20 173.58,86.8 173.4,86.62 v1(173.35,86.62)
  BOTTOM w0.279: v2(175.26,111.44) v1(175.26,112)
MAA2: length 66.6
  TOP w0.127: VRAM1.P3 166.29,111.93 166.28,111.93 165.95,112.26 165.95,112.73 v1(165.38,113.29) ; VRAM4.P3 188.79,111.93 188.78,111.93 188.17,112.54 188.17,112.63 187.88,112.92 v1(187.88,113.29)
  TOP w0.279: v1(175.39,112.63) 175.06,112.96 v2(174.9,112.96)
  L4 w0.127: v1(187.88,113.29) 187.76,113.41 186.78,113.41 186.76,113.39 184.42,113.39 183.91,112.88 182.11,112.88 181.81,113.17 177.85,113.17 177.32,112.63 v1(175.39,112.63) 175.29,112.73 172.68,112.73 172.55,112.6 172.55,112.23 172.45,112.13 172.14,112.13 172.04,112.23 172.04,113.17 171.91,113.29 171.58,113.29 171.46,113.17 171.46,112.66 171.36,112.56 171.05,112.56 170.95,112.66 170.95,112.95 170.82,113.08 169.99,113.08 169.79,112.88 168.47,112.88 168.05,113.29 v1(165.38,113.29)
  L6 w0.229: v1(175.39,112.63) 175.03,112.63 174.65,112.25 173.52,112.25 172,110.73 172,107.04 171.45,106.5 171.45,100.52 169.88,98.94 169.88,91.48 171.62,89.74 171.62,88.52 v1(172.21,87.92)
  BOTTOM w0.127: v1(165.38,113.29) 164.79,113.29 164.67,113.41 164.33,113.41 163.89,112.98 163.89,112.26 163.33,111.7 VRAM2.P3 ; v1(187.88,113.29) 187.29,113.29 187.17,113.41 186.83,113.41 186.39,112.98 186.39,112.26 185.83,111.7 VRAM3.P3
  BOTTOM w0.14: GPU1.H23 172.04,87.92 v1(172.21,87.92)
MAA3: length 69.3
  TOP w0.127: v1(187.75,112.46) 188.92,111.29 189.43,111.29 VRAM4.N2 ; VRAM1.N2 166.93,111.29 166.42,111.29 v1(165.25,112.46)
  L4 w0.127: v1(165.25,112.46) 165.92,112.46 166.29,112.09 166.29,112.09 166.48,111.89 167.98,111.89 168.5,112.41 169.99,112.41 170.12,112.28 170.12,111.54 170.24,111.41 170.52,111.41 170.65,111.54 170.65,111.8 170.75,111.9 171.06,111.9 171.16,111.8 171.16,111.54 171.29,111.41 173.17,111.41 173.9,110.68 173.9,110.41 174.19,110.12 174.68,110.12 175.02,110.46 175.02,110.64 174.37,111.29 v1(174.37,111.57) 174.49,111.69 174.94,111.69 175.57,111.06 177.09,111.06 178.35,112.32 180.63,112.32 180.87,112.08 181.76,112.08 182.04,112.35 186.72,112.35 186.94,112.58 187.63,112.58 v1(187.75,112.46)
  L6 w0.229: v1(174.37,111.57) 173.88,111.08 173.05,111.08 172.51,110.54 172.51,106.79 171.96,106.24 171.96,100.21 170.36,98.61 170.36,91.94 170.67,91.63 171.75,91.63 172.64,90.74 172.64,89.11 v1(172.21,88.68)
  BOTTOM w0.127: v1(165.25,112.46) 164.91,112.46 164.79,112.58 164.44,112.58 164.2,112.33 164.2,112.09 163.46,111.36 163.26,111.36 162.81,110.9 VRAM2.N2 ; v1(187.75,112.46) 187.41,112.46 187.29,112.58 186.94,112.58 186.7,112.33 186.7,112.09 185.96,111.36 185.76,111.36 185.31,110.9 VRAM3.N2
  BOTTOM w0.14: GPU1.G23 171.75,88.43 171.96,88.43 v1(172.21,88.68)
  BOTTOM w0.279: v2(174.07,111.03) 174.37,111.34 v1(174.37,111.57)
MAA4: length 71.2
  TOP w0.127: v1(164.46,113.83) 163.66,113.04 163.66,112.36 163.46,112.16 163.12,112.16 162.67,111.7 VRAM1.P8 ; v1(186.96,113.83) 186.16,113.04 186.16,112.36 185.96,112.16 185.62,112.16 185.17,111.7 VRAM4.P8
  L4 w0.127: v1(164.46,113.83) 164.58,113.71 165.97,113.71 166.03,113.78 173.25,113.78 173.78,113.25 v1(173.96,113.25) 174.13,113.08 177.04,113.08 178.1,114.13 180.21,114.13 180.51,113.83 v1(186.96,113.83)
  L6 w0.229: v1(173.96,113.25) 173.28,113.93 171.09,113.93 170.74,113.57 170.74,112.77 170.88,112.63 171.61,112.63 171.73,112.52 171.73,111.85 171.05,111.17 171.05,107.53 170.41,106.89 170.41,101.31 168.38,99.27 168.38,90.49 169.99,88.87 170.46,88.87 v1(170.52,88.8)
  BOTTOM w0.127: VRAM3.P8 189.51,111.7 189.16,112.04 188.99,112.04 188.68,112.36 188.68,113.09 188.06,113.71 187.08,113.71 v1(186.96,113.83) ; VRAM2.P8 167,111.7 166.66,112.04 166.49,112.04 166.18,112.36 166.18,113.09 165.56,113.71 164.58,113.71 v1(164.46,113.83)
  BOTTOM w0.14: v1(170.52,88.8) 170.92,88.41 GPU1.G24
  BOTTOM w0.279: v2(173.94,113.83) 173.94,113.27 v1(173.96,113.25)
MAA5: length 72
  TOP w0.127: v1(187.77,114.13) 187.77,114 188.3,113.47 188.3,112.82 188.4,112.72 188.4,112.63 188.88,112.16 189.36,112.16 VRAM4.P2 ; v1(165.27,114.13) 166.18,113.22 166.18,112.36 166.38,112.16 166.86,112.16 VRAM1.P2
  L4 w0.127: v1(187.77,114.13) 187.65,114.25 180.55,114.25 180.34,114.46 180.31,114.46 180.14,114.64 178.1,114.64 176.99,113.52 v1(175.42,113.52) 175.24,113.7 173.88,113.7 173.47,114.11 165.29,114.11 v1(165.27,114.13)
  L6 w0.127: 168.81,92.8 168.81,90.59 170.15,89.25 170.71,89.25 171.16,88.8 171.16,87.38 v1(171.32,87.22)
  L6 w0.229: 168.81,92.8 168.84,92.82 168.84,99 170.98,101.15 170.98,106.75 171.53,107.29 171.53,110.93 173.33,112.73 174.17,112.73 174.89,113.45 175.34,113.45 v1(175.42,113.52)
  BOTTOM w0.127: VRAM3.P2 185.33,111.7 185.68,112.04 185.85,112.04 186.16,112.36 186.16,113.63 186.78,114.25 187.13,114.25 187.25,114.13 v1(187.77,114.13) ; VRAM2.P2 162.83,111.7 163.18,112.04 163.35,112.04 163.66,112.36 163.66,113.63 164.28,114.25 164.63,114.25 164.75,114.13 v1(165.27,114.13)
  BOTTOM w0.14: v1(171.32,87.22) 170.94,87.6 GPU1.H24
  BOTTOM w0.279: v1(175.42,113.52) 175.41,113.53 v2(175.41,114.08)
MAA6: length 82.7
  TOP w0.127: VRAM1.R8 162.18,112.84 162.18,114.44 v1(164.85,117.11) ; v1(187.35,117.11) 184.68,114.44 184.68,112.84 VRAM4.R8
  L4 w0.127: v1(187.35,117.11) 186.92,117.54 176.26,117.54 175.89,117.16 v1(174.65,117.16) 174.08,117.74 167.09,117.74 166.11,116.76 165.19,116.76 v1(164.85,117.11)
  L6 w0.127: 174.65,89.93 174.65,89.16 174.97,88.84 174.97,87.81 174.41,87.25 v1(174.33,87.25)
  L6 w0.229: 174.65,89.93 174.65,91.6 173.58,92.67 173.58,102.64 174.1,103.15 174.1,105.69 173.93,105.86 173.93,108.04 174.66,108.77 174.66,109.62 176.4,111.37 176.4,113.93 175.09,115.25 175.09,116.57 174.65,117 v1(174.65,117.16)
  BOTTOM w0.127: v1(187.35,117.11) 187.7,116.76 188.66,116.76 190.16,115.26 190.16,112.96 189.82,112.62 VRAM3.R8 ; VRAM2.R8 167.32,112.62 167.66,112.96 167.66,115.26 166.16,116.76 165.19,116.76 v1(164.85,117.11)
  BOTTOM w0.14: v1(174.33,87.25) 174.33,87.25 174.77,86.8 GPU1.J19
  BOTTOM w0.279: v2(174.65,116.6) v1(174.65,117.16)
MAA7: length 85.1
  TOP w0.127: v1(188.31,117.18) 190.16,115.33 190.16,112.84 VRAM4.R2 ; v1(165.81,117.18) 167.66,115.33 167.66,112.84 VRAM1.R2
  L4 w0.127: v1(165.81,117.18) 166.8,118.17 176.72,118.17 v1(176.91,117.98) 177.03,117.87 187.63,117.87 v1(188.31,117.18)
  L6 w0.127: v1(175.03,85.47) 175.29,85.74 175.29,86.51 175.3,86.52 175.3,88.98 175.21,89.07 175.21,89.98
  L6 w0.229: v1(176.91,117.98) 176.91,117.65 175.97,116.71 175.97,115.1 176.87,114.2 176.87,111.17 175.13,109.43 175.13,108.52 174.57,107.97 174.57,102.88 174.05,102.36 174.05,93.8 175.21,92.64 175.21,89.98
  BOTTOM w0.127: v1(188.31,117.18) 188.24,117.18 187.89,117.53 187.17,117.53 186.93,117.28 186.93,116.97 184.68,114.72 184.68,112.84 VRAM3.R2 ; VRAM2.R2 162.52,112.7 162.18,113.04 162.18,115.03 v2(164.05,116.91) 164.67,117.53 165.39,117.53 165.74,117.18 v1(165.81,117.18)
  BOTTOM w0.14: GPU1.K19 175.03,85.91 v1(175.03,85.47)
MAA8: length 73.8
  TOP w0.127: v1(164.69,116.3) 164.39,116.3 162.52,114.43 VRAM1.T8 ; v1(187.19,116.3) 186.89,116.3 185.02,114.43 VRAM4.T8
  L4 w0.127: v1(164.69,116.3) 164.71,116.28 165.46,116.28 165.94,115.8 166.58,115.8 167.63,116.85 171.79,116.85 172.23,116.42 176.39,116.42 v1(176.6,116.62) 176.62,116.62 176.89,116.9 186.36,116.9 186.97,116.3 v1(187.19,116.3)
  L6 w0.127: 177.98,93.74 177.98,93.69 178.06,93.61 178.06,91.98 178.99,91.04 178.99,89.26 178.84,89.11 178.84,87.21 179.27,86.78 v1(179.27,86.72)
  L6 w0.229: v1(176.6,116.62) 176.6,116.62 176.43,116.45 176.43,116.29 176.43,116.28 176.43,115.87 176.43,115.87 176.43,115.33 177.34,114.41 177.34,110.89 176.97,110.51 176.97,107.14 177.32,106.79 177.32,94.4 177.98,93.74
  BOTTOM w0.127: VRAM3.T8 189.82,114.39 187.91,116.3 v1(187.19,116.3) ; v1(164.69,116.3) 165.41,116.3 167.32,114.39 VRAM2.T8
  BOTTOM w0.14: GPU1.J14 178.8,86.72 v1(179.27,86.72)
  BOTTOM w0.279: v1(176.6,116.62) 176.6,116.91 v2(176.35,117.16)
MAA9: length 77.2
  TOP w0.127: v1(165.26,115.86) 166.86,114.25 166.86,112.84 VRAM1.R3 ; v1(187.76,115.86) 189.36,114.25 189.36,112.84 VRAM4.R3
  TOP w0.279: v2(177.19,116.62) 177.19,116.35 v1(176.92,116.08)
  L4 w0.127: v1(187.76,115.86) 186.97,115.86 186.29,116.55 177.39,116.55 v1(176.92,116.08) 176.75,115.91 172.02,115.91 171.42,116.51 167.73,116.51 166.79,115.57 165.85,115.57 165.56,115.86 v1(165.26,115.86)
  L6 w0.127: 180.16,89.85 179.78,89.46 179.78,87.69 179.78,87.69 179.78,87.25 179.73,87.2 179.73,86.35 179.39,86 v1(179.28,86)
  L6 w0.229: 180.16,89.85 180.16,91.21 179.56,91.81 179.56,93.4 178.3,94.66 178.3,107.21 177.91,107.6 177.91,110.12 178.37,110.59 178.38,110.59 179.2,111.41 179.2,114.37 177.49,116.08 v1(176.92,116.08)
  BOTTOM w0.127: v1(187.76,115.86) 187.74,115.88 187.01,115.88 186.94,115.95 186.54,115.95 185.48,114.89 185.48,113.05 185.82,112.71 VRAM3.R3 ; v1(165.26,115.86) 165.24,115.88 164.51,115.88 164.44,115.95 164.04,115.95 162.98,114.89 162.98,113.05 163.32,112.71 VRAM2.R3
  BOTTOM w0.14: v1(179.28,86) GPU1.K14
MAA10: length 73.6
  TOP w0.127: VRAM1.L7 163.38,109.24 165.32,109.24 v1(165.58,108.98) ; v1(187.24,108.99) 187.03,108.77 186.62,108.77 186.49,108.9 186.49,109.36 186.36,109.48 186,109.48 VRAM4.L7
  L4 w0.127: v1(165.58,108.98) 165.85,108.71 165.85,107.97 165.32,107.44 165.32,106.49 165.45,106.37 166.07,106.37 166.73,107.02 167.08,107.02 167.62,106.49 168.35,106.49 168.48,106.61 168.48,106.94 168.94,107.4 169.49,107.4 171.03,105.86 171.03,104.96 172.18,103.81 174.63,103.81 174.66,103.84 178.04,103.84 178.33,104.13 178.33,105.16 v1(178.87,105.7) 178.97,105.7 179.3,105.37 179.3,104.63 179.43,104.5 180.91,104.5 181.04,104.63 181.04,105.03 181.17,105.16 181.51,105.16 181.64,105.28 181.64,105.54 181.51,105.67 181.17,105.67 181.04,105.79 181.04,106.6 181.58,107.13 181.58,107.97 181.84,108.24 182.38,108.24 182.51,108.11 182.51,106.31 182.63,106.18 184.76,106.18 185,106.42 185,106.67 185.25,106.92 185.98,106.92 186.3,107.24 186.74,107.24 186.86,107.36 186.86,107.8 186.74,107.92 186.52,107.92 186.27,108.17 186.27,108.52 186.6,108.85 186.6,109.41 187.36,110.17 187.58,110.17 187.82,109.93 187.82,109.42 187.39,108.99 v1(187.24,108.99)
  L6 w0.127: 180.16,89.22 180.11,89.16 180.11,87.83 180.11,87.83 180.11,87.11 180.06,87.06 180.06,86.55 180.51,86.1 v1(180.51,86.01)
  L6 w0.229: 180.16,89.22 180.16,89.24 180.84,89.91 180.84,91.15 180,91.99 180,92.4 180.62,93.03 180.62,93.66 179.52,94.76 179.52,98.66 179.33,98.84 179.33,99.6 178.77,100.16 178.77,101.65 179.33,102.21 179.33,105.24 v1(178.87,105.7)
  BOTTOM w0.127: VRAM2.L7 166.13,109.3 165.81,108.98 v1(165.58,108.98) ; v1(187.24,108.99) 187.9,109.64 188.26,109.64 188.45,109.84 188.79,109.84 189.02,109.61 VRAM3.L7
  BOTTOM w0.14: v1(180.51,86.01) 181.12,86.62 GPU1.J11
  BOTTOM w0.279: v1(178.87,105.7) 178.87,106.28 v2(178.87,106.28)
MAA11: length 76.2
  TOP w0.127: VRAM4.R7 185.37,112.95 185.37,114.46 186.44,115.53 v1(186.71,115.53) ; v1(164.21,115.53) 162.98,114.3 162.98,112.84 VRAM1.R7
  L4 w0.127: v1(164.21,115.53) 164.3,115.44 165.65,115.44 165.75,115.34 167.04,115.34 167.71,116 171.21,116 171.81,115.4 176.87,115.4 177.41,115.94 178.63,115.94 v1(178.79,116.1) 178.82,116.1 178.9,116.01 180.25,116.01 180.46,115.81 180.64,115.81 180.76,115.94 180.76,116.11 180.86,116.22 181.17,116.22 181.27,116.11 181.27,115.94 181.4,115.81 181.85,115.81 181.98,115.94 181.98,116.11 182.11,116.24 182.36,116.24 182.49,116.11 182.49,115.94 182.62,115.81 183.16,115.81 183.36,116.01 186.23,116.01 v1(186.71,115.53)
  L6 w0.127: v1(180.57,86.75) 181.15,86.75 182,87.6 182,88.13 182.02,88.15
  L6 w0.229: 182.02,88.15 182.02,88.3 182.3,88.58 182.59,88.88 182.59,89.08 182.77,89.26 182.77,90.56 182.83,90.62 182.83,91.79 182.79,92.74 182.79,94.57 181.39,95.97 181.39,100.21 180.82,100.78 180.82,108.8 180.21,109.41 180.21,114.66 178.79,116.08 v1(178.79,116.1)
  BOTTOM w0.127: VRAM3.R7 189.02,112.5 189.36,112.85 189.36,114.08 188,115.44 186.8,115.44 v1(186.71,115.53) ; VRAM2.R7 166.52,112.5 166.86,112.85 166.86,114.08 165.5,115.44 164.3,115.44 v1(164.21,115.53)
  BOTTOM w0.14: GPU1.J13 180.07,86.65 180.47,86.65 v1(180.57,86.75)
  BOTTOM w0.279: v1(178.79,116.1) 178.79,116.57 v2(178.64,116.72)
MAA12: length 70.8
  TOP w0.127: VRAM4.N7 185.85,110.9 186.54,111.59 186.82,111.59 186.97,111.45 v1(186.97,111.31) ; VRAM1.N7 163.85,110.9 164.26,111.31 v1(164.47,111.31)
  TOP w0.279: v2(178.56,108.77) v1(178.56,109.33)
  L4 w0.127: 178.56,109.32 177.25,108.01 175.92,108.01 175.41,107.5 175.03,107.5 174.63,107.1 172.87,107.1 172.06,107.91 172.06,108.8 172.06,109.34 170.97,110.42 169.77,110.42 169.44,110.75 168.31,110.75 168.18,110.63 168.18,109.38 168.07,109.27 167.31,109.27 167.18,109.4 167.18,109.91 167.05,110.03 166.53,110.03 165.94,110.62 165.94,111.07 165.81,111.2 164.58,111.2 v1(164.47,111.31) ; 178.56,109.32 178.56,109.31 178.82,109.05 179.24,109.05 179.44,108.85 179.83,108.85 180.16,109.18 180.16,110.57 180.38,110.78 180.71,110.78 180.83,110.65 180.83,110.53 180.94,110.41 181.23,110.41 181.34,110.53 181.34,110.65 181.47,110.78 181.89,110.78 182.02,110.65 182.02,109.74 182.14,109.61 182.45,109.61 182.58,109.74 182.58,110.83 182.79,111.05 184.21,111.05 184.33,111.17 184.33,111.49 184.46,111.62 184.77,111.62 184.9,111.49 184.9,110.82 185.04,110.67 185.04,109.18 185.17,109.06 185.52,109.06 185.68,109.21 185.68,110.31 186.67,111.31 v1(186.97,111.31) ; 178.56,109.32 v1(178.56,109.33)
  L6 w0.229: v1(180.56,87.4) 180.81,87.4 181.05,87.64 181.05,89.52 181.39,89.86 181.39,91.51 181.29,91.61 181.29,93.77 180.02,95.04 180.02,95.82 180.38,96.17 180.38,96.89 180.02,97.24 180.02,97.95 180.38,98.31 180.38,99.49 179.32,100.54 179.32,101.28 179.83,101.79 179.83,106.42 178.38,107.88 178.38,109.15 v1(178.56,109.33)
  BOTTOM w0.127: VRAM3.N7 188.64,110.9 188.34,111.2 187.63,111.2 187.51,111.31 v1(186.97,111.31) ; VRAM2.N7 165.73,110.9 165.43,111.2 164.89,111.2 164.77,111.31 v1(164.47,111.31)
  BOTTOM w0.14: GPU1.H11 180.88,87.36 180.59,87.36 180.56,87.4 v1(180.56,87.4)
MAA13: length 69
  TOP w0.127: v1(165.33,115.02) 166.52,113.83 VRAM1.T3 ; VRAM4.T3 189.02,113.47 187.83,114.66 v1(187.83,115.02)
  L4 w0.127: v1(187.83,115.02) 187.76,115.09 186.03,115.09 185.64,115.48 177.99,115.48 177.86,115.61 177.55,115.61 176.42,114.48 v1(174.57,114.48) 174.22,114.83 170.25,114.83 170.12,114.96 170.12,115.45 170,115.58 169.74,115.58 169.61,115.45 169.61,114.96 169.49,114.83 169.26,114.83 169.13,114.96 169.13,115.53 169,115.66 168.75,115.66 168.62,115.53 168.62,114.96 168.5,114.83 168.24,114.83 168.12,114.96 168.12,115.48 167.99,115.61 167.73,115.61 167.61,115.48 167.61,114.96 167.48,114.83 165.93,114.83 165.74,115.02 v1(165.33,115.02)
  L6 w0.127: v1(174.3,88) 174.19,88 173.66,88.53 173.66,92.03 172.85,92.85
  L6 w0.229: v1(174.57,114.48) 175.19,114.48 175.93,113.74 175.93,111.56 174.19,109.82 174.19,109.02 173.46,108.29 173.46,106.26 173.07,105.87 173.07,99.42 172.38,98.73 172.38,93.31 172.85,92.85
  BOTTOM w0.127: v1(165.33,115.02) 164.76,115.02 164.69,115.09 164.34,115.09 163.32,114.07 VRAM2.T3 ; VRAM3.T3 185.82,114.07 186.84,115.09 187.19,115.09 187.26,115.02 v1(187.83,115.02)
  BOTTOM w0.14: v1(174.3,88) 173.92,88.37 GPU1.G20
  BOTTOM w0.279: v2(174.57,115.07) v1(174.57,114.48)
MAA14: length 67.2
  TOP w0.127: v1(187.02,114.67) 187.02,114.87 186.89,115 186.24,115 185.71,114.46 185.71,113.41 VRAM4.T7 ; v1(164.52,114.67) 163.32,113.48 VRAM1.T7
  L4 w0.127: v1(164.52,114.67) 164.58,114.6 165.6,114.6 165.74,114.46 173.58,114.46 174.02,114.03 176.6,114.03 v1(177.7,115.12) 180.47,115.12 180.88,114.71 181.26,114.71 181.38,114.84 181.38,115.02 181.51,115.15 181.76,115.15 181.89,115.02 181.89,114.72 182.02,114.59 182.27,114.59 182.4,114.72 182.4,115.05 182.53,115.17 182.78,115.17 182.91,115.05 182.91,114.69 183.03,114.56 183.29,114.56 183.42,114.69 183.42,115.05 183.54,115.17 183.8,115.17 183.92,115.05 183.92,114.77 184.05,114.64 184.68,114.64 184.78,114.74 184.78,115.07 184.91,115.2 185.24,115.2 185.37,115.07 185.37,114.59 185.48,114.48 186.83,114.48 v1(187.02,114.67)
  L6 w0.127: 178.44,93.91 178.44,92.4 179.6,91.23 179.6,89.95 179.32,89.67 v1(179.32,88.78)
  L6 w0.229: v1(177.7,115.12) 177.8,115.02 177.83,115.02 178.05,114.79 178.05,113.87 178.05,113.86 178.05,113.44 178.69,112.8 178.69,112.35 177.81,111.47 177.81,110.69 177.44,110.32 177.44,107.34 177.83,106.95 177.83,94.53 178.44,93.91
  BOTTOM w0.127: VRAM3.T7 189.12,113.4 189.12,114 188.56,114.56 187.12,114.56 v1(187.02,114.67) ; v1(164.52,114.67) 164.64,114.55 165.44,114.55 166.52,113.47 VRAM2.T7
  BOTTOM w0.14: GPU1.G14 179.1,88.78 v1(179.32,88.78)
  BOTTOM w0.279: v2(177.67,114.56) 177.67,115.1 v1(177.7,115.12)
MAA15: length 79.2
  TOP w0.127: VRAM1.M7 163.34,110.08 164.26,110.08 164.42,109.92 v1(165.1,109.92) ; VRAM4.M7 186.43,110.1 v1(186.56,109.96)
  TOP w0.279: v1(175.77,106.18) 175.77,106.17 v2(175.77,105.57)
  L4 w0.127: v1(165.1,109.92) 165.1,109.54 165.24,109.39 165.41,109.39 165.41,109.4 165.76,109.4 165.76,109.39 165.9,109.39 166.08,109.22 166.08,107.87 165.63,107.43 165.63,106.82 165.76,106.69 165.91,106.69 166.47,107.25 166.47,107.48 166.67,107.68 167.06,107.68 167.18,107.55 167.18,107.24 167.55,106.88 167.89,106.88 168.14,107.13 168.14,108.11 168.27,108.24 168.68,108.24 168.81,108.11 168.81,107.81 168.94,107.68 169.26,107.68 169.39,107.81 169.39,108.6 169.51,108.72 170,108.72 170.13,108.6 170.13,107.22 171.24,106.11 171.25,106.11 171.37,105.98 171.37,105.46 171.5,105.33 172.12,105.33 172.4,105.05 172.4,104.87 172.08,104.55 172.08,104.37 172.32,104.14 172.84,104.14 173.4,104.7 174.37,104.7 174.5,104.57 174.5,104.29 174.62,104.17 174.88,104.17 175,104.29 175,104.57 175.48,105.05 175.48,105.92 175.73,106.18 v1(175.77,106.18) 175.98,106.18 176.33,105.83 176.33,104.29 176.45,104.17 176.78,104.17 176.91,104.29 176.91,104.89 177.04,105.01 177.29,105.01 177.42,104.89 177.42,104.29 177.55,104.17 177.88,104.17 178,104.29 178,105.3 178.43,105.72 178.43,106.08 178.55,106.21 179.5,106.21 179.63,106.08 179.63,104.96 179.76,104.83 180.37,104.83 180.49,104.96 180.49,106.51 180.71,106.73 180.71,106.73 181.25,107.27 181.25,108.11 181.76,108.62 182.74,108.62 182.81,108.54 182.81,107.74 183.43,107.13 183.43,106.6 183.55,106.48 184.48,106.48 185.15,107.15 185.89,107.15 186.18,107.44 186.18,107.9 186.04,108.04 186.04,108.61 186.37,108.94 186.37,109.87 186.47,109.96 v1(186.56,109.96)
  L6 w0.127: 175.83,94.7 175.83,94.27 176.48,93.62 176.48,89.19 176.53,89.14 176.53,89.04 176.53,88.03 176.52,88.02 176.52,87.44 176.53,87.44 176.53,86.66 176.5,86.64 176.5,86.62 176.5,86.62 176.5,86.4 176.06,85.96 176.06,85.64 176.2,85.51 176.69,85.51 v1(176.89,85.71)
  L6 w0.229: 175.83,94.7 175.83,99.34 175.12,100.05 175.12,101.8 175.83,102.51 175.83,104.42 175.53,104.72 175.53,105.93 v1(175.77,106.18)
  BOTTOM w0.127: v1(165.1,109.92) 165.3,109.92 165.48,110.1 VRAM2.M7 ; v1(186.56,109.96) 186.57,109.97 187.37,109.97 188,110.59 188.53,110.59 VRAM3.M7
  BOTTOM w0.178: GPU1.L17 176.52,85.2 176.89,85.57 v1(176.89,85.71)
MAA_BA0: length 77.2
  TOP w0.127: v1(165.19,110.78) 166.15,110.78 166.38,110.56 166.77,110.56 167.23,110.1 VRAM1.M2 ; VRAM4.M2 189.8,110.12 189.8,110.45 189.7,110.56 188.88,110.56 188.61,110.82 188.61,110.9 188.31,111.2 187.98,111.2 187.59,110.81 v1(187.59,110.78)
  TOP w0.279: v1(176.27,107.42) 176.25,107.44 v2(176.25,107.99)
  L4 w0.127: v1(165.19,110.78) 165.46,110.78 166.43,109.8 166.44,109.8 166.57,109.68 166.57,108.88 166.7,108.75 168.77,108.75 169.2,109.19 169.2,110.05 169.33,110.18 170.58,110.18 170.71,110.05 170.71,109.59 170.81,109.48 171.25,109.48 171.55,109.18 171.55,107.91 171.9,107.57 171.9,107.39 171.57,107.06 171.57,106.88 171.75,106.7 171.93,106.7 172.25,107.03 172.43,107.03 172.67,106.79 172.67,106.06 172.8,105.93 173.05,105.93 173.18,106.06 173.18,106.64 173.3,106.77 173.56,106.77 173.69,106.64 173.69,106.06 173.81,105.93 174.07,105.93 174.19,106.06 174.19,106.64 174.32,106.77 175.15,106.77 175.8,107.42 v1(176.27,107.42) 176.71,106.98 176.71,106.64 177.29,106.06 177.47,106.06 177.65,106.24 177.65,106.42 177.07,107 177.07,107.18 177.34,107.45 177.67,107.45 177.94,107.72 177.94,108.05 178.61,108.72 179.1,108.72 179.36,108.47 179.95,108.47 180.55,109.07 180.55,109.96 180.68,110.08 181.48,110.08 181.61,109.96 181.61,109.41 181.74,109.28 182.84,109.28 182.97,109.41 182.97,110.65 183.1,110.78 183.93,110.78 184.06,110.65 184.06,110.05 183.82,109.81 183.82,108.89 183.95,108.76 185.55,108.76 185.92,109.13 185.92,110.23 186.56,110.88 187.49,110.88 v1(187.59,110.78)
  L6 w0.127: v1(178.09,86.34) 178.51,86.76 178.51,89.02 178.08,89.45 178.08,90.99 177.72,91.35 177.72,93.38 177.41,93.7
  L6 w0.229: 177.41,93.7 176.89,94.22 176.89,106.51 176.27,107.12 v1(176.27,107.42)
  BOTTOM w0.127: VRAM2.M2 162.72,110.1 163.09,110.48 163.53,110.48 163.93,110.88 164.64,110.88 164.74,110.78 v1(165.19,110.78) ; VRAM3.M2 185.04,110.12 185.04,110.45 185.15,110.56 186.16,110.56 186.48,110.88 187.49,110.88 v1(187.59,110.78)
  BOTTOM w0.14: v1(178.09,86.34) 177.63,86.8 GPU1.J16
MAA_BA1: length 73.2
  TOP w0.127: v1(164.62,112.16) 163.8,111.34 162.97,111.34 162.53,110.9 VRAM1.N8 ; VRAM4.N8 185.02,111.12 185.15,111.24 185.85,111.24 186.16,111.56 186.16,111.71 186.75,112.3 186.99,112.3 187.12,112.17 v1(187.12,112.16)
  TOP w0.279: v2(176.4,110.14) v1(176.4,109.59)
  L4 w0.127: v1(164.62,112.16) 164.74,112.04 165.98,112.04 166.43,111.59 166.43,110.81 166.56,110.68 166.91,110.68 167.04,110.81 167.04,111.45 167.25,111.66 168.08,111.66 168.53,112.12 169.75,112.12 169.89,111.98 169.89,111.42 170.23,111.08 172.85,111.08 172.97,110.96 172.97,109.92 173.1,109.79 174.54,109.79 174.54,109.79 175.22,109.79 175.35,109.92 175.35,110.49 175.59,110.73 175.94,110.73 176.15,110.53 176.15,109.84 v1(176.4,109.59) 176.52,109.59 176.81,109.87 176.99,109.87 177.45,109.41 177.63,109.41 177.77,109.56 177.77,109.81 177.35,110.23 177.35,110.85 177.93,111.44 178.12,111.44 178.59,110.96 179,110.96 179.13,111.08 179.13,111.85 179.26,111.97 179.97,111.97 180.1,111.85 180.1,111.54 180.2,111.44 180.64,111.44 180.87,111.67 181.27,111.67 181.5,111.44 181.91,111.44 182.59,112.12 185.23,112.12 185.36,111.99 185.36,111.22 185.49,111.09 185.81,111.09 185.95,111.24 185.95,111.98 186.08,112.1 187.07,112.1 v1(187.12,112.16)
  L6 w0.127: v1(177.85,85.51) 177.82,85.51 177.5,85.84 177.5,88.86 176.81,89.54 176.81,93.75 176.3,94.27 176.3,94.55
  L6 w0.229: v1(176.4,109.59) 176.4,108.38 175.64,107.62 175.64,107.04 176.3,106.39 176.3,102.16 175.77,101.64 175.77,100.18 176.3,99.65 176.3,94.55
  BOTTOM w0.127: v1(164.62,112.16) 164.74,112.04 165.47,112.04 166.17,111.34 166.73,111.34 167.16,110.9 VRAM2.N8 ; VRAM3.N8 189.66,110.9 189.23,111.34 188.67,111.34 187.97,112.04 187.24,112.04 v1(187.12,112.16)
  BOTTOM w0.14: GPU1.L15 178.16,85.2 v1(177.85,85.51)
MAA_BA2: length 74.1
  TOP w0.127: VRAM1.M3 166.26,110.36 164.57,110.36 v1(164.47,110.46) ; VRAM4.M3 188.79,110.33 188.78,110.33 188.52,110.59 188.35,110.59 188.34,110.59 188,110.59 187.99,110.59 187.75,110.35 187.75,109.81 187.62,109.68 187.1,109.68 186.98,109.8 186.98,110.45 v1(186.97,110.46)
  L4 w0.127: v1(186.97,110.46) 186.89,110.54 186.54,110.54 186.14,110.14 186.14,109.04 185.64,108.53 184.31,108.53 184.2,108.41 184.2,106.82 184.09,106.7 183.78,106.7 183.65,106.83 183.65,107.69 183.53,107.82 183.21,107.82 183.08,107.95 183.08,108.2 183.21,108.33 183.53,108.33 183.65,108.46 183.65,108.66 183.36,108.95 180.9,108.95 180.04,108.09 180.04,106.67 179.91,106.54 179.64,106.54 179.2,106.54 179.07,106.67 179.07,108.04 v1(178.89,108.21) 178.79,108.21 178.31,107.73 178.31,106.43 177.48,105.6 177.29,105.6 176.19,106.7 175.64,106.7 174.54,105.6 172.35,105.6 171.12,106.83 171.12,108.87 170.84,109.15 169.49,109.15 168.87,108.53 166.47,108.53 166.34,108.65 166.34,109.28 165.26,110.36 164.57,110.36 v1(164.47,110.46)
  L6 w0.127: v1(181.56,88.73) 181.81,88.97 181.81,89.71 181.94,89.83 182.22,89.83 182.35,89.96 182.35,90.22 182.22,90.34 181.94,90.34 181.81,90.47 181.81,90.72 181.94,90.85 182.32,90.85 182.44,90.97 182.44,91.24 182.32,91.36 181.94,91.36 181.81,91.49 181.81,91.81 181.68,91.95 181.68,93.22 181.8,93.35 182.3,93.35 182.41,93.46 182.41,93.74 182.3,93.85 181.8,93.85 181.68,93.98 181.68,94.38
  L6 w0.229: v1(178.89,108.21) 178.89,108.7 179.17,108.98 179.88,108.98 180.34,108.52 180.34,100.39 180.85,99.88 180.85,95.21 181.68,94.38
  BOTTOM w0.127: VRAM3.M3 186.11,110.1 186.51,110.51 186.93,110.51 v1(186.97,110.46) ; v1(164.47,110.46) 164.11,110.1 VRAM2.M3
  BOTTOM w0.14: GPU1.G11 181.24,88.4 v1(181.56,88.73)
  BOTTOM w0.279: v2(178.89,107.63) v1(178.89,108.21)
MASK_BASE_LEDS#: length 62.4
  TOP w0.114: v1(215.14,31.35) 215.32,31.54 KBC24.23 ; v1(208.56,10.15) 209.49,9.22 Q6407.G 210.27,8.78 210.36,8.69 213.05,8.69 v1(213.87,9.51)
  BOTTOM w0.114: Q6406.5 Q6406.2 199.14,17.26 v2(199.61,16.78) 199.9,16.5 199.9,16.08 200.39,15.59 200.77,15.59 203.37,12.98 203.37,11.57 203.68,11.27 204.04,11.27 204.37,10.93 207.77,10.93 v1(208.56,10.15) ; R2438.1 R2499.1 208.29,33.63 208.92,33.01 208.91,33.01 208.91,31.35 209.26,31.01 211.29,31.01 212.19,31.91 213.84,31.91 214,31.76 214.73,31.76 v1(215.14,31.35) 214.96,31.18 214.7,31.18 214.01,30.49 212.73,30.49 212.69,30.52 212.16,30.52 210.29,28.65 210.29,27 209.19,25.9 209.19,21.4 213.27,17.32 213.27,10.43 213.87,9.82 v1(213.87,9.51)
MCARD_WWAN_PWREN: length 43
  TOP w0.127: v1(88.01,108.82) 88.11,108.72 R6212.1 ; U9601.12 v2(75.69,74.85) 78.74,74.85 83.12,79.23 83.12,80.55 83.35,80.78 83.35,86.31 85.53,88.49 85.53,93.06 86.18,93.71 v1(86.31,93.71)
  L3 w0.127: v1(86.31,93.71) 86.73,94.13 86.73,94.94 87.05,95.25 87.05,107.86 v1(88.01,108.82)
MCT:
  vias: v2(22,87.69)
MCT0: length 6
  TOP w0.508: RN3201.1 v2(20.27,93.25) 20.27,94.21 v1(19.48,95)
  BOTTOM w0.508: XF3103.24 v1(19.48,95)
MCT1: length 4.1
  TOP w0.305: RN3201.2 19.69,90.53 19.25,90.97 19.25,91.22 v2(19.23,91.25) 19.23,91.8 v1(19.43,92)
  BOTTOM w0.508: XF3103.21 v1(19.43,92)
MCT2: length 3.7
  TOP w0.305: RN3201.3 19.64,90.03 v2(19.28,89.67) 19.28,89.15 v1(19.43,89)
  BOTTOM w0.508: XF3103.18 v1(19.43,89)
MCT3: length 5.2
  TOP w0.508: RN3201.4 20.27,88.32 v2(20.04,88.1) v1(19.56,87.62)
  BOTTOM w0.508: v1(19.56,87.62) 19.56,86.79 18.77,86 XF3103.15
MDO0+: length 6.9
  BOTTOM w0.089: RJ45.1 12.53,85.8 12.59,85.73 13.93,84.39 15.85,84.39 15.96,84.39 16.05,84.3 16.05,84.09 16.14,84 XF3103.13
MDO0-: length 6.7
  BOTTOM w0.089: XF3103.14 16.14,85 16.05,84.91 16.05,84.7 15.96,84.61 15.94,84.61 14.02,84.61 12.75,85.88 12.69,85.94 RJ45.2
MDO1+: length 8.3
  TOP w0.089: RJ45.3 12.84,87.87 13.64,88.67 13.72,88.67 13.8,88.58 13.8,87.86 14.26,87.4 15.41,87.4 15.62,87.19 v1(15.62,87.09) 16.03,86.68 v2(16.03,86.68)
  BOTTOM w0.089: XF3103.16 16.62,87 16.23,87.39 15.93,87.39 v1(15.62,87.09)
MDO1-: length 8.3
  TOP w0.089: RJ45.6 13.72,89.93 13.72,88.97 13.87,88.82 14.02,88.67 14.02,87.95 14.35,87.62 15.32,87.62 v1(15.62,87.91) 15.83,88.12 v2(16.21,88.12)
  BOTTOM w0.089: XF3103.17 16.64,88 16.25,87.61 15.93,87.61 v1(15.62,87.91)
MDO2+: length 6.2
  BOTTOM w0.089: RJ45.4 12.69,89.8 12.74,89.86 12.77,89.89 13.93,89.89 14.44,90.39 15.54,90.39 15.93,90 XF3103.19
MDO2-: length 6.4
  BOTTOM w0.089: RJ45.5 12.53,89.94 12.59,90.01 12.68,90.1 13.84,90.1 14.35,90.61 15.41,90.61 15.8,90.99 16.13,90.99 16.14,91 XF3103.20
MDO3+: length 7
  BOTTOM w0.089: RJ45.7 12.53,91.92 12.54,91.9 12.65,91.78 14.05,91.78 15.66,93.39 15.96,93.39 16.05,93.3 16.05,93.09 16.14,93 XF3103.22
MDO3-: length 6.8
  BOTTOM w0.089: RJ45.8 12.69,92.06 12.75,92 13.96,92 15.57,93.61 15.96,93.61 16.05,93.7 16.05,93.91 16.14,94 XF3103.23
ME_FWP_CPU: length 178.7
  TOP w0.102: v1(200.2,56.91) 200.2,56.79 198.93,55.51 198.75,55.51 196.47,53.22 196.47,39.99 v1(196.16,39.69) ; v1(210.21,112.66) 209.4,112.66 208.35,113.71 MESW1.C MESW1.C1 ; v1(116.2,45.32) 116.74,45.32 v2(117.81,44.26) 117.88,44.18 151.3,44.18 158.21,37.27 162.12,37.27 162.94,38.09 v1(163.12,38.09)
  L3 w0.102: v1(210.21,112.66) 210.64,112.23 210.64,102.71 206.12,98.19 206.12,93.55 202.55,89.98 202.55,87.91 201.87,87.23 199.35,87.23 196.85,84.73 196.85,82.14 196.55,81.84 196.55,71.57 197.41,70.71 197.41,65.73 200.38,62.76 200.38,57.44 200.2,57.26 v1(200.2,56.91) ; v1(196.16,39.69) 195.02,38.54 193.93,38.54 193.47,39 189.22,39 188.31,38.09 v1(163.12,38.09)
  BOTTOM w0.102: R1909.1 R9801.2 116.81,49.73 116.81,45.93 v1(116.2,45.32)
ME_FWP_EC: length 190.5
  TOP w0.102: v1(162.53,38.34) 161.67,37.48 158.29,37.48 151.38,44.38 118.59,44.38 116.36,46.62 v1(116.36,46.85) ; KBC24.80 200.46,29.14 200.28,29.32 v1(199.9,29.32) ; MESW1.A 208.6,112 v1(210.21,112)
  L3 w0.102: v1(200.99,56.14) 200.66,56.47 199.85,56.47 199.67,56.65 199.67,57.44 199.97,57.74 199.97,58.66 199.95,58.68 199.95,59.47 200.05,59.57 200.05,59.95 199.95,60.06 199.95,62.9 197.21,65.64 197.21,70.62 196.34,71.48 196.34,81.93 196.65,82.23 196.65,84.81 199.37,87.54 201.89,87.54 202.35,88 202.35,90.07 205.87,93.58 205.87,98.23 210.21,102.57 v1(210.21,112) ; v1(199.14,38.73) 196.43,38.73 195.86,38.16 194.01,38.16 193.37,38.8 189.31,38.8 188.04,37.53 182.98,37.53 182.4,36.94 166.09,36.94 165.35,37.68 163.58,37.68 163.55,37.65 162.92,37.65 162.69,37.88 162.69,38.19 v1(162.53,38.34)
  L6 w0.102: v1(199.9,29.32) 200.33,29.75 200.33,33.67 199.14,34.86 v1(199.14,38.73) 199.14,39.61 197.68,41.07 197.68,45.37 198.22,45.91 v1(198.22,47.25)
  BOTTOM w0.102: v1(198.22,47.25) 198.22,48.5 197.94,48.78 197.94,53.01 200.53,55.61 200.53,55.69 v1(200.99,56.14) ; R9801.1 v2(116.36,48.35) v1(116.36,46.85)
ME_SUS_PWR_ACK: length 78.8
  TOP w0.127: KBC24.42 211.51,38.71 v1(211.48,38.75) ; v1(155.45,63.93) 155.45,64.37 154.69,65.14 R1712.1
  L4 w0.127: v1(155.45,63.93) 156.11,63.93 157.35,62.69 157.35,59.88 160.43,56.8 164.41,56.8 166.76,54.46 170.46,54.46 171.13,53.79 179.03,53.79 179.36,53.46 184.92,53.46 186.56,55.1 187.34,55.1 187.63,55.4 188.54,55.4 189.03,54.91 191.83,54.91 192,54.75 192.79,54.75 194.63,52.9 204.11,52.9 207.13,49.87 207.13,48.12 v1(206.88,47.86)
  L6 w0.127: v1(211.48,38.75) 211.48,39.67 211.02,40.13 211.02,41.16 210.36,41.82 210.36,43.85 208.45,45.76 207.86,45.76 207.38,46.24 207.38,47.06 206.88,47.56 v1(206.88,47.86)
  BOTTOM w0.127: v2(207.39,48.37) v1(206.88,47.86)
ME_SUS_PWR_ACK_R: length 36.2
  TOP w0.127: v1(125.17,68.21) 125.22,68.26 127.39,68.26 127.72,68.59 128,68.59 128.64,69.23 128.95,69.23 128.95,69.22 128.99,69.22 129.22,68.99 129.22,68.95 129.89,68.29 130.2,68.29 131.07,67.42 133.84,67.42 134.43,68.01 143.28,68.01 143.77,67.51 144.85,67.51 145.11,67.77 145.11,68.67 145.44,69 149.33,69 v2(149.61,68.72) 149.72,68.6 151.19,68.6 151.98,67.82 R1708.1 153.55,67.82 154.69,66.68 R1712.2 154.14,66.28 153.32,65.45 R2039.2
  BOTTOM w0.127: CPU1.AR13 124.85,68.5 125.15,68.21 v1(125.17,68.21)
MEM_CALRP0: length 4.3
  TOP w0.102: R7809.2 167.56,83.8 v2(167.56,84.49) 167.6,84.53 168.16,84.53 169.04,85.41 v1(169.04,85.46)
  BOTTOM w0.102: GPU1.K25 169.65,85.53 169.11,85.53 v1(169.04,85.46)
MEM_SMBCLK: length 45.6
  TOP w0.14: RN1811.3 131.98,84.25 131.98,83.86 132.11,83.73 132.11,82.13 131.62,81.65 131.62,81.07 130.92,80.37 130.92,80.36 130.91,80.34 130.91,78.57 130.59,78.25 ; 130.59,78.25 v2(130.43,78.42) ; 130.59,78.25 130.05,77.71 128.48,77.71 128.29,77.91 v1(128.29,78.14)
  L6 w0.114: v1(128.29,78.14) 128.29,76.8 128.6,76.49 130,76.49 130.85,77.34 135.35,77.34 137.57,75.12 137.57,72.8 140.44,69.94 140.44,67.31 145.41,62.33 145.41,60.71 145.02,60.31 v1(145.01,60.31)
  BOTTOM w0.14: Q1801.3 144.03,57.5 143.4,58.13 143.4,59.51 144.22,60.34 144.68,60.34 144.7,60.31 v1(145.01,60.31) ; CPU1.R7 128.56,78.42 128.55,78.4 v1(128.29,78.14)
MEM_SMBDATA: length 44.7
  TOP w0.14: 132.37,82.89 132.37,83.79 132.44,83.86 132.44,84.25 RN1811.4 ; 132.37,82.89 v2(132.59,82.89) ; 132.37,82.89 132.37,82.02 131.89,81.54 131.89,80.96 131.19,80.26 131.19,80.25 131.18,80.23 131.18,78.46 130.16,77.44 128.37,77.44 127.68,78.14 v1(127.63,78.14)
  L6 w0.114: v1(127.63,78.14) 127.63,78.1 128.07,77.66 128.07,77.35 128.07,77.35 128.07,76.72 128.51,76.28 130.09,76.28 130.94,77.13 135.26,77.13 137.36,75.03 137.36,72.71 140.22,69.85 140.22,67.22 145.2,62.24 145.2,61.22 v1(144.98,61)
  BOTTOM w0.14: CPU1.R8 127.63,78.12 v1(127.63,78.14) ; Q1801.6 142.7,59.19 144.11,60.6 144.54,60.6 144.94,61 v1(144.98,61)
MESO_SVC: length 9.1
  BOTTOM w0.102: GPU1.AJ11 181.32,70.87 180.99,70.54 180.99,70 180.3,69.31 180.3,68.43 179.14,67.26 v2(179.14,67.26) 178.97,67.09 176.14,67.09 R7946.2
MESO_SVD: length 10.1
  BOTTOM w0.102: GPU1.AK12 180.52,70.53 178.75,68.76 178.75,68.7 v2(177.65,67.6) 177.39,67.35 176.01,67.35 175.52,67.83 173.89,67.83 173.55,67.49 R7944.2
MESO_SVT: length 7.8
  BOTTOM w0.102: GPU1.AL11 181.32,69.34 180.75,68.77 180.75,67.37 180.47,67.09 v2(180.42,67.09) 180.19,66.86 177.11,66.86 176.85,66.6 R7945.2
MESO_U1: length 8.5
  BOTTOM w0.102: GPU1.U1 187.72,79.95 188.25,79.42 188.25,78.43 189.61,77.07 v2(190.63,77.07) 191.11,77.07 191.9,76.29 191.9,75.02 191.84,74.96 RN7905.2
MESO_U3: length 9.7
  BOTTOM w0.102: RN7905.1 191.19,74.97 191.69,75.47 191.69,76.21 191.49,76.41 190.96,76.41 190.42,75.88 v2(190.09,75.88) 188.05,77.92 188.05,79.34 187.83,79.56 187.46,79.93 187.39,79.93 GPU1.U3
MESW1_B: length 7.6
  TOP w0.102: v1(209.19,114.03) 209.19,115.91 208.36,116.75 MESW1.B
  BOTTOM w0.102: v2(209.19,114.62) v1(209.19,114.03) 209,113.84 R9804.1 208.27,113.84 207.57,113.14 207.57,112.59 206.76,111.78 R9805.2
MIC2_VREFO: length 17
  TOP w0.203: v1(23.24,7.22) 23.33,7.31 HDA27.29
  TOP w0.254: RN2901.2 16.78,11.98 16.64,12.13 16.64,12.79 ; 16.64,12.79 16.79,12.63 RN2901.1 ; 16.64,12.79 v1(16.64,13.73)
  L3 w0.254: v1(16.64,13.73) 17.02,14.11 18.64,14.11 19.1,13.65 19.1,12.66 20.14,11.62 20.14,10.32 v1(23.24,7.22)
  BOTTOM w0.254: v2(16.4,13.03) 16.4,13.49 v1(16.64,13.73)
MIC_CAP: length 3.7
  TOP w0.203: HDA27.19 19.43,11.62 19.02,11.21 v2(19.02,11.01)
  TOP w0.254: C2713.1 19.02,10.42 v2(19.02,11.01)
MIC_GND: length 4.6
  TOP w0.508: v1(48.13,77.71) R5531.1 47.38,78.66 v2(47.21,78.83)
  BOTTOM w0.305: v1(48.13,77.71) 48.01,77.71 47.52,77.23 47.52,76.98 47.15,76.61 LCD1.26
MLPS_EN#: length 6.4
  BOTTOM w0.102: R7935.2 R7936.1 190.74,81.04 190.58,81.04 190.49,81.08 v2(190.04,81.52) 189.84,81.52 189.39,81.97 188.31,81.97 187.95,82.33 187.58,82.33 187.52,82.27 187.12,82.27 187.06,82.33 186.45,82.33 GPU1.R5
MODEL_ID: length 9.1
  TOP w0.102: KBC24.109 207.52,20.18 206.43,19.09 205.31,19.09 205.13,18.91 203.84,18.91 203.33,18.4 R2441.1 C2407.2 203.28,17.51 203.53,17.26 203.53,16.7 v2(203.43,16.6) 203.35,16.52 203,16.52 202.81,16.71 R2442.2
MPV18: length 21.8
  TOP w0.254: v1(183.39,85.46) 183.87,85.94 184.71,85.94 184.72,85.93 184.82,85.93 185.98,84.77 188.7,84.77 189.87,85.94 190.68,85.94 190.85,86.12 v2(191.19,86.12) 193.79,86.12 195.92,88.25 v1(196.6,88.25)
  BOTTOM w0.254: v1(196.6,88.25) 197.21,88.25 197.7,88.75 C8045.1 198.72,89.16 C8043.1 C8044.1 200.94,89.16 201.55,89.77 L8001.2 ; v1(183.39,85.46) 183.39,85.33 GPU1.L8
MSM#: length 1.6
  TOP w0.102: TP617.1 99.87,69.83 v1(99.52,69.48)
  BOTTOM w0.102: CPU1.AP56 99.89,69.15 99.57,69.48 v1(99.52,69.48)
MVREFDA: length 6
  TOP w0.508: R7817.2 166.63,82.85 C7805.2 R7818.1 v2(166.63,85.58) 166.71,85.66 168.13,85.66 168.86,86.39 168.89,86.39 v1(168.92,86.42)
  BOTTOM w0.356: GPU1.K26 169.17,86.15 169.16,86.15 168.92,86.39 168.92,86.42 v1(168.92,86.42)
MVREFSA: length 11.7
  TOP w0.203: v1(168.93,87.16) 168.67,86.91 167.58,86.91 167.01,86.33 164.96,86.33 164.9,86.39
  TOP w0.508: v1(164.01,84.49) v2(164.01,85.35) 164.01,85.51 164.9,86.39
  BOTTOM w0.356: GPU1.J26 168.96,87.16 v1(168.93,87.16)
  BOTTOM w0.508: v1(164.01,84.49) 163.97,84.53 R7814.1 C7801.2 161.96,84.53 161.39,83.96 161.39,83.32 161.9,82.81 R7810.2
NC#AA3: length 7
  BOTTOM w0.102: R7938.2 190.81,72.05 190.81,73.38 190.24,73.95 v2(190.22,73.95) 190.22,73.97 186.99,77.2 GPU1.AA3
NC_R: length 3.9
  BOTTOM w0.102: TP7922.1 168.02,67.85 168.18,68.01 168.18,68.6 169.32,69.74 GPU1.AM26
NC_VSYNC: length 5.8
  BOTTOM w0.102: GPU1.AJ27 169.39,71.2 169.65,70.94 169.65,70.66 169.57,70.58 169.57,70.22 169.65,70.14 169.65,69.86 169.6,69.81 v2(169.6,67.57) 169.04,67.02 R7941.2
NCT7718_ALERT#: length 4
  BOTTOM w0.102: R2603.2 73.35,93.84 v2(73.62,94.11) 73.62,94.12 73.73,94.23 73.73,95.78 73.46,96.05 THM26.6
NCT7718_DXN: length 308.4
  L3 w0.254: v1(72.9,54.47) 72.9,57.77 74.5,59.36 74.5,65.67 75.77,66.94 75.77,71.41 74.9,72.27 74.9,76.12 75.31,76.53 75.31,78.65 76.25,79.59 76.25,80.82 73.94,83.13 73.94,86.92 74.34,87.32 75.7,87.32 77.83,89.45 77.83,94.16 78.95,95.29 81.1,95.29 81.58,95.77 v1(81.58,95.82)
  L6 w0.254: v1(194.18,32.8) 194.34,32.64 194.34,28.65 193.85,28.16 193.85,23.63 194.27,23.21 194.27,20.45 192.79,18.97 192.79,17.38 192.84,17.33 192.84,15.74 192.48,15.38 192.48,13.6 190.49,11.61 189.5,11.61 186.58,8.68 138.24,8.68 136.82,7.27 134.35,7.27 133.49,6.41 132.4,6.41 129.91,3.92 117.53,3.92 116.64,4.81 115.21,4.81 114.89,4.49 114.06,4.49 112.67,5.87 112.67,7.42 112.08,8.01 111.61,8.01 111.12,8.49 100.9,8.49 99.09,6.69 93.94,6.69 92.07,4.81 84.21,4.81 83.99,4.6 68.96,4.6 68.23,5.33 64.25,5.33 60.31,9.28 47.3,9.28 46.29,10.29 45.83,10.75 45.75,10.83 42.17,14.41 42.17,15.82 46,19.64 59.07,19.64 75.88,36.46 75.88,52.25 75.15,52.98 73.79,54.34 73.03,54.34 v1(72.9,54.47)
  BOTTOM w0.254: v1(81.58,95.82) 81.58,95.34 81.36,95.11 79.27,95.11 78.87,95.5 C2607.2 77.91,96.05 THM26.3 ; Q2603.E 194.84,28.08 194.84,29.81 194.61,30.04 194.61,31.06 C2606.2 194.63,31.41 194.63,31.94 194.38,32.19 194.38,32.61 v1(194.18,32.8) ; v1(72.9,54.47) 72.9,55.08 v2(72.9,55.08)
NCT7718_DXP: length 310.5
  L3 w0.254: v1(72.26,54.98) 72.39,55.1 72.39,57.98 73.99,59.57 73.99,65.88 75.26,67.15 75.26,71.2 74.4,72.06 74.4,76.33 74.8,76.74 74.8,78.86 75.74,79.8 75.74,80.61 73.43,82.92 73.43,87.13 74.13,87.83 75.49,87.83 77.32,89.66 77.32,94.37 78.74,95.79 80.87,95.79 v1(80.92,95.84)
  L6 w0.254: v1(72.26,54.98) 72.26,54.38 72.81,53.83 73.58,53.83 75.37,52.04 75.37,36.67 58.86,20.15 45.79,20.15 41.67,16.03 41.67,14.19 41.98,13.88 47.09,8.77 60.1,8.77 64.04,4.82 68.02,4.82 68.75,4.09 84.2,4.09 84.42,4.3 92.28,4.3 94.15,6.18 99.3,6.18 101.11,7.99 110.91,7.99 111.4,7.5 111.87,7.5 112.17,7.21 112.17,6.58 112.17,5.66 113.85,3.98 115.1,3.98 115.42,4.3 116.43,4.3 117.32,3.41 130.12,3.41 132.61,5.9 133.71,5.9 134.56,6.76 137.03,6.76 138.45,8.18 186.79,8.18 189.71,11.1 190.7,11.1 192.99,13.39 192.99,15.17 193.34,15.53 193.34,17.54 193.29,17.59 193.29,18.76 194.78,20.24 194.78,23.42 194.36,23.84 194.36,27.95 194.85,28.44 194.85,32.61 v1(195.02,32.78)
  BOTTOM w0.254: v1(80.92,95.84) 80.7,95.62 79.48,95.62 78.7,96.39 C2607.1 78.15,96.7 THM26.2 ; v1(195.02,32.78) 194.88,32.64 194.88,32.4 195.14,32.15 195.14,31.43 C2606.1 195.12,31.01 195.12,30.25 Q2603.C 195.35,29.51 195.35,28.84 196.33,27.86 Q2603.B 197.06,27.86 v2(197.67,28.47)
NGFF_CONFIG_0: length 67.6
  TOP w0.102: AFTP6258.1 102.26,109.46 v1(101.57,108.77) 101.5,108.77 101.03,109.24 R6201.1 ; v1(79.27,101.92) 79.27,101.75 81.41,99.62 81.41,99.05 84.77,95.68 84.77,88.08 83.11,86.41 83.11,80.88 82.88,80.65 82.88,79.33 79.41,75.85 75.84,75.85 75.84,75.85 U9601.14
  L3 w0.102: v1(83.06,107.17) 83.06,106.79 79.27,103.01 v1(79.27,101.92)
  L4 w0.102: v1(101.57,108.77) 101.32,109.03 98.55,109.03 98.32,109.26 91.34,109.26 90.27,108.19 84.07,108.19 v1(83.06,107.17)
  BOTTOM w0.102: WWAN1.21 103.3,109.25 102.82,108.77 v1(101.57,108.77)
NGFF_CONFIG_1: length 77
  TOP w0.102: v1(78.59,101.92) 78.59,101.76 81.2,99.15 81.2,98.96 84.57,95.6 84.57,88.37 82.91,86.71 82.91,80.96 82.68,80.73 82.68,79.41 79.61,76.35 U9601.15 ; v1(101.09,121.37) 100.87,121.37 AFTP6253.1 100.46,122.03 101.41,122.98 R6202.1
  L3 w0.102: v1(101.09,121.37) 99.92,121.37 97.71,119.16 93.55,119.16 93.29,118.91 93.29,116.09 91.57,114.36 89.2,114.36 84.4,109.56 84.4,106.87 82.5,104.96 82.5,104.43 82.25,104.18 81.71,104.18 81.52,103.99 80.96,103.99 80.01,103.03 80.01,101.71 79.77,101.47 78.88,101.47 78.59,101.76 v1(78.59,101.92)
  BOTTOM w0.102: WWAN1.69 104.12,121.19 103.44,121.19 103.24,120.99 102.64,120.99 102.23,121.4 102.23,121.53 101.97,121.79 101.51,121.79 v1(101.09,121.37)
NGFF_CONFIG_2: length 220.4
  TOP w0.102: KBC24.20 215.72,30.34 215.72,30.33 214.72,30.33 214,31.05 v1(214,31.23) ; AFTP6260.1 94.87,120.38 R6203.1 95.31,121.97 98.04,124.7 98.3,124.7 98.68,125.08 101.09,125.08 101.47,124.7 101.47,123.94 101.85,123.56 101.85,122.54 v1(101.6,122.29)
  L4 w0.102: v1(206.22,47.94) 206.17,47.99 206.17,50.06 204.17,52.06 194.71,52.06 192.41,54.35 186.57,54.35 185.44,53.22 178.03,53.22 178.01,53.24 164.3,53.24 164.2,53.14 159.82,53.14 156.84,56.12 156.84,61.81 155.1,63.55 154.49,63.55 153.85,64.19 151.95,64.19 151.38,64.76 149.77,64.76 149.15,64.14 149.15,63.81 148.9,63.56 148.54,63.56 148.29,63.81 148.29,64.47 147.93,64.83 147.93,65.19 147.83,65.29 147.83,72.7 148.54,73.41 148.54,74.31 148.97,74.74 149.1,74.74 149.35,74.99 149.35,75.35 149.22,75.48 149.22,77.46 150.62,78.85 150.62,81.76 151.13,82.27 151.13,84.82 150.83,85.12 150.83,85.48 151.1,85.76 151.1,86.06 151.18,86.14 151.18,91.91 140.05,103.03 138.09,103.03 137.28,102.22 122.38,102.22 122.07,102.52 108.58,102.52 107.01,104.1 107.01,109.22 105.03,111.2 105.03,115.84 105.76,116.57 105.76,116.93 105.03,117.66 105.03,117.84 102.87,120 v1(102.49,120)
  L6 w0.102: v1(209.68,30.47) 210.24,31.02 210.24,33.51 208.68,35.07 208.61,35.07 208.18,35.49 208.18,42.09 205.53,44.74 204.11,44.74 203.58,45.27 203.58,46.23 204.79,47.43 205.72,47.43 v1(206.22,47.94)
  BOTTOM w0.102: WWAN1.75 101.81,122.75 101.6,122.54 v1(101.6,122.29) 101.4,122.29 100.66,121.55 100.66,121.19 101.21,120.64 101.85,120.64 v1(102.49,120) ; v1(214,31.23) 213.87,31.23 213.74,31.36 212.22,31.36 211.33,30.47 v1(209.68,30.47)
NGFF_CONFIG_3: length 221.2
  TOP w0.102: KBC24.25 215.79,32.34 215.62,32.17 214.49,32.17 214.48,32.18 214.25,32.18 213.74,32.69 v1(213.74,32.78) ; AFTP6254.1 v1(101.47,106.03) R6204.1
  L4 w0.102: v1(205.55,47.95) 205.55,49.49 203.21,51.83 194.61,51.83 192.59,53.85 186.4,53.85 185.47,52.92 159.73,52.92 156.61,56.04 156.61,61.26 154.54,63.33 154.41,63.33 153.75,63.99 151.86,63.99 151.81,64.04 149.67,64.04 148.98,63.36 148.45,63.36 147.62,64.19 147.62,72.79 148.34,73.5 148.34,76.85 150.4,78.92 150.4,81.83 150.93,82.36 150.93,84.12 150.37,84.67 150.09,84.67 149.83,84.92 149.83,85.28 150.09,85.53 150.37,85.53 150.9,86.06 150.9,91.81 140.7,102.02 122.28,102.02 121.97,102.32 108.5,102.32 106.81,104.01 106.81,109.14 104.83,111.12 104.83,117.57 102.95,119.44 101.9,119.44 101.51,119.83 101.51,120.21 101.24,120.48 100.86,120.48 100.59,120.21 100.59,120.01 99.57,118.98 99.57,118.73 v1(100.08,118.22)
  L6 w0.102: v1(205.55,47.95) 205.27,47.66 204.71,47.66 203.37,46.32 203.37,45.18 204.03,44.51 205.45,44.51 207.87,42.1 207.87,35.54 207.85,35.52 207.85,34.53 209.68,32.7 v1(209.68,31.48)
  BOTTOM w0.102: WWAN1.1 101.98,104.25 101.47,104.76 v1(101.47,106.03) 101.47,107.05 100.71,107.81 100.71,117.59 v1(100.08,118.22) ; v1(213.74,32.78) 213.71,32.75 v2(213.13,32.75) 213.11,32.75 212.72,32.37 210.57,32.37 v1(209.68,31.48) ; v2(205.61,47.31) 205.61,47.88 v1(205.55,47.95)
NGFF_DEVSLP1: length 96.8
  TOP w0.102: R6216.2 R6209.2 90.58,114.31 90.2,113.93 v1(90.11,113.93) ; v1(87.78,91.02) 87.78,91.02 87,91.81 87,94.32 86.36,94.95 v1(86.36,95.62)
  L3 w0.102: v1(90.11,113.93) 88.54,112.36 88.54,109.81 88.27,109.54 88.11,109.54 86.79,108.22 86.79,96.05 v1(86.36,95.62)
  L4 w0.102: v1(87.78,91.02) 88.06,91.3 94.74,91.3 101.57,98.13 108.24,98.13 109.22,97.16 109.22,97.15 109.35,97.03 109.35,95.58 111.04,93.89 116.9,93.89 117.99,94.98 118.29,94.98 118.29,94.98 125.22,94.98 125.23,94.98 125.35,94.98 125.6,94.73 128.52,94.73 129.67,93.58 131.57,93.58 132.31,92.85 132.5,92.65 132.5,92.65 134.18,90.98 134.18,90.98 135,90.15 135,89.95 135.84,89.11 136.28,89.11 136.75,88.64 136.75,85.15 136.12,84.52 v1(136.12,83.35)
  BOTTOM w0.089: CPU1.J2 131.51,81.65 131.62,81.65 131.71,81.62 132.43,81.62 132.67,81.85
  BOTTOM w0.102: 132.67,81.85 134.45,81.85 135.43,82.84 135.43,83.08 135.65,83.3 136.07,83.3 136.12,83.35 v1(136.12,83.35) ; v2(87.3,95.77) 86.51,95.77 v1(86.36,95.62)
