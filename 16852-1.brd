# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
3D3V_S5_IT8010: length 7
  TOP w0.254: v1(72.26,78.34) 72.41,78.19 U9601.18
  BOTTOM w0.508: v2(77.72,78.09) 77.58,78.23 R9601.2 75.87,78.23 C9601.1 74.62,78.28 74.56,78.34 73.91,78.34 73.41,77.84 72.77,77.84 v1(72.26,78.34)
3D3V_S5_KBC: length 597.8
  TOP w0.203: KBC24.19 218.33,29.94 218.38,29.98 ; KBC24.65 201.17,35.77 200.91,36.03 v1(200.61,36.03) ; KBC24.5 217.65,24.34 v1(217.86,24.55) 218.07,24.55 C2420.1 ; KBC24.115 209.91,20.06 v1(209.91,20.05) ; KBC24.103 205.12,20.34 204.72,19.95 v1(204.09,19.95) ; KBC24.82 202.82,28.34 ; 210.79,38.3 211.11,37.98 KBC24.43 211.11,35.9 211.5,35.52 v1(211.58,35.52) ; 218.38,31.1 218.34,31.14 KBC24.22
  TOP w0.508: C2414.1 218.38,31.93 217.93,32.37 v1(217.93,32.62) ; v1(173.48,22.24) 173.72,21.99 FC2401.1 ; v1(103.1,7.48) 102.59,6.97 R2420.2 R2455.2 ; v1(205.04,30.3) 205.04,29.18 204.2,28.34 202.82,28.34 ; ED4306.2 232.32,34.32 231.87,34.32 230.94,35.25 230.94,37.72 ED4305.2 229.32,37.74 v1(228.6,37.02) ; C2411.1 v1(201.93,19.42) ; PR4411.1 242.25,17.19 242.95,17.89 242.95,19.29 242.35,19.89 PR4412.1 241.2,21.19 243.76,23.76 v1(243.79,23.76) ; v1(209.91,20.05) 209.91,19.87 210.16,19.62 C2422.1 ; 210.79,38.3 210.79,38.77 210.03,39.53 209.84,39.53 v1(209.68,39.68) 209.78,39.68 210.38,40.28 C2410.1 210.38,41.6 C2417.1 R2446.2 211.05,43.04 v1(211.18,43.17) ; R2456.1 v1(91.68,5.61) ; R2518.2 91.05,8.13 91.68,7.49 v1(91.68,7.33)
  L3 w0.508: v1(204.09,19.95) 202.83,19.95 202.3,19.42 v1(201.93,19.42) ; v1(228.6,37.02) 228.07,37.55 226.65,37.55 226.27,37.93 222.74,37.93 222.03,38.64 219.53,38.64 218.19,37.3 218.19,35.65 217.46,34.92 217.46,33 217.83,32.62 v1(217.93,32.62) 217.93,32.37 216.66,31.1 216.66,25.74 v1(217.86,24.55) ; v1(184.82,21.55) 185.09,21.29 185.09,12.94 183.43,11.29 148.37,11.29 148.14,11.05 145.37,11.05 143.39,9.07 132.48,9.07 131.83,8.42 131.83,5.53 131,4.71 120.03,4.71 118.96,5.78 118.71,5.78 118.12,6.36 118.05,6.36 117.46,6.96 117.46,8.05 v1(116.69,8.82) ; v1(243.79,23.76) 243.51,24.04 243.51,27.46 242.95,28.02 242.95,28.06 241.94,29.08 241.94,30.69 240.73,31.9 240.73,34.69 241.76,35.73 v1(241.76,38.18) ; v1(78.36,85.33) 78.22,85.2 78.22,78 77.37,77.15 v1(77.37,73.7)
  L4 w0.508: v1(77.37,73.7) 76.97,73.3 68.7,73.3 68.48,73.52 67.11,73.52 66.83,73.24 62.18,73.24 61.56,73.86 61.56,75.76 60.65,76.67 59.49,76.67 59.01,76.19 56.13,76.19 52.3,72.35 v1(45.42,72.35) ; v1(91.68,7.33) 91.45,7.33 90.33,6.21 86.11,6.21 85.06,7.25 76.06,7.25 75.86,7.05 74.16,7.05 73.37,7.83 65.06,7.83 65.03,7.81 63.83,7.81 63.37,7.35 58.8,7.35 57.66,8.49 57.01,8.49 56.99,8.47 52.73,8.47 52.5,8.24 50.3,8.24 50.07,8.47 45.37,8.47 44.29,9.55 43.48,9.55 40.31,12.71 40.31,21.94 41.75,23.38 43.03,23.38 43.05,23.36 45.35,23.36 48.96,26.97 48.96,32.59 53.77,37.4 53.77,38.49 54.7,39.42 55.79,39.42 56.03,39.66 57.84,39.66 58.88,40.7 58.88,45.81 59.11,46.04 59.11,47.75 58.5,48.36 58.5,52.36 58.93,52.79 58.93,53.58 58.55,53.96 58.55,58.28 57.34,59.48 47.43,59.48 45.96,60.95 v1(41.88,60.95) ; v1(197.3,15.03) 198.66,15.03 199.14,15.5 199.83,15.5 200.09,15.25 200.83,15.25 201.35,15.77 201.35,15.85 202.37,16.88 202.73,16.88 203.25,17.4 203.25,17.76 204.09,18.59 v1(204.09,19.95) 204.7,20.56 209.4,20.56 v1(209.91,20.05) ; v1(173.48,22.24) 173.61,22.11 184.26,22.11 v1(184.82,21.55) 185.48,20.89 188.18,20.89 188.59,21.3 189.11,21.3 189.52,20.89 198.26,20.89 198.87,20.28 201.07,20.28 v1(201.93,19.42) ; v1(217.93,32.62) 217.68,32.62 216.15,34.15 212.84,34.15 211.58,35.41 v1(211.58,35.52) 211.46,35.39 211.46,35.23 210.78,34.55 206.32,34.55 205.16,35.72 204.05,35.72 v1(203.7,35.37) 201.44,35.37 200.79,36.03 v1(200.61,36.03) ; v1(241.76,38.18) 243.71,36.23 259.86,36.23 260.06,36.26 260.74,36.94 263.02,36.94 263.25,37.18 266.73,37.18 267.87,38.31 275.44,38.31 v1(276.87,39.74) 276.87,39.75 277.11,39.99 277.11,42.75 v1(278.91,44.55)
  L6 w0.508: v1(211.58,35.52) 211.46,35.65 211.46,35.98 210.51,36.93 210.51,39.06 209.88,39.68 v1(209.68,39.68)
  BOTTOM w0.305: v1(223.77,9.64) 222.96,8.82 RN2402.1 223.01,8.6 223.01,8.11 222.88,7.99 222.45,7.99 222.31,8.13 RN2402.2
  BOTTOM w0.381: R2607.1 76.4,85.88 77.83,85.88 78.36,85.35 v1(78.36,85.33)
  BOTTOM w0.508: 206.68,30.47 206.68,26.05 206.12,25.49 206.12,21.98 v1(204.09,19.95) 201.99,22.04 C2413.1 ; 206.68,30.47 206.68,31.45 205.17,32.96 204.78,32.96 203.81,33.93 203.81,35.26 v1(203.7,35.37) ; 206.68,30.47 205.21,30.47 v1(205.04,30.3) 205.04,30.35 204.53,30.86 R2496.2 ; v1(41.88,60.95) 44.35,63.41 44.35,66.58 45.42,67.65 v1(45.42,72.35) ; v1(200.61,36.03) 200.84,36.03 201.32,35.55 R2450.2 201.36,35.55 C2412.1 ; R2415.2 201.17,20.18 v1(201.93,19.42) ; v1(228.6,37.02) 234.81,37.02 234.81,37.01 235.64,37.01 237.74,34.91 239.93,34.91 ED4304.2 240.44,35.07 241.94,36.56 241.94,38.01 v1(241.76,38.18) ; v1(223.77,9.64) 223.77,10.53 225.4,12.15 225.4,13.13 225.35,13.18 225.35,14.72 224.46,15.61 221.02,15.61 219.82,16.81 219.82,17.2 218.31,18.7 218.31,24.09 v1(217.86,24.55) ; v1(197.3,15.03) 197.2,15.03 R4032.1 ; C2429.1 217.82,33.96 217.46,33.6 217.46,33 217.83,32.62 v1(217.93,32.62) ; v1(211.18,43.17) 210.92,42.91 R2462.2 ; v1(116.69,8.82) 116.61,8.75 115.89,8.75 FC9713.1 115.51,8.75 112.94,8.75 112.3,9.38 111.78,9.38 111.22,8.82 104.44,8.82 v1(103.1,7.48) 102.36,8.21 v2(93.73,8.21) 92.11,8.21 FC9714.2 91.68,7.78 v1(91.68,7.33) v1(91.68,5.61) ; v1(276.87,39.74) 276.87,40.44 R2478.2 277.18,40.63 R2414.2 ; R2476.2 279.15,44.82 278.91,44.58 v1(278.91,44.55)
3D3V_S5_PCH: length 393.6
  TOP w0.305: v3(148.59,71.11) 148.13,70.65 v2(143.99,70.65) 143.61,70.65 143.34,70.92 137.69,70.92 135.86,72.76 132.52,72.76 R1820.1 ; RN1811.2 131.88,87.42 v1(132.21,87.74) 132.53,87.42 RN1811.1 ; v1(147.65,62.55) 147.46,62.36 143.75,62.36 140.13,65.97 v1(136.65,65.97)
  TOP w0.508: v1(224.28,5.29) 225.15,6.16 225.15,10.08 226.01,10.94 Q2401.G 227.04,10.4 R2461.1 227.9,10.23 228.55,9.59 v1(229.01,9.59) ; v1(150.88,58.18) 150.5,58.56 148.77,58.56 148.39,58.18 146.52,58.18 R1814.1
  L3 w0.508: v1(183.66,26.01) 183.69,26.01 183.96,25.74 184.49,25.74 184.64,25.89 185.48,25.89 186.33,25.03 187.56,25.03 189.85,22.74 189.85,21.33 193.77,17.41 199.31,17.41 199.85,16.88 202.7,16.88 203.08,17.26 210.81,17.26 211.4,16.67 212.47,16.67 213.19,15.95 214.66,14.49 225.91,14.49 226.44,13.96 226.45,13.96 229.01,11.39 229.01,10.44 v1(229.01,9.59) 229.24,9.81 232.37,9.81 232.77,9.41 233.72,9.41 234.67,10.36 234.67,10.37 235.05,10.75 235.05,11.21 236.25,12.41 237.36,12.41 239.11,14.16 241.03,14.16 242.16,15.29 242.16,16.37 244.42,18.63 244.42,19.39 245.85,20.81 245.85,24.58 246.1,24.84 246.1,25.34 247.82,27.06 251.54,27.06 252.95,25.65 253.74,25.65 254.41,26.32 254.41,29.4 v1(255.47,30.47) ; 148.59,71.14 148.59,74.35 148.92,74.68 v1(148.92,75.17) 148.36,75.17 145.44,78.09 145.44,80.63 142.52,83.55 142.11,83.55 139.45,86.22 135.47,86.22 133.95,87.74 v1(132.21,87.74)
  L4 w0.381: v1(154.69,62.22) 153.42,62.22 152.01,63.62 151.71,63.62 151.66,63.68 150.3,63.68 149.1,62.47 147.83,62.47 147.75,62.55 v1(147.65,62.55)
  L4 w0.508: v1(224.28,5.29) 221.28,5.29 v1(220.4,4.4) ; v1(120.69,10.93) 120.99,11.22 121.6,11.22 122.18,11.8 154.47,11.8 154.51,11.76 163.08,11.76 164.66,13.35 164.66,18.1 171.04,24.48 182.51,24.48 183.64,25.61 183.64,25.99 v1(183.66,26.01)
  L6 w0.508: v1(183.66,26.01) 183.03,26.64 183.03,29.05 182.84,29.24 182.84,29.49 178.94,33.39 178.94,42 v1(178.94,42) ; v1(74.42,7.68) 77.87,11.13 102.78,11.13 102.99,11.35 111.09,11.35 112.33,12.58 115.59,12.58 116.01,12.16 118.93,12.14 119.4,12.14 120.61,10.93 v1(120.69,10.93)
  L6 w0.635: v4(128.45,93.45) 128.97,92.93 128.97,92.66 129.53,92.1 130.01,92.1 131.69,90.42 131.69,88.19 132.09,87.79 132.16,87.79 v1(132.21,87.74)
  BOTTOM w0.305: RN2501.4 153.92,61.46 153.95,61.43 R2501.2 154.69,61.64 v1(154.69,62.22) 153.23,62.22 RN2501.3 ; v1(136.65,65.97) 136.96,66.28 R1824.1 ; RN1802.2 147.54,65.83 v1(148.36,65.01) ; Q2604.5 220.83,5.29 220.4,4.86 v1(220.4,4.4) ; RN1802.1 147.77,67.49 148.91,68.63 R2007.1
  BOTTOM w0.406: Q2604.2 v1(224.28,5.29)
  BOTTOM w0.508: v4(128.45,93.45) 128.54,93.36 RN1602.4 ; v1(74.42,7.68) 73.71,7.68 R9103.2 ; R411.1 141.86,50.48 145.21,47.13 v1(145.21,46.82) ; v1(178.94,42) 178.91,41.97 178.91,41.96 178.71,41.76 178.34,41.39 176.14,41.39 174.33,43.2 174.33,43.2 173.18,44.35 173.17,44.35 172.36,45.16 167.76,45.16 167.73,45.13 166.41,45.13 166.06,44.78 153.35,44.78 v1(151.31,46.82) ; v1(255.47,30.47) 255.12,30.82 R9146.1 ; v1(150.88,58.18) 150.44,58.61 149.01,58.61 SKT25.8 ; R2007.1 149.29,68.82 150.37,69.9 150.37,70.72 149.99,71.11 v3(148.59,71.11)
  BOTTOM w0.635: v3(148.59,71.11) 148.46,71.23 R1112.1
  vias: v1(148.84,46.82) v1(149.63,46.82) v1(150.42,46.82) v1(155.98,52.33) v3(151.38,67.04)
3D3V_S5_WLAN:
  vias: v1(36.6,49.64) v1(37.23,49.64) v1(38.73,66.41) v1(39.24,65.9)
3D3V_S5_WWAN: length 47.8
  TOP w0.305: v1(95.25,123.81) 96.41,124.97 FC6201.1 ; v1(90.11,117.97) 90.13,117.95 90.13,117.17 90.66,116.64 R6208.2 ; R6204.2 v1(99.06,106.03) ; R6227.1 77.6,107.94 77.34,107.68 77.34,107.05 76.83,106.54 R6303.2
  TOP w0.508: v1(90.12,114.89) 90.22,115 91.2,115 91.63,114.56 R6209.1 ; v1(91.21,106.74) 91.24,106.74 91.63,106.35 R6217.2 ; R6302.2 77.6,109.84 v1(77.34,109.59) 77.66,109.27 R6227.1 ; R6201.2 v1(98.81,109.46) ; R6202.2 v4(100.52,124.38) ; R6203.2 94.87,123.43 v1(95.25,123.81) 94.55,124.51 C6201.1 C6202.1
  L3 w0.508: v1(90.12,114.89) 90.12,114.99 90.82,115.69 90.82,116.77 90.13,117.46 90.13,117.95 v1(90.11,117.97)
  L6 w0.508: v1(77.34,109.59) 78.49,108.44 87.12,108.44 87.76,107.81 90.64,107.81 91.21,107.23 v1(91.21,106.74)
  BOTTOM w0.508: v1(91.21,106.74) 91.24,106.74 92.25,105.73 v1(92.25,104.81) ; v1(90.11,117.97) 90.13,117.97 90.29,117.81 90.87,117.81 92.39,119.34 92.39,121.21 95,123.81 v1(95.25,123.81)
  vias: v3(92.99,104.82) v3(93.56,104.18)
3D3V_SPIVCC2: length 7.1
  TOP w0.508: C2506.1 102.84,9 102.17,9.68 C2507.1 ; C2506.1 102.84,8.39 101.66,7.21 R2420.1 ; C2506.1 102.11,8.62 v2(101.35,9.38) 101.27,9.31 SPI241.8
3D3V_TP_S5_R: length 4.7
  BOTTOM w0.381: C6503.2 196.91,17.51 R6520.1 v2(196.98,18.65) R6521.1 196.66,19.61 195.99,18.94 Q6504.S
3D3V_TPM: length 236.6
  TOP w0.305: U9101.8 252.5,32.93 252.5,32.5 v1(252.48,32.47)
  TOP w0.508: R9114.1 259.61,35.16 v1(260.2,34.58) ; Q9102.S 256.1,31.48 255.71,31.86 253.49,31.86 252.88,32.47 v1(252.48,32.47) ; R9119.1 246.68,33.78 246.68,34.17 v1(246.56,34.3) ; C9112.1 243.97,32.81 v1(243.97,32.18)
  L4 w0.508: v1(121.4,10.59) 121.87,10.59 122.46,11.19 154.18,11.19 154.22,11.15 163.33,11.15 165.27,13.09 165.27,17.81 171.24,23.78 184.81,23.78 v1(186.77,25.74) ; v1(243.97,32.18) 242.75,32.18 242.18,31.61 239.15,31.61 237.32,33.44 230.92,33.44 227.71,36.65 227.71,37.39 227.74,37.41 227.74,38.88 227.03,39.58 225.06,39.58 225.02,39.62 219.14,39.62 216.94,37.42 215.32,37.42 215.12,37.63 208.74,37.63 207.95,36.84 202.95,36.84 201.82,37.96 199.63,37.96 199.21,37.55 189.85,37.55 v1(187.38,35.08)
  L6 w0.508: v1(186.77,25.74) 187.38,26.35 v1(187.38,35.08) ; v1(121.4,10.59) 121.4,11.12 119.74,12.77 118.94,12.77 116.28,12.79 114.78,14.29 113.13,14.29 110.8,11.96 102.74,11.96 102.54,11.75 76.02,11.75 73.05,8.79 v1(72.69,8.79)
  BOTTOM w0.508: R9140.1 242.3,30.79 242.3,31.49 242.99,32.18 v1(243.97,32.18) 244.03,32.24 R9147.1 244.03,33.7 244.6,34.28 246.53,34.28 v1(246.56,34.3) 246.56,34.12 248.11,32.57 ; 248.11,32.57 248.72,33.18 249.58,33.18 ; 248.11,32.57 248.28,32.39 v2(248.28,31.86) 248.28,30.24 247.78,29.73 R9149.1 ; v1(260.2,34.58) 260.2,34.99 259.82,35.37 254.71,35.37 253.9,34.55 253.9,33.73 R9102.1 ; v1(72.69,8.79) 72.69,7.81 R9103.1 72.39,7.35 R9138.1 71.85,6.42 Q9103.G
3D3V_TPM_1: length 5.3
  BOTTOM w0.305: C9113.1 251.4,28.44 v2(251.25,28.59)
  BOTTOM w0.508: C9106.1 251.21,26.5 R9143.2 ; C9106.1 251.23,27.32 251.27,27.36 251.27,27.54 C9113.1 ; C9106.1 251.93,25.83 R9144.1
3D3V_VGA_S0: length 199.6
  TOP w0.406: v1(178.03,69.57) 178.3,69.3 Q7901.2 ; v1(181.85,68.82) 181.63,69.04 181.54,69.04 181.27,69.3 Q7901.5
  TOP w0.508: 177.05,65.39 175.93,65.39 175.77,65.24 175.55,65.24 R7942.1 175.13,64.82 175.13,64.66 174.85,64.37 174.41,64.37 174.2,64.16 ; v1(171.96,66.91) 171.96,66.58 173.81,64.73 173.81,64.6 174.2,64.21 174.2,64.16 ; PR8503.1 204.66,53.22 203.98,53.9 203.98,53.94 203.84,54.09 v1(203.84,54.9) ; 174.2,64.16 173.76,63.72 173.76,63.38 v1(173.35,62.98) ; 179.82,64.81 180.1,65.09 180.39,65.09 184.58,69.27 186.49,69.27 v1(186.55,69.22) 186.59,69.26 186.59,69.66 185.12,71.14 185.12,72.27 185.47,72.63 186.2,72.63 187.27,73.7 187.27,78.2 R7921.1 ; PR8505.1 206.5,56.63 v1(206.38,56.5) ; v1(176.11,76.74) 176.31,76.94 C8024.1
  L3 w0.508: v1(182.25,61.21) 181.3,62.15 180.58,62.15 ; 180.58,62.15 179.73,61.3 178.33,61.3 v1(177.8,60.77) ; 180.58,62.15 180.58,62.82 178.71,64.68 v1(178.71,64.81) ; v1(176.11,76.74) 176.17,76.67 176.27,76.67 177.49,75.45 177.49,75.05 177.59,74.95 177.59,74.44 177.55,74.39 177.55,70.06 v1(178.03,69.57)
  L4 w0.508: v1(200.79,105.14) 202.79,105.14 v1(205.69,102.25) ; v1(171.96,66.91) 170.87,66.91 169.95,67.83 169.95,68.13 168.25,69.84 167.12,69.84 166.8,70.15 165.36,70.15 162.36,73.15 162.36,73.68 162.98,74.31 163.07,74.31 163.42,74.65 163.42,75.23 161.32,77.33 v1(157.99,77.33) ; v1(178.03,69.57) 178.91,70.44 185.32,70.44 v1(186.55,69.22) 188.56,71.23 191.03,71.23 192.53,72.73 v1(192.53,80.45) 192.96,80.88 192.96,88.25 193.29,88.58 v1(193.29,88.61) ; v1(183.39,64.25) 183.87,64.25 184.83,65.21 193.74,65.21 196.22,62.73 196.22,62.24 197.51,60.95 200.06,60.95 201.43,59.57 202.84,59.57 203.43,58.99 203.49,58.99 203.86,58.62 203.86,58.04 204.22,57.68 204.22,56.24 204.59,55.87 205.88,55.87 206.38,56.36 v1(206.38,56.5)
  L4 w0.635: v1(205.69,102.25) 205.51,102.25 199.14,95.88 199.14,93.97 195.5,90.33 194.36,90.33 193.29,89.27 v1(193.29,88.61)
  BOTTOM w0.305: v1(192.53,80.45) 192.13,80.05 R7935.1 ; THM263.1 205.23,106.62 205.41,106.79 C2622.1
  BOTTOM w0.508: v1(173.35,62.98) PR8625.1 ; R2617.1 206.32,106.86 C2622.1 206.26,105.76 C2621.1 206.38,104.08 Q2606.G 205.64,102.29 v1(205.69,102.25) ; PC8605.1 184.19,60.09 PR8601.2 ; PC8605.1 PC8604.1 182.14,61.11 182.25,61.21 v1(182.25,61.21) ; PC8605.1 183.95,61.85 PQ8609.D 183.26,63.64 183.39,63.77 v1(183.39,64.25) ; v1(177.8,60.77) 177.8,60.79 177.6,61 PR8609.2 ; R2616.1 201.04,105.4 v1(200.79,105.14) ; v1(203.84,54.9) 204.52,54.21 v2(205.1,54.21) 205.99,55.1 PR8518.1 206.69,56.25 206.44,56.5 v1(206.38,56.5) ; R7903.2 193.07,89.56 193.07,88.83 v1(193.29,88.61) ; v1(157.99,77.33) 157.89,77.23 153.56,77.23 R7625.1 ; v1(181.85,68.82) 182.27,68.82 182.37,68.72 183.41,68.72 183.92,69.22 v1(186.55,69.22)
81208_AGND: length 9.7
  TOP w0.508: PC4628.2 143.32,117.65 142.62,118.35 142.62,120.71 143.5,121.59 144.72,121.59 145.1,121.2 PR4636.2 145.1,119.78 PR4635.2
  BOTTOM w0.381: PR4602.1 153.57,114.39 153.39,114.2 v1(153.17,114.2)
  BOTTOM w0.508: v1(153.17,114.2) 153.14,114.23 PR4611.2
  vias: v1(144.91,113.78) v1(145.67,113.78) v1(146.43,115.3) v1(146.43,114.54) v1(146.43,113.78) v1(146.43,113.02) v1(146.43,112.25) v1(147.19,113.78) v1(147.96,113.78) v2(145.2,115.16) v2(152.63,112.02)
+DC_IN: length 20
  TOP w0.356: PQ4305.2 60.81,103.44 60.7,103.44 57.28,106.87 57.28,107.81
  TOP w0.508: v1(49.65,101.82) 49.88,101.59 PR4312.1
  BOTTOM w0.508: v3(56.9,109.59) 56.16,108.85 56.16,106.41 51.57,101.82 v1(49.65,101.82)
  vias: v3(49.78,119.49) v3(49.78,118.6) v3(49.78,117.59) v3(50.8,119.49) v3(50.8,118.58) v3(57.4,108.57) v3(57.94,109.59) v3(58.9,109.56) v3(61.01,110.68) v3(62,110.75)
+DC_IN_C:
  vias: v2(55.04,110.2) v3(55.5,117.13) v3(55.88,117.97) v3(56.01,116.32) v3(56.41,117.16) v3(56.72,118.02)
+RTC_VCC: length 4.3
  TOP w0.508: AFTP2502.1 v1(230.12,42.78)
  BOTTOM w0.508: RTC1.1 229.34,42 v1(230.12,42.78) R2502.2
+SDC_IN: length 301.5
  TOP w0.203: PR4410.1 234.35,10.65 233.43,10.65 233.17,10.91 v1(233.17,10.98)
  L4 w0.203: v1(66.67,107.17) 66.93,106.92 70.61,106.92 71.37,107.68 71.37,113.14 73,114.77 75.91,114.77 77.91,112.76 82.93,112.76 86.04,115.87 89.91,115.87 89.91,115.86 90.31,115.86 90.31,115.87 91.74,115.87 92.03,115.58 98.86,115.58 101.83,118.55 102.64,118.55 103.86,117.33 103.86,117.33 103.91,117.27 103.91,110.07 104.65,109.33 104.65,108.7 105.66,107.68 105.66,103.87 108,101.53 109.8,101.53 109.93,101.41 120.95,101.41 121.92,100.44 140.84,100.44 149.38,91.91 149.38,88.39 146.99,86 146.99,81.43 146.99,81.43 146.99,81.05 142.81,76.87 142.81,71.22 142.81,70.84 141.43,69.45 141.43,66.03 143.89,63.56 143.89,60.1 146.78,57.21 147.45,57.21 155.09,49.57 157.66,49.57 158.39,50.3 171.66,50.3 173.76,48.2 183.35,48.2 185.52,50.37 185.52,51.17 187.53,53.18 188.15,53.18 188.15,53.18 188.86,53.18 189.17,52.87 191.87,52.87 194.21,50.53 203.18,50.53 204.29,49.42 204.29,48.37 205.44,47.23 207.26,47.23 207.77,47.74 209.8,47.74 211.2,46.34 214.88,46.34 215.7,47.15 218.05,47.15 218.05,47.15 218.43,47.15 221.72,43.86 221.72,42.73 v1(222.03,42.43)
  BOTTOM w0.203: v1(233.17,10.98) 233.53,10.63 233.53,9.28 234.57,8.24 236.78,8.24 239.47,10.93 239.9,10.93 239.93,10.91 243.02,10.91 244.6,12.49 244.6,16.2 243.76,17.04 243.76,18.84 239.28,23.33 237.92,23.33 236.37,24.88 236.37,25.7 236.57,25.9 236.57,28.05 236.35,28.28 236.35,32.14 236.73,32.53 236.73,33.16 234.09,35.79 228.26,35.79 224.8,39.25 222.67,39.25 222.03,39.89 v1(222.03,42.43)
  vias: v2(72.44,104.38)
+UZ12_TPM: length 6.4
  TOP w0.305: U9104.8 252.23,30.63 v1(252.65,31.05)
  BOTTOM w0.508: v2(252.93,29.8) 253.66,29.07 R9145.2 253.91,29.88 C9117.1 253.91,29.93 253.91,30.69 R9146.2 252.88,30.82 v1(252.65,31.05) 252.45,30.85 C9114.1
+V_VREF_PATH1: length 2.1
  BOTTOM w0.508: C1222.2 88.53,9.05 R1209.1 88.89,8.46 88.9,8.44 v2(88.9,8.37)
+V_VREF_PATH2: length 1.9
  BOTTOM w0.508: R1309.1 C1323.2 87.6,55.7 87.6,54.93 v2(87.66,54.87)
A5_TP: length 4.1
  BOTTOM w0.102: CPU1.A5 129.67,86.82 131.37,88.52 131.37,89.82 TP2309.1
A67_TP: length 1.8
  TOP w0.102: v1(93.33,87.41) 92.87,87.87 TP2311.1
  BOTTOM w0.102: CPU1.A67 93.72,86.82 93.33,87.22 v1(93.33,87.41)
A70_TP: length 3.1
  TOP w0.102: v1(89.98,86.31) 89.84,86.45 TP2310.1
  BOTTOM w0.102: v1(89.98,86.31) 90.39,86.71 CPU1.A70
A_A0: length 4
  TOP w0.102: v2(68.91,76.21) 68.96,76.21 v1(69.42,75.75) 69.82,75.35 U9601.3
  BOTTOM w0.102: R9608.1 R9609.2 69.09,75.42 v1(69.42,75.75)
A_A1: length 4.7
  TOP w0.102: U9601.2 69.93,75.85 69.72,76.06 69.72,76.69 v1(69.47,76.95) 69.47,77.25 v2(69.11,77.61)
  BOTTOM w0.102: R9607.2 R9606.1 68.52,76.95 v1(69.47,76.95)
A_A2: length 5.4
  TOP w0.102: v1(70.36,77.07) 70.37,77.06 U9601.1
  BOTTOM w0.102: v1(70.36,77.07) 70.23,77.07 69.6,77.71 68.64,77.71 R9604.1 68.49,78.32 R9605.2 69.49,78.98 v2(69.62,79.11)
AC_DIS: length 320
  TOP w0.102: v1(165.79,34.76) 157.45,34.76 151.07,41.13 150.15,42.06 147.01,42.06 123.87,42.06 122.94,41.13 118.18,36.38 117.42,36.38 62.59,36.38 v1(61.49,37.48) ; KBC24.69 202.23,33.54 202.26,33.51 202.74,33.51 v1(203.13,33.9) ; PQ4403.G 238.37,24.91 v1(238.33,24.95) ; v1(50.9,102.88) 50.93,102.85 50.93,102.72 51.18,102.47 52.96,102.47 53.39,102.91 PQ4306.5 53.39,104.05 53.67,104.33 54.66,104.33 v2(55.83,103.16) 56.48,102.51 PQ4304.B
  L3 w0.102: v1(50.9,102.88) 49.33,102.88 43.92,97.47 41.35,97.47 40.94,97.06 40.94,97.06 40.69,96.81 40.69,96.81 40.64,96.76 33.66,96.76 31.62,94.73 31.62,83.75 30.15,82.28 30.15,76.01 32.33,73.82 32.33,65.18 36.78,60.73 36.78,54.41 39.95,51.24 45.63,51.24 46.21,50.66 49.75,50.66 50.73,49.68 52.36,49.68 54.67,47.37 58.78,47.37 59.26,46.89 59.26,44.82 59.23,44.8 59.23,40.27 60.93,38.57 60.93,38.03 v1(61.49,37.48) ; v1(238.33,24.95) 237.26,26.02 235.73,26.02 232.11,29.64 232.11,38.23 231.39,38.95 230.53,38.95 229.77,38.19 226.92,38.19 225.86,39.25 223.78,39.25 223.1,39.94 219.28,39.94 218.72,40.5 216.65,40.5 216.15,40 216.15,37.61 214.83,36.29 214.83,34.2 215.57,33.46 215.57,32.56 215.32,32.31 214.99,32.31 214.62,31.94 206.3,31.94 205.38,32.85 204.42,32.85 203.49,33.79 203.25,33.79 v1(203.13,33.9) 202.48,34.55 185.42,34.55 185.12,34.25 168.36,34.25 167.87,34.74 166.95,34.74 166.9,34.68 165.86,34.68 v1(165.79,34.76)
AC_DIS_M: length 35.5
  TOP w0.254: v1(218.09,33.26) 218.67,33.26 219.6,34.19 PU4403.4 ; v1(234.95,28.76) 234.95,28.43 235.59,27.8 v2(235.59,27.67) 235.81,27.44 PR4422.2
  TOP w0.508: PR4422.2 237.15,27.44 PQ4403.D
  L6 w0.254: v1(234.95,28.76) 234.64,28.45 232.85,28.45 229.69,31.61 229.69,33.64 226.99,36.35 226.99,36.97 226.05,37.91 222.94,37.91 222.2,38.64 218.67,38.64 218.39,38.36 218.39,35.67 218.03,35.32 218.03,33.32 v1(218.09,33.26)
AC_IN#_G: length 5.1
  TOP w0.254: PQ4306.2 53.39,100.75 53.14,100.49 52.1,100.49 v2(51.66,100.06) 51.49,100.24 51.49,100.59 50.99,101.09 PR4312.2 50.75,101.06 PR4313.1
AC_IN_KBC#: length 3
  TOP w0.102: AFTP4316.1 50.22,102.83 50.7,103.31 PQ4306.6
AC_PRESENT: length 143.5
  L4 w0.102: v1(173.96,56.53) 173.79,56.35 172.37,56.35 171.94,56.78 168.65,56.78 168.49,56.94 168.49,59.39 168.25,59.62 165.25,59.62 162.31,62.57 162.31,69.32 v1(162.18,69.45) ; v1(125.63,57.06) 127.23,57.06 129.74,54.55 129.74,50.01 153.45,26.3 172.22,26.3 177.85,31.93 177.85,35.42 v1(178.18,35.75)
  L6 w0.102: v1(178.08,42.02) 177.88,41.82 177.88,36.05 v1(178.18,35.75)
  BOTTOM w0.102: v1(162.18,69.45) 162.18,69.45 162.18,70.22 161.81,70.58 160.86,70.58 160.66,70.78 v2(159.89,70.78) 159.88,70.77 157.94,70.77 157.67,71.04 EC1707.1 157.46,71.45 Q1702.3 ; CPU1.AY15 123.33,65.3 123.66,64.98 123.66,62.32 124.99,60.98 124.99,58.47 125.63,57.83 v1(125.63,57.06) 125.11,56.54 RN1701.4 ; v1(178.08,42.02) 178.51,42.45 179.62,42.45 179.63,42.46 180.04,42.46 180.84,43.25 180.84,50.26 D1703.A 181.86,51.42 179.4,53.88 175.27,53.88 174.09,55.06 174.09,56.4 v1(173.96,56.53)
ACAV_IN: length 4.5
  TOP w0.254: KBC24.128 215.18,21.26 217.87,21.26 218.12,21.51 R2469.2 v2(218.57,22.46)
ACOK_IN: length 356.2
  TOP w0.254: v1(76.07,108.19) 76.05,108.19 75.82,108.42 75.21,108.42 74.75,108.87 PQ4402.2 ; v1(236.19,4.33) 236.19,4.66 236.17,4.68 236.17,6.21 234.77,7.61 v2(234.77,9.38) 234.77,10.16 PR4416.1
  L3 w0.254: v1(76.07,108.19) 76.2,108.06 76.2,106.92 76.83,106.28 76.83,103.62 74.55,101.33 74.55,95.94 72.47,93.85 72.47,91.46 72.41,91.32 72.37,91.13 72.37,90.95 72.41,90.77 72.47,90.63 72.47,84.85 71.73,84.11 67.35,84.11 64.41,81.16 64.19,81.01 61.69,78.52 61.55,78.3 61.55,72.61 58.68,69.74 58.68,68.2 58.65,68.17 58.65,67.65 61.42,64.88 61.42,62.66 59.94,61.19 59.94,58.02 62.61,55.36 64.26,55.36 64.64,54.98 67.31,54.98 67.69,55.36 70.36,55.36 v1(72.26,53.45) ; v1(236.19,4.33) 235.15,3.29 225.07,3.29 224.97,3.19 222.53,3.19 222.35,3.01 218.71,3.01 218.67,3.05 208.29,3.05 205.18,6.16 199.09,6.16 197.7,7.54 191.4,7.54 190.82,6.96 185.29,6.96 182.63,4.3 177.04,4.3 174.38,6.96 146.55,6.96 142.23,2.64 136.16,2.64 135.15,1.64 112.65,1.64 112.64,1.63 84.45,1.63 84.07,1.26 81.28,1.26 80.9,1.64 67.94,1.64 67.64,1.94 65.35,1.94 65.2,2.09 v1(63.86,2.09)
  L6 w0.254: v1(63.86,2.09) 63.35,2.09 59.75,5.7 47.9,5.7 40.07,13.53 40.07,16.51 40.07,16.87 44.94,21.75 57.68,21.75 73.03,37.1 73.03,47.91 71.99,48.95 71.99,51.18 72.26,51.46 v1(72.26,53.45)
AD+: length 286.4
  TOP w0.203: PD4402.A v1(236.85,25.08) PR4422.1 ; PR4431.1 240.21,9.94 v1(239.7,10.45) PR4408.1
  L4 w0.203: v1(222.88,42.02) 222.53,41.67 221.71,41.67 221.27,42.11 221.27,43.67 218.24,46.7 215.89,46.7 215.07,45.88 211.01,45.88 209.61,47.28 207.96,47.28 207.45,46.77 205.18,46.77 203.83,48.12 203.83,48.82 203.84,48.82 203.84,49.23 202.99,50.07 194.02,50.07 191.68,52.41 188.98,52.41 188.67,52.72 187.72,52.72 185.98,50.98 185.98,50.18 183.54,47.74 173.57,47.74 171.47,49.85 158.58,49.85 157.85,49.11 154.9,49.11 147.26,56.75 146.59,56.75 143.43,59.91 143.43,63.37 140.97,65.84 140.97,69.64 142.35,71.03 142.35,77.06 146.53,81.24 146.53,86.19 148.89,88.55 148.89,91.64 140.6,99.93 121.77,99.93 120.75,100.95 109.73,100.95 109.6,101.08 107.8,101.08 105.21,103.67 105.21,107.38 104.14,108.44 104.14,109.08 103.38,109.84 103.38,117.16 102.45,118.09 102.02,118.09 99.05,115.12 91.84,115.12 91.55,115.41 89.72,115.41 89.72,115.41 86.29,115.41 83.13,112.25 77.77,112.25 77.55,112.47 75.72,114.31 73.19,114.31 72.23,113.35 72.23,112.76 v1(72.88,112.11)
  BOTTOM w0.203: v1(239.7,10.45) 243.2,10.45 245.06,12.3 245.06,16.39 244.22,17.23 244.22,19.06 239.86,23.43 239.86,23.43 239.5,23.78 238.15,23.78 v1(236.85,25.08) 236.85,25.51 237.11,25.77 237.11,28.18 236.85,28.43 236.85,30.91 PR4430.1 237.24,32.31 237.24,33.3 234.28,36.25 228.45,36.25 224.99,39.71 223.81,39.71 223.8,39.73 222.84,39.73 222.62,39.95 222.62,41.75 v1(222.88,42.02)
  vias: v2(70.66,112.05)
AD+_G_1: length 4.3
  TOP w0.254: 74.75,106.67 PQ4402.5 ; 74.75,106.67 74.75,106.36 v2(74.32,105.93) 74.17,105.78 PR4406.1 ; 74.75,106.67 75.08,106.67 75.4,106.99 PQ4402.6
AD+_G_2: length 3.5
  TOP w0.254: PR4406.2 71.67,105.78 PR4403.2 71.55,105.89 v2(71.55,106.77) 71.4,106.91 PU4402.4
AD_IA: length 45.4
  TOP w0.102: PC4423.1 241.17,13.12 v1(240.77,13.52) 240.36,13.12 PG4401.2 ; v1(209.02,19.34) 209.17,19.19 v2(209.17,18.76) 208.75,18.34 R2421.1
  L4 w0.102: v1(240.77,13.52) 238.86,13.52 235.99,10.65 233.78,10.65 233.35,10.22 232.99,10.22 232.03,11.19 227.51,11.19 226.9,10.58 214.69,10.58 214.1,9.99 v1(213.08,9.99)
  BOTTOM w0.102: v1(213.08,9.99) 212.85,10.22 212.85,16.72 210.24,19.34 v1(209.02,19.34)
AD_OFF_L: length 5.2
  TOP w0.254: PQ4305.1 60.12,102.49 58.3,104.32 PQ4304.C 57.18,105.1 v2(57.18,105.93)
AD_OFF_R: length 8.5
  TOP w0.254: PR4308.1 60.93,106.03 PR4307.2 PC4301.2 58.42,106.51 v2(57.86,107.07) ; PR4308.1 61.8,105.83 61.11,105.14 PQ4305.3 ; PR4308.1 61.8,106.79 62.42,107.42 PU4301.4
ALL_SYS_PWRGD: length 293.9
  TOP w0.127: v1(169.93,32.5) 168.78,33.64 166.99,33.64 166.59,33.24 157.16,33.24 149.62,40.79 146.49,40.79 124.39,40.79 118.7,35.1 58.21,35.1 57.78,35.52 v1(57.78,35.93) ; R2481.2 207.04,40.66 207.04,41.35 v1(206.83,41.55)
  L3 w0.127: v1(182.37,32.78) 182.21,32.94 170.37,32.94 v1(169.93,32.5) ; v1(89.6,93.2) 89.34,93.2 87.34,91.2 87.34,90.17 82.82,85.65 81.5,85.65 80.68,86.46 76.99,86.46 75.49,84.96 75.49,83.74 77.77,81.45 77.77,78.96 77.19,78.37 77.18,78.37 76.87,78.06 76.87,73.56 77.98,72.46 v1(77.98,70.09)
  L4 w0.127: v1(66.17,50.53) 65.28,49.64 65.28,41.77 64.47,40.96 62.08,40.96 57.78,36.66 v1(57.78,35.93) ; v1(206.83,41.55) 206.47,41.55 206.42,41.5 195.72,41.5 194.82,42.4 v1(194.18,42.4) 191.22,39.44 189.27,39.44 188.02,40.69 186.06,40.69 185.3,39.93 183.58,39.93 183.13,39.48 182.17,39.48 v1(181.94,39.25)
  L6 w0.127: v1(194.18,42.4) 194.31,42.28 194.31,39.58 196.2,37.7 196.2,34.19 197.04,33.34 197.04,31.16 196.59,30.71 196.59,28.38 195.44,27.22 195.44,25.42 196.81,24.05 196.81,16.84 196.3,16.33 196.05,16.33 195.64,15.92 195.64,15.16 196.22,14.58 196.22,13.19 v1(196.34,13.07) ; v1(181.94,39.25) 181.86,39.18 181.86,33.44 182.37,32.93 v1(182.37,32.78)
  BOTTOM w0.127: R1716.1 v1(89.6,93.2) EC1709.1 ; v1(77.98,70.09) 77.79,69.9 77.79,67.59 75.06,64.86 75.06,64.5 74.8,64.25 74.8,55.21 72.29,52.69 71.86,52.69 69.9,50.73 v2(68.22,50.73) 66.37,50.73 v1(66.17,50.53) ; v1(196.34,13.07) 196.34,12.22 196.68,11.88 197.54,11.88 197.65,11.77 197.65,10.74 198.06,10.33 D4002.1 197.47,9.22 196.62,8.37 195.11,8.37 R4005.2 R4002.1 194.65,9.81 R4011.2
ALWON: length 179.3
  TOP w0.127: v1(211.46,23.99) 212.48,22.96 212.48,22.25 212.31,22.09 KBC24.121 ; R4009.2 53.44,35.58 53.94,36.09 55.47,36.09 56.44,35.13 56.8,35.13 57.2,34.72 57.46,34.47 118.44,34.47 119.35,34.47 125.04,40.16 145.04,40.16 149.36,40.16 156.9,32.61 167,32.61 167.08,32.69 167.44,32.69 168.15,31.98 169.27,31.98 v2(169.87,31.39) 170.31,30.95 v1(170.31,30.06)
  L3 w0.127: v1(170.31,30.06) 170.32,30.07 183.81,30.07 184.86,29.03 187.64,29.03 190.54,26.13 190.54,24.16 191.29,23.41 191.29,22.09 192.96,20.42 193.99,20.42 194.96,19.45 200.85,19.45 201.89,20.5 202.24,20.5 202.76,21.02 205.13,21.02 206.39,22.27 206.39,23.11 206.88,23.59 207.37,23.59 207.56,23.78 211.23,23.78 211.44,23.99 v1(211.46,23.99)
AMBER_LED_BAT: length 15.7
  TOP w0.508: Q6403.C 208.47,5.32 208.47,4.05 EC6402.1 209.41,3.92 209.54,3.8 210.07,3.8 210.19,3.92 217.36,3.92 v1(218.09,4.65) 218.09,4.72 218.69,5.32 v2(219.84,5.32)
  BOTTOM w0.508: v1(218.09,4.65) 218.44,5 R6407.1
ATI_RST#: length 5
  BOTTOM w0.102: R7621.1 R7625.2 152.45,77.14 R7623.2 151.3,77.4 v2(150.55,77.4) 149.89,77.4 D7601.3
AUD_AGND: length 27.5
  TOP w0.203: v1(27.81,9.71) 27.81,9.81 27.61,10.02 HDA27.38 ; v1(21.11,8.49) 21.41,8.8 HDA27.25
  TOP w0.508: v1(16.89,14.69) R2707.2 17.74,14.96 18.54,15.76 R2730.1 19.18,15.83 EC2703.1 ; C2715.2 C2712.1 ; v1(16.03,10.88) EC2905.2 16.68,10.28 C2713.2 16.79,9.51 R2920.2 ; v1(24.64,2.25) 24.69,2.25 24.93,2.49 R2919.2 ; v1(15.14,14.69) 15.14,15.54 R2901.2
  BOTTOM w0.508: EC2908.2 21.48,3.99 v1(21.36,3.87) ; EC9743.1 EC9744.1 24.77,2.37 v1(24.64,2.25) 24.61,2.27 EC2907.2 ; v1(14.61,18.53) 15.33,19.25 EC2707.1 ; EC2705.1 EC9739.1 19.68,12.05 v2(18.99,12.74) 18.56,12.3 17.96,12.3 17.4,12.86 17.4,14.02 EC2906.2 17.34,14.25 v1(16.89,14.69)
  vias: v1(19.15,3.87) v1(20.42,3.9) v1(30.35,3.41) v1(30.35,2.4) v1(30.61,5.83) v1(30.61,4.81)
AUD_HP1_JACK_L: length 5.3
  TOP w0.203: HDA27.32 24.53,7.34 25.15,6.72 25.15,5.45
  TOP w0.254: R2908.1 24.93,3.83 25.15,4.05 v2(25.15,4.73) 25.15,5.45
AUD_HP1_JACK_L1: length 23
  TOP w0.254: R2912.2 24.2,3.98 R2908.2 R2919.1 23.94,3.06 v2(22.56,3.06) 22.12,2.63 v1(22.12,2.09) ; v1(14.14,8.57) 14.14,7.79 14.58,7.35 R2922.2
  L3 w0.254: v1(14.14,8.57) 14.12,8.57 13.77,8.21 13.77,6.36 15.95,4.18 15.95,3.01 17.48,1.48 21.51,1.48 v1(22.12,2.09)
  BOTTOM w0.254: EC2907.1 22.3,2.27 v1(22.12,2.09) 21.54,2.09 R2907.1
AUD_HP1_JACK_R: length 4.3
  TOP w0.203: 25.27,7.1 24.93,7.44 HDA27.33
  TOP w0.254: v2(25.6,6.54) 25.78,6.72 v1(25.78,7.1) 25.27,7.1
  BOTTOM w0.254: R2910.1 25.53,6.84 v1(25.78,7.1)
AUD_HP1_JACK_R1: length 26.6
  TOP w0.254: R2909.1 15.44,11.69 15.44,9.65 R2920.1 15.3,9.19 15.53,8.96 R2921.2 15.16,8.49 v1(14.48,9.18) ; v2(20.88,3.16) 21.56,3.16 v1(21.63,3.1)
  L3 w0.254: v1(14.48,9.18) 14.48,8.98 14.66,8.8 14.66,8.34 14.27,7.96 14.27,6.59 16.83,4.04 16.83,2.86 17.69,1.99 20.5,1.99 21.6,3.1 v1(21.63,3.1) 21.63,3.12 22.76,4.25 v1(26.14,4.25)
  BOTTOM w0.254: R2910.2 25.53,4.86 v1(26.14,4.25) ; R2913.2 EC2908.1 v1(21.63,3.1)
AUD_PC_BEEP_3246: length 2.7
  TOP w0.203: v1(20.02,12.94) 20.13,12.82 HDA27.16
  BOTTOM w0.254: v1(20.02,12.94) 20.47,12.94 v2(20.7,13.17) 20.78,13.24 20.78,13.93 20.64,14.07 R2723.1
AUD_PC_BEEP_C: length 5.5
  BOTTOM w0.254: D2701.3 20.14,18.35 19.68,17.89 v2(19.68,16.65) 19.71,16.62 19.71,16.51 R2717.1 19.58,15.8 C2720.1
AUD_PC_BEEP_R: length 0.9
  BOTTOM w0.254: C2720.2 19.75,14.82 R2723.2
AUD_PORTA_L_HPMIC1: length 17.6
  L3 w0.381: HPMIC1.1 11.96,7.3 15.24,4.02 15.24,2.86 v1(16.87,1.23)
  BOTTOM w0.381: v1(16.87,1.23) 17.86,1.23 18.72,2.09 18.72,3.29 18.39,3.62 v2(18.39,3.97) 19.59,5.17 ED2903.1 20.15,4.6 19.79,4.23 19.79,3.03 R2907.2
AUD_PORTA_R_HPMIC1: length 23.7
  TOP w0.381: R2909.2 v1(14.25,13.04)
  L3 w0.381: HPMIC1.2 6.15,16.8 7.29,17.94 13,17.94 14.2,16.74 14.2,14.82 15.12,13.9 v1(15.34,13.9)
  BOTTOM w0.381: v1(15.34,13.9) 15.44,13.8 15.44,12.73 v2(16.48,11.69) 16.94,11.23 16.94,10.08 ED2901.2 14.71,10.04 14.25,10.5 v1(14.25,13.04)
AUD_SENSE: length 2.4
  TOP w0.254: R2923.2 20.88,19.01 21.62,18.27 v2(21.62,18.02) 21.62,17.35 R2709.2
AUD_SENSE_A: length 4.6
  TOP w0.254: HDA27.13 20.9,14.29 20.45,14.74 20.45,15.99 v2(20.57,16.11) 20.98,16.52 20.98,17.02 R2709.1 20.83,17.24 20.83,17.96 R2722.2
AUD_SPK_L+:
  vias: v2(30.81,10.93)
AUD_SPK_L+_C: length 1.5
  TOP w0.508: AFTP2902.1 37.41,10.65 EC2909.1
  vias: v2(34.35,10.64) v3(36.25,10.58)
AUD_SPK_L-:
  vias: v2(31.62,12.15)
AUD_SPK_L-_C: length 1.5
  TOP w0.508: EC2910.1 37.16,12.3 AFTP2901.1
  vias: v2(37.82,10.67) v3(36.25,12.18)
AUD_SPK_R+:
  vias: v2(29.82,14.49)
AUD_SPK_R+_C: length 5.8
  TOP w0.305: EL2902.1 33.81,16.27 AFTP2904.1
  TOP w0.508: EC2911.1 36.22,14.59 v3(36.09,14.72)
  TOP w1.016: v3(36.09,14.72) 35.2,15.61 EL2902.1
  vias: v2(34.37,13.09)
AUD_SPK_R-:
  vias: v2(30.51,13.4)
AUD_SPK_R-_C: length 1.9
  TOP w0.508: AFTP2903.1 35.66,13.7 EC2912.1
  vias: v2(30.79,14.64) v3(34.7,14.62)
AUD_VREF: length 3.8
  TOP w0.203: 22.8,7.56 22.93,7.68 HDA27.28
  TOP w0.305: 22.8,7.56 22.71,7.46 22.71,6.92 v2(23.14,6.49) 23.14,5.68 22.86,5.4 C2705.2
AUX_EN_WOWL: length 38.1
  TOP w0.102: v1(73.15,72.38) 73.18,72.35 73.69,72.35 v2(73.94,72.1) 73.96,72.1 74.47,71.59 74.47,71.12 R9613.2 ; v1(45.72,65.14) 46.6,65.14 R6104.1 46.72,64.3 R1721.2
  L4 w0.102: v1(73.15,72.38) 62.43,72.38 61.01,73.79 61.01,74.48 60.26,75.23 57.85,75.23 52.4,69.78 50.79,69.78 49.37,68.36 47.6,68.36 46.23,66.99 46.23,65.64 v1(45.72,65.14)
AUX_EN_WOWL_GP0: length 2.9
  TOP w0.102: U9601.9 72.92,72.9 72.64,72.63 72.64,71.74 v2(72.75,71.64) 73.28,71.11 R9613.1
AUX_EN_WOWL_R: length 106.7
  TOP w0.102: R1721.1 v1(46.84,62.24) ; v1(122.05,62.85) 122.05,56.56 120.13,54.64 119.85,54.64 110.28,45.08 v2(69.44,45.08) 67.85,45.08 67.01,44.23 63.14,44.23 62.84,44.54 62.38,44.54 62.13,44.28 62.13,44.27 v1(61.69,43.83)
  L4 w0.102: v1(57.15,62.85) 57.15,62.19 60.3,59.04 60.3,55 60.96,54.34 60.96,52.08 60.3,51.42 60.3,49.03 61.84,47.5 61.84,44.7 61.8,44.66 61.8,43.94 v1(61.69,43.83)
  L6 w0.102: v1(57.15,62.85) 50.55,62.85 50.42,62.72 47.32,62.72 v1(46.84,62.24)
  BOTTOM w0.102: CPU1.BB17 122.14,64.04 122.14,62.95 v1(122.05,62.85)
B71_TP: length 2.3
  TOP w0.102: TP2312.1 90.77,87.84 v1(90.77,86.29)
  BOTTOM w0.102: CPU1.B71 90.81,86.25 v1(90.77,86.29)
BA1_TP: length 3.6
  BOTTOM w0.102: TP2305.1 134.55,64.55 CPU1.BA1
BA2_TP: length 6
  BOTTOM w0.102: CPU1.BA2 134.67,61.35 TP2306.1
BA71_TP: length 6.6
  BOTTOM w0.102: TP2303.1 86.64,62.01 87.36,62.01 89.66,64.31 90.6,64.31 90.84,64.55 CPU1.BA71
BAT1_LED#: length 33.7
  TOP w0.127: v1(213.87,10.91) 213.45,11.33 201.65,11.33 Q2417.1 201.56,10.99 201.77,10.78 202.32,10.78 202.6,10.5 202.6,9.17 202.41,8.98 202.41,8.27 v2(202.21,8.06) 202.41,7.86 202.41,7.11 RN2405.1 ; v1(214.12,22.97) 214.35,22.74 KBC24.1
  L6 w0.127: v1(214.12,22.97) 214.12,20.74 213.68,20.29 213.68,18.71 213.72,18.68 213.72,18.08 214.77,17.03 214.77,16.51 v1(214.96,16.32)
  BOTTOM w0.127: v1(213.87,10.91) 214.88,11.92 214.88,16.24 v1(214.96,16.32)
BAT2_LED#: length 19.3
  TOP w0.127: RN2405.2 201.6,7.43 200.26,8.76 Q2417.4 200.26,9.86 199.26,10.86 v2(199.26,13.32) 199.26,14.67 v1(199.47,14.87) ; KBC24.106 206.32,20.37 v1(205.87,19.92)
  L4 w0.127: v1(199.47,14.87) 199.84,14.87 199.9,14.81 201.01,14.81 201.79,15.59 201.79,15.67 202.56,16.43 202.91,16.43 203.7,17.21 203.7,17.57 205.87,19.74 v1(205.87,19.92)
BAT_AMBER: length 15.4
  TOP w0.305: 213.23,16.26 213.54,16.56 213.54,16.67 213.65,16.79 LEDBD1.1
  TOP w0.508: 213.23,16.26 213.23,15.28 219.46,9.05 AFTP6308.1 220.24,8.77 218.95,7.48 v1(218.95,7.22)
  BOTTOM w0.508: R6407.2 v1(218.95,7.22)
BAT_WHITE: length 15.5
  TOP w0.305: LEDBD1.2 214.15,16.5
  TOP w0.508: 214.15,16.5 214.15,15.75 218.87,11.03 220.17,11.03 AFTP6307.1 220.85,10.35 220.85,7.86 220.22,7.22 v1(219.84,7.22)
  BOTTOM w0.508: R6406.2 v1(219.84,7.22)
BATT_WHITE_LED#: length 13.8
  TOP w0.127: Q2417.6 201.89,9.36 202.15,9.61 202.15,10.07 v1(202.11,10.11)
  BOTTOM w0.127: v1(202.11,10.11) 202.12,10.12 202.12,13.05 200.96,14.21 v2(200.48,14.21) 199.5,14.21 198.51,15.2 198.51,15.29 198.5,15.29 Q6401.D 198.08,15.71 198.08,19.58 198.48,19.97 Q6406.4
BATT_WHITE_LED#_M: length 17.6
  TOP w0.127: v1(202.18,4.3) 202.18,4.61 v2(202.51,4.94) 202.95,5.37 202.95,10.53 203.1,10.68 v1(203.1,10.88)
  BOTTOM w0.127: Q6406.3 198.49,17.02 198.5,17.02 199.1,16.43 199.1,15.95 199.89,15.16 200.59,15.16 202.95,12.81 202.95,11.03 v1(203.1,10.88) ; v1(202.18,4.3) 202.56,4.68 R6404.1
BATT_WHITE_LED_R#: length 3.1
  TOP w0.127: v1(204.72,4.56) 205.14,4.98 Q6404.B
  BOTTOM w0.127: R6404.2 204.03,4.21 204.32,3.92 204.66,3.92 v2(204.69,3.95) 204.78,4.05 204.78,4.5 v1(204.72,4.56)
BB67_TP: length 3.5
  TOP w0.102: TP2302.1 92.18,64.35 v1(93.23,63.29)
  BOTTOM w0.102: v1(93.23,63.29) 93.72,63.78 CPU1.BB67
BB70_TP: length 8.7
  BOTTOM w0.102: CPU1.BB70 91.59,63.9 89.79,63.9 88.9,63.01 88.9,62.98 86.71,60.79 85.47,60.79 TP2301.1
BEEP: length 214.9
  TOP w0.203: KBC24.45 210.31,33.05
  TOP w0.254: 210.31,33.05 211.07,32.29 211.07,27.76 211.46,27.37 211.46,26.35 v1(211.33,26.22)
  L3 w0.254: v1(41.12,9.71) 42.53,11.12 58,11.12 58.71,11.82 88.81,11.82 89.09,12.1 109.46,12.1 111.36,14 113.1,14 113.21,14.02 113.6,14.41 114.8,14.41 117.14,12.07 142.78,12.07 143.93,13.22 143.93,13.26 146.63,15.97 146.63,18.07 154.85,26.29 181.07,26.29 181.69,26.91 186.28,26.91 v1(186.61,26.58)
  L4 w0.254: v1(186.61,26.58) 186.66,26.63 186.72,26.63 186.99,26.91 191.16,26.91 191.79,27.54 198.81,27.54 198.89,27.45 203.05,27.45 203.47,27.87 207.77,27.87 207.98,28.08 210.62,28.08 211.46,27.25 211.46,26.35 v1(211.33,26.22)
  BOTTOM w0.254: RN2701.1 26.94,17.51 29.34,17.51 29.82,18 v2(31.24,18) 38.09,18 41.12,14.97 v1(41.12,9.71)
BKLGT_PWM: length 48.4
  TOP w0.203: v1(209.77,38.9) 209.77,38.46 210.64,37.58 210.64,37.58 210.71,37.51 KBC24.44
  TOP w0.508: Q6501.G 187.21,58.42 187.2,58.41 185.49,58.41 185.12,58.03 185.12,56.23 182.91,54.02 182.91,47.97 v2(183.4,47.47) 184.21,46.66 R6505.1 184.21,44.5 186.31,42.4 187.53,42.4 187.57,42.36 188.51,42.36 v1(189.87,41.01)
  L3 w0.508: v1(209.77,38.9) 208.68,38.9 207.72,39.86 207.65,39.86 206.51,41.01 205.48,41.01 204.97,41.51 198.62,41.51 197.98,40.88 189.99,40.88 v1(189.87,41.01)
BKLT_CTRL: length 8.5
  TOP w0.114: R5524.1 D5503.3 51.69,70.66 RN5503.7 ; R5524.1 48.77,70.47 48.9,70.6 49.79,70.6 49.9,70.71 49.9,71.62 49.77,71.74 RN5502.6 ; R5524.1 48.76,70.14 48.21,70.14 v2(47.83,69.76)
BLON_OUT: length 201.5
  TOP w0.127: RN5503.6 v1(51.18,71.11) ; v1(54.1,34.71) 54.64,34.71 55.36,33.98 56.9,33.98 56.95,33.93 56.95,33.93 57.15,33.73 118.13,33.73 118.14,33.73 119.66,33.73 125.35,39.42 145.34,39.42 149.05,39.42 157.06,31.4 166.83,31.4 167.09,31.14 167.58,31.14 v2(167.59,31.15) 167.59,31.15 167.92,30.82 v1(169.19,30.82)
  L3 w0.127: v1(192.15,27.01) 191.56,27.01 187.64,30.93 184.53,30.93 184.28,31.19 169.68,31.19 169.31,30.82 v1(169.19,30.82)
  L4 w0.127: v1(54.1,34.71) 54.57,35.18 54.57,36.05 56,37.47 56.29,37.47 59.41,40.59 59.41,45.65 59.55,45.79 59.55,47.93 59,48.48 59,52.18 59.44,52.61 59.44,53.71 59,54.14 59,58.48 56,61.48 54.55,61.48 50.18,65.86 50.18,66.21 50.18,67.15 50.93,67.9 v1(51.1,67.9)
  BOTTOM w0.127: v1(192.15,27.01) 193.57,27.01 194.31,26.27 R2480.2 195.47,23.14 195.96,22.64 v2(197.49,22.64) 197.68,22.83 R2439.1 ; v1(51.1,67.9) 51.1,71.03 v1(51.18,71.11)
BLON_OUT_C: length 5.7
  TOP w0.102: RN5503.3 51.18,73.24 50.6,73.82 50.52,73.82 50.34,74 50.32,74 50.09,74.23 v2(49.76,74.23) 49.53,74 v1(49.53,73.65) 49.53,73.04 RN5502.8
  BOTTOM w0.102: LCD1.21 49.65,73.77 v1(49.53,73.65)
BLUETOOTH_EN: length 196.2
  TOP w0.102: D6102.K 39.88,51.75 38.81,52.82 33.71,52.82 33.69,52.79 31.07,52.79 v1(30.66,53.2)
  L4 w0.102: v1(140.34,75.17) 140.28,75.12 137.87,75.12 137.09,75.9 137.09,81.4 137.64,81.95 137.64,84.49 137.62,84.51 137.62,86.94 140.58,89.9 140.9,90.39 141.13,90.93 141.24,91.51 141.24,92.09 141.13,92.67 140.9,93.21 140.58,93.7 140.16,94.11 139.99,94.29 139.9,94.29 139.68,94.43 139.14,94.66 138.56,94.77 134.52,94.77 134.35,94.94 125.68,94.94 125.44,95.18 125.31,95.18 125.31,95.19 118.2,95.19 118.2,95.18 117.9,95.18 116.81,94.09 111.12,94.09 109.55,95.67 109.55,97.11 109.42,97.24 109.42,97.24 108.33,98.33 101.4,98.33 94.82,91.76 85.06,91.76 81.13,87.82 75.77,87.82 75.59,87.64 75.01,87.64 72.7,85.33 71.57,85.33 71.08,85.83 71.08,85.88 69.77,87.18 66.85,87.18 64.67,89.37 62.51,89.37 61.26,88.11 60.26,88.11 60.1,88.28 56.39,88.28 56.34,88.22 56.19,88.08 56.19,88.08 53.85,85.74 52.53,85.74 50.75,87.51 49.1,87.51 46.33,84.74 44.51,84.74 43.32,83.55 41.22,83.55 34.86,77.19 34.86,76.6 31.71,73.45 31.71,64.66 33.12,63.26 33.12,62.21 32.59,61.68 32.59,61.68 32.33,61.42 32.33,61.14 32.18,61 32.18,60.13 31.98,59.92 31.33,59.92 31.28,59.88 31.06,59.88 30.03,58.84 30.03,53.83 v1(30.66,53.2)
  BOTTOM w0.089: CPU1.AB2 131.49,75.04 131.72,75.04 131.83,74.99 132.1,74.99
  BOTTOM w0.102: 132.1,74.99 132.34,75.22 132.86,75.22 132.87,75.23 134.58,75.23 134.74,75.07 135.06,75.07 135.07,75.08 137.62,75.08 137.62,75.08 139.31,75.08 139.32,75.07 140.23,75.07 v1(140.34,75.17) 140.87,75.7 v2(140.87,76.36) 141.07,76.57 R2002.2
BLUETOOTH_EN_NGFF: length 12.5
  TOP w0.102: v1(38.73,56.3) 39.95,56.3 AFTP5804.1 40.64,56.37 42.8,56.37 43.31,55.87 43.31,52.82 42.16,51.67 D6102.A
  BOTTOM w0.102: v1(38.73,56.3) 38.29,55.87 37.97,55.87 37.61,55.5 WLAN1.54
BOARD_ID: length 13.7
  TOP w0.102: v2(200.27,14.43) 200.49,14.22 C2408.2 ; R2444.1 C2408.2 ; C2408.2 201.24,14.25 R2443.2 201.92,15.11 201.93,15.1 v1(202.18,15.1) ; v1(208.53,19.92) 208.32,20.14 KBC24.111
  L4 w0.102: v1(208.53,19.92) 206.7,19.92 203.94,17.16 203.94,17.11 203.01,16.19 202.97,16.19 202.18,15.4 v1(202.18,15.1)
BOARD_ID2: length 14
  BOTTOM w0.089: CPU1.AB3 131.02,74.86 131.67,74.86 131.68,74.86 131.81,74.8 132.22,74.8
  BOTTOM w0.102: R2005.2 143.28,75.61 142.92,75.98 142.35,75.98 R2008.1 141.35,75.42 141.18,75.26 141.04,75.26 140.5,74.71 v2(139.47,74.71) 139.32,74.86 139.24,74.86 139.22,74.88 137.53,74.88 134.66,74.88 134.5,75.04 132.95,75.04 132.94,75.03 132.45,75.03 132.22,74.8
BOOST_MON: length 44.6
  TOP w0.254: PC4424.1 241.43,14.13 v1(240.77,14.79) 240.11,14.13 PG4414.2
  L4 w0.254: v1(240.77,14.79) 239.7,14.79 236.07,11.16 233.86,11.16 233.27,11.75 227,11.75 226.14,10.88 214.56,10.88 214.08,10.4 213.66,10.4 213.56,10.5 211.81,10.5 211.05,9.74 v1(210.9,9.74)
  BOTTOM w0.254: v1(210.9,9.74) 209.98,9.74 209.7,9.46 209.68,9.46 209.3,9.08 v2(202.54,9.08) 201.33,9.08 R2423.1
BP_PWRGD_RST#: length 7.7
  TOP w0.114: XDP1.41 60.5,98.07 61.04,98.61 61.57,98.61 62.2,99.25 v2(64.39,99.25) 64.39,99.58 63.94,100.02 C9901.1 R9926.2
BT+: length 11.7
  L6 w1.016: v3(228.42,30.8) 229.02,30.8 236.6,23.21 v1(236.6,22.85)
  vias: v3(228.24,32.75) v3(228.17,31.84) v3(229.06,32.14)
BT+_1: length 2.5
  TOP w0.254: PR4414.2 235.45,21.52 PG4417.1 236.68,21.45 v2(236.68,20.56)
CAP_LED: length 25
  TOP w0.305: KB1.4 196.58,36.7
  TOP w0.508: R6506.2 179.84,44.56 180.52,43.89 AFTP6243.1 183,43.85 184.47,42.38 184.94,42.38 185.67,41.64 186.37,41.64 187.99,40.02 187.99,39.14 188.56,38.57 193.68,38.57 194.44,37.81 195.48,37.81 196.58,36.7
CAP_LED#: length 20.5
  TOP w0.127: v1(199.21,23.73) 199.42,23.94 KBC24.93 ; v1(198.65,16.24) v2(198.65,15) 198.65,13.17 199.01,12.81 199.01,11.81 Q2418.1 198.44,11.24 199.37,10.3 199.37,10 199.52,9.8 199.52,8.92 201.1,7.34 RN2405.3
  L6 w0.127: v1(199.21,23.73) 199.14,23.66 199.14,21.81 198.65,21.33 v1(198.65,16.24)
CAP_LED#_S: length 70.3
  TOP w0.127: Q2418.6 198.46,9.36 198.86,9.75 198.86,10.05 v1(198.93,10.12) ; v1(169.01,45.88) 169.01,45.26 169.26,45.01 EC6507.1 169.62,45.91 v2(169.67,45.96) 169.67,46.81 R6508.1
  L3 w0.127: v1(192.02,43.83) 191.35,44.5 182.31,44.5 180.35,42.54 174.11,42.54 172.21,44.44 171.06,44.44 170.34,45.16 169.74,45.16 v1(169.01,45.88)
  L6 w0.127: v1(192.02,43.83) 194.1,43.83 194.63,43.29 194.63,39.67 196.45,37.85 196.45,34.3 197.3,33.45 197.3,31.05 196.85,30.6 196.85,28.27 195.69,27.12 195.69,25.52 197.07,24.15 197.07,16.74 196.4,16.08 196.16,16.08 195.9,15.82 195.9,15.26 198.15,13.02 198.67,13.02 199.01,12.68 199.01,12.31 198.93,12.23 v1(198.93,10.12)
CAP_LED_Q: length 2.3
  TOP w0.508: 175.36,43.67 v2(175.39,43.65) ; 175.36,43.67 Q6502.C ; 175.36,43.67 175.45,43.76 R6506.1
CAP_LED_R#: length 3.6
  TOP w0.127: R6508.2 170.5,45.13 v2(170.69,44.94) 170.97,44.66 Q6502.B
CASA0#: length 48.2
  TOP w0.127: v1(164.47,106.54) 164.96,106.54 166.1,107.68 166.1,108.08 VRAM1.K3
  L4 w0.127: 158.83,107.88 159.08,108.14 161.24,108.14 161.85,108.75 163.19,108.75 163.57,108.37 164.12,107.82 164.12,106.88 v1(164.47,106.54)
  L4 w0.254: 158.83,107.88 158.73,107.78 158.47,107.78 157.16,106.47 157.16,95.43 161.05,91.54 163.2,91.54 163.47,91.81 166.32,91.81 167.01,91.11 173.32,91.11 173.74,90.7 173.74,90.03 173.64,89.93 173.64,89.53 174.51,88.66 v1(174.52,88.66)
  BOTTOM w0.127: VRAM2.K3 163.32,108.29 164.27,107.34 164.27,106.73 v1(164.47,106.54)
  BOTTOM w0.14: GPU1.G19 174.78,88.4 v1(174.52,88.66)
CASA1#: length 49
  TOP w0.127: VRAM4.K3 188.6,108.08 188.6,107.63 187.51,106.54 186.94,106.54 v1(186.66,106.82)
  L4 w0.127: 192.49,107.61 192.17,107.93 190.84,107.93 190.64,107.73 190.64,107.13 190.39,106.88 190.05,106.88 189.8,107.13 189.8,107.36 189.67,107.49 187.9,107.49 187.76,107.35 187.76,106.78 187.51,106.54 186.94,106.54 v1(186.66,106.82)
  L4 w0.254: v1(178.01,88.61) 177.8,88.82 177.8,89.56 178.4,90.16 182.16,90.16 182.31,90.31 182.31,90.31 182.44,90.44 183.16,90.44 183.74,91.02 185.39,91.02 188.11,93.74 189.65,93.74 190.18,94.27 191.59,94.27 191.97,93.9 193.06,93.9 195.65,96.48 195.65,104.46 192.49,107.61
  BOTTOM w0.127: VRAM3.K3 185.82,108.3 186.42,107.69 186.75,107.69 186.88,107.57 186.88,107.03 v1(186.66,106.82)
  BOTTOM w0.14: v1(178.01,88.61) 177.73,88.61 GPU1.G16
CBN: length 3.5
  TOP w0.203: HDA27.35 25.73,8.29 25.8,8.22 25.8,8.18 26.52,7.45 v2(26.7,7.45) 26.99,7.16 C2703.1
CBP: length 4.1
  TOP w0.203: HDA27.37 26.95,9.1
  TOP w0.254: C2703.2 27.86,5.98 27.86,7.38 v2(27.94,7.45) 27.3,8.09 27.3,8.75 26.95,9.1
CFG0: length 48.2
  TOP w0.114: XDP1.9 68.5,98.2 v1(68.71,98.41) ; R9611.1 62.13,101.74 62.43,102.04 62.87,102.04 63.65,102.83 64.8,102.83 65.38,102.25 v1(65.63,102.25)
  L3 w0.114: v1(65.63,102.25) 65.79,102.09 65.79,101.33 v1(68.71,98.41)
  BOTTOM w0.089: 93.66,88.01 93.99,87.68 93.99,87.15 94.16,86.99 94.16,86.57 94.13,86.49 94.13,86.06 94.06,85.98 94.06,85.1 CPU1.E68
  BOTTOM w0.114: 93.66,88.01 93.6,88.07 89.59,88.07 88.9,88.76 86.94,88.76 86.24,89.47 v2(86.12,89.47) 86.08,89.47 84.56,90.99 84.56,95.6 83.16,97 82.65,97.5 82.41,97.5 80.68,99.23 77.93,99.23 77.92,99.22 69.83,99.22 69.02,98.41 v1(68.71,98.41)
CFG1: length 37.8
  TOP w0.114: XDP1.11 68,97.87 67.97,97.9 v1(67.97,98.41)
  BOTTOM w0.089: CPU1.B67 93.72,86.08 93.95,86.31 93.95,86.52 93.98,86.6 93.98,86.6 93.98,86.9 93.77,87.1 93.77,87.54 93.56,87.76
  BOTTOM w0.114: v1(67.97,98.41) 68.48,97.9 68.96,97.9 69.96,98.9 78.05,98.9 78.06,98.91 80.55,98.91 82.28,97.18 82.52,97.18 84.2,95.5 84.2,89.93 v2(84.74,89.38) 85.43,88.7 86.55,88.7 86.81,88.44 88.6,88.44 89.17,87.87 93.45,87.87 93.56,87.76
CFG2: length 40.5
  TOP w0.114: v1(66.98,98.34) 66.98,96.72 XDP1.15
  BOTTOM w0.089: CPU1.D65 94.68,85.15 94.68,85.79 94.63,85.93 94.63,86.2 94.65,86.26 94.65,86.52 94.63,86.58 94.63,86.97 94.78,87.12 94.78,87.56 94.42,87.92 94.11,87.92 93.72,88.31
  BOTTOM w0.114: 93.72,88.31 89.85,88.31 89,89.16 v2(87.86,89.16) 87.05,89.16 84.89,91.33 84.89,95.72 83.29,97.31 83.29,97.31 82.78,97.82 82.54,97.82 80.82,99.55 77.8,99.55 77.78,99.53 68.17,99.53 v1(66.98,98.34)
CFG3: length 43
  TOP w0.114: R9902.1 66.34,99.01 66.34,98.39 v1(66.34,98.38) 66.5,98.23 XDP1.17
  BOTTOM w0.114: CPU1.D67 93.72,85.63 93.44,85.91 93.44,86.76 93.2,87 93.16,87 92.65,87.51 88.75,87.51 88.14,88.12 86.68,88.12 86.42,88.38 83.78,88.38 83.33,87.93 R604.1 83.19,88.96 83.88,89.66 83.88,95.37 82.39,96.87 82.15,96.87 80.42,98.59 78.19,98.59 78.1,98.51 76.66,98.51 76.66,98.5 70.07,98.5 68.88,97.32 v2(68.88,97.22) 67.35,97.22 66.34,98.23 66.34,98.38 v1(66.34,98.38)
CFG4: length 41.4
  TOP w0.114: XDP1.27 64,94.68 63.47,94.16 v1(63.42,94.16)
  BOTTOM w0.089: CPU1.E70 91.68,84.41 91.43,84.66 91.09,84.66 90.84,84.92 90.4,84.92
  BOTTOM w0.114: v1(63.42,94.16) 64.19,93.4 65.21,93.4 65.28,93.33 65.39,93.33 66.1,92.62 66.1,90.56 66.28,90.38 66.28,88.9 66.14,88.77 66.14,87.91 66.95,87.1 66.95,84.5 68.51,82.94 71.99,82.94 72.02,82.96 81.66,82.96 82.76,84.06 v2(84.07,84.06) 85.28,84.06 R605.1 86.14,84.92 90.4,84.92
CFG5: length 40.1
  TOP w0.114: v1(63.46,95.06) 63.5,95.1 XDP1.29
  BOTTOM w0.114: v1(63.46,95.06) 63.46,95.06 64.89,95.06 65.67,94.28 66.31,94.28 67.92,92.67 67.92,90.95 69.43,89.43 69.43,87.8 69.18,87.55 69.18,85.87 70.2,84.85 75.04,84.85 75.3,85.11 77.29,85.11 77.81,84.58 79.41,84.58 80.04,85.21 v2(82.32,85.21) 82.94,85.21 83.35,85.62 90.67,85.62 90.96,85.91 91.54,85.91 91.68,85.77 92.25,85.77 CPU1.C68
CFG6: length 41.9
  TOP w0.114: XDP1.33 62.5,95.5 61.64,94.64 v1(61.64,94.44)
  BOTTOM w0.114: CPU1.D68 91.8,84.94 91.48,85.26 v2(83.77,85.26) 83.44,85.26 83.03,84.85 80.13,84.85 79.19,83.91 70.2,83.91 67.98,86.13 67.98,87.42 67.36,88.03 67.36,88.81 67.03,89.14 67.03,90.52 66.88,90.68 66.88,92.74 65.65,93.97 65.54,93.97 64.76,94.75 64.18,94.75 64.06,94.62 63.03,94.62 63.01,94.6 61.79,94.6 v1(61.64,94.44)
CFG7: length 44.5
  TOP w0.114: v1(62.99,98.36) 62.84,98.51 62.46,98.51 62,98.05 XDP1.35
  BOTTOM w0.114: CPU1.C67 93.13,85.96 92.69,86.4 92.29,86.4 92.09,86.6 92.09,86.85 91.9,87.04 89.01,87.04 88.55,86.58 v2(88.11,86.58) 83.86,86.58 82.86,85.58 79.96,85.58 79.28,84.9 77.95,84.9 77.43,85.42 72.47,85.42 72.22,85.17 70.33,85.17 69.5,86 69.5,87.42 69.75,87.67 69.75,89.56 68.24,91.08 68.24,92.81 66.39,94.65 65.81,94.65 64.7,95.76 64.24,95.76 62.99,97.01 v1(62.99,98.36)
CFG8: length 36.5
  TOP w0.114: v1(65.38,87.67) 65.48,87.77 67.22,87.77 68.5,89.04 XDP1.10
  BOTTOM w0.089: CPU1.F71 91.68,83.86 90.24,83.86 90.04,84.06
  BOTTOM w0.114: v1(65.38,87.67) 65.38,87.56 66.27,86.67 v2(66.27,85.3) 66.27,84.13 68.09,82.3 72.25,82.3 72.28,82.33 81.93,82.33 82.98,83.38 85.88,83.38 86.78,84.27 89.83,84.27 90.04,84.06
CFG9: length 42.1
  TOP w0.114: v1(63.98,88.53) 65.3,88.53 65.63,88.2 66.19,88.2 66.31,88.08 66.94,88.08 68,89.14 XDP1.12
  BOTTOM w0.089: CPU1.G69 92.51,82.96 92.24,82.96 92.05,82.9 91.87,82.9 91.74,82.93 91.48,82.93 91.41,82.9 91.15,82.9 90.99,83.05 89.68,83.05
  BOTTOM w0.114: v1(63.98,88.53) 63.98,85.71 64.66,85.03 v2(64.66,84.52) 64.66,83.94 68.31,80.29 69.9,80.29 70.35,80.74 74.93,80.74 75.24,81.06 82.45,81.06 83.51,82.11 86.41,82.11 87.31,83 87.76,83 88.1,83.35 89.38,83.35 89.68,83.05
CFG10: length 35.4
  TOP w0.114: v1(65.84,89.08) 66.66,89.08 67,89.42 XDP1.16
  BOTTOM w0.089: CPU1.F70 92.08,84.05 91.48,84.05 91.47,84.04 90.42,84.04 90.12,84.34
  BOTTOM w0.114: v1(65.84,89.08) 65.82,89.07 65.82,87.77 66.63,86.97 66.63,84.28 v2(68.21,82.7) 68.29,82.62 72.12,82.62 72.15,82.64 81.8,82.64 82.85,83.7 85.72,83.7 86.61,84.59 89.87,84.59 90.12,84.34
