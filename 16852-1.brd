# Allegro board 16852-1.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
H_PROCHOT#: length 418.6
  TOP w0.14: v1(89.15,95.11) 88.23,94.19 88.23,88.32 86.26,86.35 86.26,77.15 84.59,75.48 83.62,75.48 83.08,76.01 83.08,76.06 v1(82.96,76.19) ; PR4624.2 PR4669.2 147.55,121.43 147.53,121.14 v1(147.53,120.72) ; v1(169.8,29.61) 169.5,29.31 167.7,29.31 166.33,30.67 156.81,30.67 148.76,38.73 126.12,38.73 120.43,33.04 119.95,33.04 v2(59.56,33.04) 56.86,33.04 56.62,33.28 v1(54.61,33.28) ; PR4418.1 240.78,16.55 241.23,16.55 v1(241.27,16.5) 241.89,16.5 PR4455.2
  L3 w0.127: v1(94.97,117.03) 94.97,115.3 91.07,111.4 91.07,107.91 91.66,107.32 91.66,106.25 91.08,105.68 91.08,104.25 92.56,102.78 92.56,99.5 89.15,96.1 v1(89.15,95.11) ; v1(169.8,29.61) 169.8,30.18 170.12,30.5 183.99,30.5 185.03,29.46 187.82,29.46 190.97,26.31 190.97,24.34 191.72,23.59 191.72,22.27 193.14,20.85 198,20.85 198.78,20.06 200.55,20.06 202.31,21.83 205.33,21.83 205.71,22.2 205.71,22.57 205.59,22.69 205.59,24.24 v1(205.31,24.52) 205.77,24.52 206.26,24.03 207.2,24.03 207.38,24.22 211.05,24.22 211.27,24.43 211.64,24.43 211.68,24.39 215.61,24.39 216.17,23.84 216.17,18.24 219.01,15.39 226.25,15.39 228.79,12.85 230.59,12.85 232.91,10.54 233.36,10.54 233.79,10.98 233.79,11.5 238.79,16.5 v1(241.27,16.5)
  L4 w0.127: v1(54.61,33.28) 54.86,33.54 54.86,34.86 55,35 55,35.87 56.18,37.04 56.47,37.04 59.84,40.41 59.84,45.42 59.98,45.57 59.98,48.11 59.44,48.66 59.44,51.93 59.94,52.44 59.94,53.83 59.44,54.34 59.44,58.68 56.21,61.91 54.73,61.91 50.61,66.04 50.61,66.97 51.03,67.4 51.87,67.4 57.52,73.05 60.03,73.05 62.12,70.97 71.22,70.97 72.84,69.34 75.28,69.34 82.12,76.19 v1(82.96,76.19) ; v1(147.53,120.72) 147.53,123.67 146.72,124.48 144.67,124.48 143.08,126.07 134.75,126.07 132.47,123.78 128.7,123.78 127.45,122.53 124.25,122.53 122.54,120.83 119.62,120.83 117.07,118.27 106.15,118.27 103.94,120.48 101.83,120.48 101.41,120.9 100.69,120.9 100.63,120.84 99.75,120.84 95.94,117.03 v1(94.97,117.03) ; v1(89.15,95.11) 87.53,95.11 v1(87.17,94.75)
  BOTTOM w0.14: C2403.1 204.22,25.83 R2416.2 205.31,25.5 v1(205.31,24.52) ; R404.1 87,93.6 87,94.57 v1(87.17,94.75) ; PR4668.2 147.53,120.11 v1(147.53,120.72)
H_PROCHOT#_EC: length 4
  BOTTOM w0.14: Q2408.D 204.77,28.94 205.54,28.18 v2(205.54,27.57) 205.54,27.26 204.99,26.72 R2416.1 204.91,26.66 R2418.2
H_PROCHOT#_R: length 11.2
  BOTTOM w0.089: 94.44,88.18 94.96,87.66 94.96,87.05 94.81,86.9 94.81,86.61 94.83,86.55 94.83,86.22 94.81,86.16 94.81,85.96 94.86,85.83 94.86,85.62 CPU1.C65
  BOTTOM w0.114: 94.44,88.18 94.21,88.18 94,88.39
  BOTTOM w0.14: 94,88.39 93.86,88.53 90.29,88.53 v2(89.18,89.64) 89.16,89.64 89.15,89.65 87.31,89.65 R403.2
H_PROCHOT#_R_R: length 2.9
  BOTTOM w0.14: R404.2 87.06,92.62 R401.2 87.12,91.62 R403.1 v2(86.18,90.73)
H_VCCST_PWRGD: length 9.2
  BOTTOM w0.089: CPU1.B65 95.33,86.32 95.33,87.92 94.82,88.43
  BOTTOM w0.127: 94.82,88.43 94.18,89.07 93.18,89.07
  BOTTOM w0.14: R1734.2 89.6,90.52 90.3,89.82 v2(91.34,89.82) 91.39,89.82 91.73,90.16 92.12,90.16 92.36,89.92 92.36,89.88 93.17,89.07 93.18,89.07
H_VCCST_PWRGD_R: length 11.5
  TOP w0.14: v2(92,98.54) 92,98.16 90.07,96.23 90.07,94.46 90.49,94.05 90.49,93.28 v1(90.49,93.28)
  BOTTOM w0.14: v1(90.49,93.28) R1716.2 R1722.2 R1734.1 91.29,90.66 R1719.1 EC1708.1 EC1715.1
H_VID3: length 2.2
  TOP w0.102: TP7919.1 182.5,70.34 v1(183.01,69.84)
  BOTTOM w0.102: v1(183.01,69.84) 182.12,70.72 GPU1.AK10
H_VID4: length 4.1
  TOP w0.102: TP7920.1 180.76,67.17 182.63,69.03 v1(182.63,69.33)
  BOTTOM w0.102: v1(182.63,69.33) 182.12,69.83 GPU1.AM10
HDA_BITCLK: length 19.9
  BOTTOM w0.14: CPU1.AY22 119.56,65.05 119.54,64.96 119.49,64.9 119.49,63.81 119.86,63.44 119.86,60.38 120.37,59.87 120.37,54.9 120.12,54.66 119.58,54.66 119.29,54.96 118.1,54.96 117.61,54.47 116.68,54.47 v2(115.34,53.12) 114.53,52.32 RN1901.3 114.49,51.74 FC1901.1
HDA_BITCLK_CODEC_R: length 2.9
  TOP w0.14: R2720.2 24.13,17.68 24.13,17.59 24.13,16.19 v2(24.05,16.11) 24.13,16.04 HDA27.6
HDA_CODEC_BITCLK: length 109.2
  TOP w0.14: R2720.1 24.16,19.53 v1(24.3,19.67) 24.3,20.2 EC2709.1
  BOTTOM w0.14: v1(24.3,19.67) 24.51,19.67 v2(25.36,20.52) 25.84,21 26.35,21 26.36,21.01 28.63,21.01 29.23,20.41 41.79,20.41 44.12,22.74 50.66,22.74 54.71,26.8 54.71,26.95 65.47,37.71 65.47,38.99 65.86,39.37 66.47,39.99 109.06,39.99 114.41,45.34 EC1901.2 114.53,48.54 RN1901.2
HDA_CODEC_SDIN0: length 7.4
  TOP w0.14: HDA27.8 23.33,16.28 23.11,16.5 23.01,16.5 22.35,17.16 22.35,20.18 22.68,20.51 v2(22.68,20.61) 22.48,20.81 22.48,21.46 R2718.2
HDA_CODEC_SDOUT: length 108.7
  TOP w0.14: EC2708.1 25.02,19.37 v1(25.07,19.31) 25.07,19.23 24.99,19.16 R2719.1
  BOTTOM w0.14: v1(25.07,19.31) 25.15,19.31 25.18,19.35 v2(26.14,19.35) 28.51,19.35 28.99,19.83 42.03,19.83 44.36,22.16 50.9,22.16 55.3,26.55 55.3,26.71 57.91,29.32 66.05,37.47 66.05,38.75 66.71,39.41 109.31,39.41 115.18,45.28 RN1901.1
HDA_CODEC_SYNC: length 121.3
  TOP w0.14: HDA27.10 22.53,15.43 22.1,15.86 22.1,16.16 v1(22,16.27)
  BOTTOM w0.14: v1(22,16.27) 22,16.6 21.49,17.1 21.49,20.67 21.89,21.07 22.79,21.07 23.19,20.67 23.54,20.67 23.84,20.37 23.84,19.48 24.6,18.73 25.99,18.73 26.02,18.76 v2(27.99,18.76) 28.75,18.76 29.23,19.24 42.27,19.24 44.39,21.36 50.93,21.36 55.88,26.31 55.88,26.47 66.64,37.22 66.64,38.5 66.96,38.82 110.62,38.82 117.4,45.6 117.4,50.92 R1908.1
HDA_RST#: length 2.2
  TOP w0.14: TP1903.1 120.19,67.94 120.19,67.11 v1(119.69,66.6)
  BOTTOM w0.14: CPU1.AW22 119.77,66.51 v1(119.69,66.6)
HDA_SDIN0: length 131.1
  TOP w0.14: v1(21.95,20.48) 21.68,20.75 R2718.1
  BOTTOM w0.14: CPU1.BA21 120.4,65.01 120.4,63.9 120.62,63.67 120.62,60.69 121.05,60.26 121.05,54.62 119.83,53.4 119.67,53.4 119.48,53.2 119.14,53.2 117.98,52.05 117.98,45.78 110.31,38.11 68.35,38.11 56.46,26.22 56.46,26.07 51.17,20.77 44.63,20.77 42.51,18.66 v2(30.05,18.66) 29.47,18.66 28.99,18.18 26.27,18.18 26.23,18.15 24.36,18.15 23.26,19.24 23.26,19.68 22.45,20.48 v1(21.95,20.48)
HDA_SDOUT: length 16.4
  BOTTOM w0.14: CPU1.BB22 119.77,63.88 120.14,63.51 120.14,60.49 120.59,60.04 120.59,54.81 120.16,54.37 118.66,54.37 v2(117.27,52.99) 116.36,52.07 R1909.2 115.51,52.02 RN1901.4
HDA_SDOUT_CODEC_R: length 3.1
  TOP w0.14: R2719.2 25.07,17.63 v2(25.07,16.8) 25.07,16.36 24.53,15.82 HDA27.5
HDA_SPKR_R: length 3.6
  BOTTOM w0.254: D2701.2 23.23,16.62 v2(24.59,16.62) 24.77,16.8 RN2701.3
HDA_SYNC: length 15.2
  BOTTOM w0.14: CPU1.BA22 120.12,64.39 120.12,63.86 120.4,63.58 120.4,60.6 120.82,60.17 120.82,54.71 119.9,53.79 118.9,53.79 v2(118.69,53.58) 117.29,52.18 R1908.2
HDD_DET#: length 200.2
  TOP w0.127: v1(265.94,24.5) v2(265.94,26.66) 265.94,27.06 266.92,28.04 266.92,32.78 266.7,33 v1(266.7,34.15) ; RN2002.4 129.99,75.35 129.51,75.83 129.51,76.15 129.43,76.24 128.51,76.24 v1(127.61,77.13)
  L3 w0.127: v1(265.65,18.18) 265.65,23.8 265.94,24.08 v1(265.94,24.5) ; v1(139.32,69.76) 139.36,69.8 139.36,74.87 136.99,77.24 136.16,77.24 136.13,77.27 135.03,77.27 135,77.24 131.54,77.24 130.89,76.59 128.22,76.59 127.68,77.13 v1(127.61,77.13)
  L4 w0.127: v1(266.7,34.15) 265.82,35.02 257.39,35.02 255.68,33.31 255.18,33.31 254.76,32.89 254.76,32.05 253.08,30.37 252.54,30.37 251.44,31.47 249.42,31.47 247.97,32.92 246.06,32.92 245.51,33.46 243.68,33.46 242.75,34.39 242.14,34.39 241.93,34.59 240.97,34.59 240.66,34.9 233.39,34.9 229.92,38.36 229.92,40.03 228.31,41.64 223.95,41.64 223.39,41.08 221.49,41.08 220.61,41.96 220.61,43.09 217.88,45.82 216.25,45.82 215.44,45.01 207.58,45.01 207.27,45.31 204.87,45.31 203.52,46.66 203.52,47.54 203.26,47.8 203.05,48 202.35,48 201.61,48.74 192.58,48.74 190.48,46.64 184.52,46.64 184.36,46.8 181.14,46.8 180.98,46.64 173.54,46.64 171.12,49.06 158.83,49.06 157.76,47.99 154.35,47.99 153.22,49.12 152.52,49.12 149.1,52.54 146.11,52.54 141.99,56.65 141.99,62.8 139.32,65.48 v1(139.32,69.76)
  BOTTOM w0.127: HDD1.10 v1(265.65,18.18) ; CPU1.U8 127.91,77.43 v1(127.61,77.13) ; EC6001.1 v1(265.94,24.5)
HDD_DEVSLP: length 177.1
  L3 w0.102: v1(254.79,25.11) 256.29,26.61 256.29,30.45 255.36,31.37 255.36,32.52 v1(255.3,32.59) ; v1(135.26,83.51) 136.87,85.13 139.8,85.13 141.9,83.03 142.43,83.03 144.98,80.48 144.98,75.92 145.23,75.67 145.23,74.91 147.83,72.31 147.83,68.97 153.83,62.97 154.99,62.97 155.61,62.35 156.08,62.35 157.3,61.13 157.3,53.79 165.96,45.14 166.86,45.14 168.56,43.43 169.34,43.43 172.11,40.66 179.42,40.66 179.56,40.8 181.84,40.8 182.57,40.07 183.01,40.07 183.16,39.91 183.52,39.91 184.1,40.5 184.66,40.5 186,41.84 195.71,41.84 200.21,46.35 201.83,46.35 203.26,44.92 206.42,44.92 207.36,43.98 207.82,43.98 v1(207.85,43.95)
  L4 w0.102: v1(255.3,32.59) 255.3,32.25 253.18,30.13 252.44,30.13 251.34,31.23 249.3,31.23 247.88,32.65 245.76,32.65 245.25,33.16 242.32,33.16 242.09,33.39 242.09,34.1 241.83,34.35 240.87,34.35 240.56,34.66 233.29,34.66 229.68,38.26 229.68,39.93 228.21,41.4 224.05,41.4 223.49,40.84 219.64,40.84 217.51,42.97 217.51,43.95 217.04,44.42 213.78,44.42 213.72,44.49 211.35,44.49 210.74,43.88 208.14,43.88 208.06,43.95 v1(207.85,43.95)
  BOTTOM w0.102: CPU1.J1 132.11,82.05 134.34,82.05 135.23,82.94 135.23,83.48 v1(135.26,83.51) ; v1(254.79,25.11) 254.94,25.26 R6007.1 255.65,25.32 v2(255.65,26.17)
HDD_DEVSLP_R: length 14.5
  TOP w0.102: v1(257.23,25.51) 256.67,24.95 255.98,24.95 255.73,24.7 255.73,24.34 256.44,23.63 256.44,20.79 v2(256.62,20.61) 257.94,19.29 260.35,19.29 260.65,18.99 v1(260.65,17.94)
  BOTTOM w0.102: HDD1.20 v1(260.65,17.94) ; v1(257.23,25.51) 256.97,25.26 R6007.2
HDD_DEW1: length 3.9
  TOP w0.102: U5601.16 265.92,30.1 v1(266.32,29.7) 266.45,29.58 v2(266.45,28.94)
  BOTTOM w0.102: R5619.2 266.32,29 v1(266.32,29.7) 266.06,29.96 R5618.1
HDD_DEW2: length 4.2
  TOP w0.102: v2(259.72,33) 259.72,32.62 v1(260.05,32.29) 260.24,32.1 U5601.6
  BOTTOM w0.102: R5617.2 R5616.1 260.21,32.29 v1(260.05,32.29)
HDD_FALL_INT: length 208.2
  TOP w0.102: U6701.12 107.52,6.86 v1(107.11,7.27) 106.63,7.76 R6702.2
  L3 w0.102: v1(184.53,39.25) 183.95,38.67 183.88,38.61 182.26,38.61 182.22,38.57 181.66,38.57 181.62,38.61 165.39,38.61 164.36,39.63 151.08,39.63 142.44,48.27 142.44,53.66 143.19,54.41 143.19,57.21 142.18,58.23 142.18,70.26 141.48,70.96 141.48,79.24 138.81,81.91 138.1,82.62 v1(137.21,82.62) ; v1(107.11,7.27) 107.57,7.73 116.08,7.73 117.03,6.79 117.03,6.78 117.32,6.49 117.9,5.9 117.97,5.9 118.53,5.34 118.78,5.34 119.85,4.28 131.18,4.28 132.26,5.35 132.26,5.55 134.54,7.83 137.52,7.83 138.32,8.64 143.57,8.64 145.55,10.62 148.32,10.62 148.55,10.86 183.61,10.86 185.58,12.83 185.58,21.03 187.17,22.62 v1(187.73,22.62)
  L6 w0.102: v1(184.53,39.25) 185.44,38.35 185.44,30.37 185.36,30.29 185.36,29.63 185.65,29.33 185.65,25.39 185.94,25.09 186.69,24.35 186.69,22.89 186.97,22.62 v1(187.73,22.62)
  BOTTOM w0.089: 134.88,81.3 134.88,80.58 134.58,80.28 131.86,80.28 131.74,80.33 131.47,80.33 131.38,80.29 131.18,80.29 131.09,80.33 130.86,80.33 CPU1.M3
  BOTTOM w0.102: v1(137.21,82.62) 137.11,82.62 136.62,82.13 135.71,82.13 134.88,81.3 ; v2(108.13,7.17) 108.03,7.27 v1(107.11,7.27)
HDMI_CLK: length 87.3
  L6 w0.102: v1(26.47,67.77) 26.76,68.06 29.59,68.06 29.88,68.35 37.1,68.35 42.45,73.7 46.85,73.7 47.29,73.26 48.39,73.26 50.41,75.28 55.22,75.28 58.97,79.03 60.36,79.03 63.36,82.03 69.24,82.03 70.13,81.14 79.07,81.14 79.71,81.77 85.72,81.77 86.95,83 90.94,83 92.1,81.85 95.74,81.85 96.35,81.24 97.53,81.24 98.44,82.15 99.82,82.15 100.3,82.64 100.3,82.85 v1(100.48,83.03)
  BOTTOM w0.127: 25.45,67.9 26.34,67.9 v1(26.47,67.77) ; 25.45,67.9 v2(25.45,67.73) ; 25.45,67.9 23.27,67.9 C5704.1 ; CPU1.G56 100.14,82.69 v1(100.48,83.03)
HDMI_CLK#: length 87.4
  L6 w0.102: v1(99.56,83.02) 99.82,83.02 100,82.84 100,82.62 99.74,82.36 98.36,82.36 97.44,81.44 96.43,81.44 95.82,82.05 92.18,82.05 91.03,83.21 86.86,83.21 85.63,81.98 79.62,81.98 78.99,81.34 70.22,81.34 69.33,82.23 63.27,82.23 60.27,79.23 58.88,79.23 55.14,75.49 50.32,75.49 48.3,73.47 47.37,73.47 46.94,73.9 42.37,73.9 37.02,68.55 29.8,68.55 29.51,68.26 26.78,68.26 v1(26.47,68.57)
  BOTTOM w0.127: C5701.1 23.48,68.14 24.13,68.14 ; 24.13,68.14 v2(24.13,68.31) ; 24.13,68.14 26.03,68.14 v1(26.47,68.57) ; CPU1.F56 99.88,83.34 v1(99.56,83.02)
HDMI_CLK#_R: length 3.4
  TOP w0.127: v2(20.65,68.72) 20.76,68.61 v1(21.34,68.61) 21.55,68.82 RN5701.7
  BOTTOM w0.127: R5712.1 20.55,68.61 v1(21.34,68.61) 22.12,68.61 C5701.2
HDMI_CLK#_R_C: length 9.4
  BOTTOM w0.127: HDMI1.12 11.68,69.77 12.59,69.77 13.91,68.44 14.83,68.44 ; v2(14.83,68.59) 14.83,68.44 ; 14.83,68.44 15.73,68.44 15.86,68.57 ED5702.2 ED5702.9 17.77,68.57 17.91,68.44 18.61,68.44 ER5701.1 18.86,68.57 R5712.2
HDMI_CLK_R: length 3.5
  TOP w0.127: v2(20.78,67.5) 21.08,67.8 v1(21.34,67.8) 21.71,68.17 RN5701.8
  BOTTOM w0.127: C5704.2 22.03,67.8 v1(21.34,67.8) 20.64,67.8 R5714.1
HDMI_CLK_R_C: length 9.5
  BOTTOM w0.127: R5714.2 19.6,67.7 18.83,67.7 ER5701.2 18.34,68.2 17.9,68.2 17.78,68.07 ED5702.10 ED5702.1 15.86,68.07 15.73,68.2 13.81,68.2 13.37,68.65 ; 13.37,68.65 12.49,69.53 11.68,69.53 HDMI1.10 ; 13.37,68.65 v2(13.23,68.51)
HDMI_DATA0: length 98
  L6 w0.102: v1(102.3,82.94) 102.39,82.85 102.39,82.1 102.14,81.85 98.84,81.85 97.57,80.58 92.03,80.58 92.01,80.6 91.99,80.6 90.98,81.62 88.8,81.62 88.4,82.02 86.86,82.02 86.13,81.29 79.91,81.29 77.47,78.85 73.7,78.85 71.93,80.63 68.96,80.63 68.07,81.52 64.38,81.52 63.3,80.44 63.3,80.44 58.46,75.6 56.89,75.6 55.73,74.44 53.76,74.44 52.1,72.78 47.09,72.78 46.65,73.21 42.65,73.21 36.96,67.52 36.96,66.57 36.42,66.03 34.07,66.03 33.36,66.74 26.37,66.74 25.37,67.73 25.37,69.87 25.63,70.12 26.03,70.12 26.42,69.73 v1(26.42,69.55)
  BOTTOM w0.127: v1(102.3,82.94) 102.3,82.82 102.17,82.69 CPU1.G53 ; v2(25.3,69.94) 25.3,70.1 ; 25.3,70.1 26.02,70.1 26.42,69.71 v1(26.42,69.55) ; 25.3,70.1 23.7,70.1 C5703.1
HDMI_DATA0#: length 98.8
  L6 w0.102: v1(102.3,83.58) 102.69,83.19 102.69,82.78 102.59,82.68 102.59,82.02 102.22,81.65 98.93,81.65 97.66,80.38 91.95,80.38 91.92,80.4 91.91,80.4 90.89,81.42 88.71,81.42 88.31,81.82 86.95,81.82 86.22,81.09 79.99,81.09 77.55,78.65 73.62,78.65 71.84,80.43 68.88,80.43 67.99,81.32 64.46,81.32 63.38,80.24 58.54,75.4 56.97,75.4 55.81,74.24 53.84,74.24 52.18,72.58 47,72.58 46.57,73.01 42.73,73.01 37.16,67.44 37.16,66.48 36.5,65.82 33.99,65.82 33.27,66.53 26.29,66.53 25.17,67.65 25.17,69.95 25.54,70.33 26.39,70.33 v1(26.42,70.35)
  BOTTOM w0.127: CPU1.F53 102.06,83.34 v1(102.3,83.58) ; v1(26.42,70.35) 26.41,70.34 24.13,70.34 ; v2(24.13,70.52) 24.13,70.34 ; 24.13,70.34 C5709.1
HDMI_DATA0#_R: length 3.4
  TOP w0.127: RN5701.5 21.77,69.97 v1(21.33,70.41) 21.33,70.59 v2(21.64,70.9)
  BOTTOM w0.127: R5715.1 21.26,70.34 v1(21.33,70.41) 22.09,70.41 C5709.2
HDMI_DATA0#_R_C: length 19
  BOTTOM w0.127: 13.7,73.26 13.7,73.53 12.83,74.41 11.27,74.41 10.48,73.62 10.37,73.22 10.49,72.59 10.36,72.19 10.5,71.59 10.5,71.59 10.36,71.21 10.48,70.62 10.37,70.16 10.5,69.62 10.39,69.3 HDMI1.9 ; 13.7,73.26 13.7,70.32 14.08,69.94 15.73,69.94 15.86,70.07 ED5702.5 ED5702.6 17.76,70.07 17.88,69.95 18.34,69.95 ER5703.1 18.86,70.34 R5715.2 ; 13.7,73.26 v2(13.84,73.26)
HDMI_DATA0_R: length 3.5
  TOP w0.127: v2(20.78,69.94) 21.11,69.61 v1(21.33,69.61) 21.61,69.32 RN5701.6
  BOTTOM w0.127: R5716.1 20.66,69.61 v1(21.33,69.61) 22.01,69.61 C5703.2
HDMI_DATA0_R_C: length 19.6
  BOTTOM w0.127: HDMI1.7 10.62,68.47 10.62,69.23 10.75,69.61 10.69,69.84 10.62,70.16 10.73,70.62 10.61,71.19 10.73,71.51 10.75,71.57 10.61,72.18 10.73,72.57 10.62,73.21 10.69,73.49 11.37,74.17 12.73,74.17 13.46,73.43 13.46,71.61 ; v2(13.34,71.61) 13.46,71.61 ; 13.46,71.61 13.46,70.22 13.98,69.7 15.73,69.7 15.86,69.57 ED5702.4 ED5702.7 17.7,69.57 17.83,69.71 18.61,69.71 ER5703.2 18.86,69.45 R5716.2
HDMI_DATA1: length 94.8
  L6 w0.102: v1(26.67,65.13) 26.35,65.44 25.87,65.44 24.41,66.91 24.41,70.43 25.67,71.69 29.55,71.69 30.56,70.67 35.5,70.67 40.21,75.38 49.11,75.38 49.94,76.21 54.89,76.21 58.9,80.22 60.15,80.22 62.85,82.93 69.64,82.93 70.54,82.03 78.7,82.03 79.34,82.66 85.35,82.66 86.62,83.93 91.15,83.93 92.47,85.26 95.99,85.26 96.73,84.52 98.95,84.52 99.29,84.18 99.29,84.08 99.31,84.06 99.31,83.91 v1(99.56,83.67)
  BOTTOM w0.127: v2(23.93,65.14) 23.93,65.29 ; 23.93,65.29 25.27,65.29 25.43,65.13 v1(26.67,65.13) ; 23.93,65.29 C5705.1 ; v1(99.56,83.67) 99.23,83.34 CPU1.F58
HDMI_DATA1#: length 94.7
  L6 w0.102: v1(26.67,65.93) 26.67,65.77 26.54,65.64 25.96,65.64 24.61,66.99 24.61,70.34 25.76,71.49 29.46,71.49 30.48,70.47 35.58,70.47 40.29,75.18 49.2,75.18 50.03,76.01 54.97,76.01 58.99,80.02 60.23,80.02 62.93,82.72 69.55,82.72 70.45,81.82 78.79,81.82 79.42,82.46 85.43,82.46 86.71,83.73 91.23,83.73 92.56,85.06 95.9,85.06 96.65,84.31 98.86,84.31 99.09,84.09 99.09,83.74 99.01,83.67 v1(98.64,83.67)
  BOTTOM w0.127: v1(26.67,65.93) 26.67,65.84 26.19,65.37 25.53,65.37 25.37,65.53 25.15,65.53 ; v1(98.64,83.67) 98.96,83.99 CPU1.E58 ; C5706.1 23.52,65.53 25.15,65.53 ; 25.15,65.53 v2(25.15,65.69)
HDMI_DATA1#_R: length 3.3
  TOP w0.127: v2(21.64,66.63) 21.23,66.23 v1(21.23,66.08) 21.63,65.68 RN5703.5
  BOTTOM w0.127: R5713.1 21.16,66.15 v1(21.23,66.08) 21.34,66.18 C5706.2
HDMI_DATA1#_R_C: length 9.4
  BOTTOM w0.127: HDMI1.6 11.68,66.77 13.21,66.77 ; R5713.2 19.21,66.15 19.18,66.11 ER5704.1 18.41,65.76 ED5701.6 ED5701.5 15.86,65.76 15.73,65.63 15.16,65.63 14.01,66.77 13.21,66.77 ; 13.21,66.77 v2(13.21,66.96)
HDMI_DATA1_R: length 3.1
  TOP w0.127: RN5703.6 21.47,65.03 v1(21.23,65.27) 20.85,65.27 v2(20.62,65.49)
  BOTTOM w0.127: C5705.2 21.25,65.29 v1(21.23,65.27) 21.23,65.26 R5711.1
HDMI_DATA1_R_C: length 9.4
  BOTTOM w0.127: 14.8,65.64 13.91,66.53 11.68,66.53 HDMI1.4 ; 14.8,65.64 15.06,65.38 15.73,65.38 15.86,65.26 ED5701.4 ED5701.7 17.93,65.26 18.18,65.51 18.48,65.51 ER5704.2 19.12,65.22 19.16,65.26 R5711.2 ; 14.8,65.64 v2(14.71,65.54)
HDMI_DATA2: length 100.3
  L6 w0.102: v1(26.6,63.45) 26.28,63.76 25.98,63.76 23.69,66.05 23.69,70.67 25.43,72.41 31.36,72.41 32.22,71.56 35.42,71.56 39.92,76.06 48.83,76.06 49.66,76.9 53.36,76.9 57.55,81.09 59.66,81.09 62.19,83.61 63.7,83.61 69.99,83.61 70.87,82.74 78.45,82.74 79.05,83.35 84.93,83.35 86.7,85.12 91.48,85.12 92.2,85.84 96.39,85.84 97.03,85.2 100.59,85.2 101.18,84.61 101.18,83.91 v1(101.39,83.7)
  BOTTOM w0.127: v1(101.39,83.7) 101.29,83.7 100.93,83.34 CPU1.F55 ; 23.77,63.38 23.89,63.38 24.43,63.93 24.93,63.93 25.32,63.54 26.51,63.54 v1(26.6,63.45) ; 23.77,63.38 C5708.1 ; 23.77,63.38 v2(23.77,63.21)
HDMI_DATA2#: length 100.3
  L6 w0.102: v1(100.46,83.68) 100.79,83.68 100.98,83.87 100.98,84.52 100.5,85 96.94,85 96.31,85.63 92.29,85.63 91.57,84.91 86.79,84.91 85.02,83.14 79.14,83.14 78.53,82.54 70.78,82.54 69.91,83.41 63.61,83.41 63.61,83.41 62.27,83.41 59.75,80.88 57.63,80.88 53.44,76.69 49.74,76.69 48.91,75.86 40.01,75.86 35.5,71.36 32.13,71.36 31.28,72.21 25.51,72.21 23.89,70.59 23.89,66.14 26.06,63.97 26.44,63.97 26.6,64.12 v1(26.6,64.26)
  BOTTOM w0.127: v2(25.78,63.94) 25.78,63.78 ; 25.78,63.78 26.29,63.78 26.6,64.08 v1(26.6,64.26) ; 25.78,63.78 25.42,63.78 25.03,64.17 24.33,64.17 23.79,63.62 23.43,63.62 22.87,64.18 C5707.1 ; v1(100.46,83.68) 100.69,83.68 100.93,83.92 CPU1.E55
HDMI_DATA2#_R: length 3.2
  TOP w0.127: v2(20.57,64.27) v1(21.24,64.27) 21.5,64.53 RN5703.7
  BOTTOM w0.127: R5717.1 20.64,64.25 21.21,64.25 v1(21.24,64.27) C5707.2
HDMI_DATA2#_R_C: length 10.9
  BOTTOM w0.127: HDMI1.3 9.87,65.65 11.4,64.13 13.46,64.13 ; R5717.2 19.57,64.32 18.81,64.32 ER5702.1 18.58,64.1 17.88,64.1 17.72,64.25 ED5701.9 ED5701.2 15.86,64.25 15.73,64.13 13.46,64.13 ; 13.46,64.13 v2(13.46,64.3)
HDMI_DATA2_R: length 3.1
  TOP w0.127: RN5703.8 21.65,63.88 v1(21.24,63.47) v2(21.24,62.87)
  BOTTOM w0.127: C5708.2 21.9,63.47 v1(21.24,63.47) 21.22,63.49 R5718.1
HDMI_DATA2_R_C: length 10.8
  BOTTOM w0.127: 14.78,63.88 11.3,63.88 10.33,64.86 10.01,64.86 HDMI1.1 ; 14.78,63.88 v2(14.78,63.69) ; 14.78,63.88 15.73,63.88 15.86,63.76 ED5701.1 ED5701.10 17.82,63.76 17.92,63.86 18.31,63.86 ER5702.2 19.1,63.4 19.19,63.49 R5718.2
HDMI_HPD_B: length 2.4
  BOTTOM w0.102: Q5703.B 22.29,77.82 v2(22.7,77.41) 21.99,77.41 R5707.2
HDMI_HPD_E: length 3.8
  BOTTOM w0.102: R5705.1 18.22,77.12 18.86,77.12 R5719.2 18.94,77.07 v2(19.84,77.07) 20.07,77.07 20.33,77.33 Q5703.E
HDMI_PLL_GND: length 4.2
  BOTTOM w0.508: R5709.2 28,75.5 Q5701.D 27.98,74.06 v1(28.36,73.68)
  vias: v2(26.06,72.48)
HOST_DEBUG_TX: length 335.8
  TOP w0.102: v1(58.85,36.9) 60.17,36.9 v2(60.55,36.51) 60.89,36.17 117.34,36.17 118.27,36.17 123.14,41.05 123.95,41.86 144.33,41.86 144.33,41.86 146.93,41.86 146.93,41.86 150.06,41.86 150.87,41.05 157.61,34.31 166.93,34.31 166.93,34.31 v1(167.13,34.31) ; R6115.1 37.34,58.02 37.59,57.77 v1(37.85,57.77) ; v1(202.9,29.09) 202.44,29.09 202.09,28.74 KBC24.81
  L3 w0.102: v1(58.85,36.9) 58.55,37.2 56.87,37.2 54.81,35.14 50.55,35.14 49.5,34.1 49.5,30.16 46.94,27.6 46.94,25.31 42.42,20.79 31.45,20.79 30.68,21.55 30.68,25.18 29.11,26.76 29.11,28.28 25.88,31.51 25.88,44.18 32.27,50.57 32.27,53.24 32.72,53.68 33.42,53.68 v1(33.53,53.57) ; v1(231.22,38.52) 230.68,37.98 226.83,37.98 225.76,39.05 223.7,39.05 223.01,39.74 219.19,39.74 218.63,40.29 216.82,40.29 216.41,39.88 216.41,37.2 216.08,36.87 216.08,32.78 215.08,31.79 214.96,31.79 214.45,31.28 214.45,30.69 212.71,28.95 203.04,28.95 v1(202.9,29.09) 202.42,29.09 200.16,31.35 199.63,31.35 198.87,30.59 195.84,30.59 195.03,31.4 192.78,31.4 192.45,31.74 192.45,33.05 191.15,34.35 185.5,34.35 185.2,34.05 167.39,34.05 v1(167.13,34.31)
  L4 w0.102: v1(279.4,44.05) 277.63,42.28 277.63,39.89 274.81,37.07 267.33,37.07 266.03,35.76 243.57,35.76 242.72,36.61 233.12,36.61 v1(231.22,38.52)
  L6 w0.102: v1(33.53,53.57) 34.26,54.3 34.26,54.53 37.5,57.77 v1(37.85,57.77)
  BOTTOM w0.102: v1(279.4,44.05) 277.94,42.59 R2466.2 R2478.1
HPD_HDMI_CON: length 16.6
  TOP w0.102: v1(15.11,73.63) 15.23,73.76 15.7,73.76 16.86,74.92 v2(18.97,74.92) 19.33,74.92 v1(20.02,75.6)
  BOTTOM w0.102: v1(20.02,75.6) 20.18,75.6 R5706.2 R5707.1 ; ED5703.9 ED5703.2 15.56,73.96 15.23,73.63 v1(15.11,73.63) 13.85,74.9 11.06,74.9 10.06,73.9 10.05,73.9 HDMI1.19
HW_GPS_DISABLE2#: length 12.7
  TOP w0.127: R2498.1 R2413.1 92.23,108.62 92.35,108.49 v1(92.36,108.49) ; D6201.K 86.18,101.53 v2(87.76,103.11) 87.71,103.16 87.71,103.95 88.01,104.25 v1(88.14,104.25)
  BOTTOM w0.127: v1(88.14,104.25) 88.14,106.51 90.02,108.39 90.25,108.39 90.35,108.49 v1(92.36,108.49)
HW_GPS_DISABLE2#_D: length 17.6
  TOP w0.127: D6201.A 88.26,103.24 88.27,103.25 v1(88.27,103.62) ; AFTP6266.1 92.02,107.27 v1(92.66,106.64)
  BOTTOM w0.127: 92.66,106.65 92.62,106.65 91.41,107.86 89.87,107.86 88.62,106.61 88.62,104.11 88.27,103.75 v1(88.27,103.62) ; 92.66,106.65 v1(92.66,106.64) ; 92.66,106.65 92.67,106.64 93.31,106.64 95.5,108.83 95.5,110.09 95.91,110.5 WWAN1.26
I2C0_SCL: length 9.1
  TOP w0.14: RN2008.1 131.75,78.5 131.33,78.08 v2(131.33,77.55) 132,77.55 132.17,77.38 132.89,77.38 133.73,78.22 v1(133.73,79.36)
  BOTTOM w0.089: CPU1.N3 130.71,79.49 131.38,79.49 131.47,79.45 131.74,79.45 131.83,79.49 133.61,79.49 v1(133.73,79.36)
I2C0_SCL_TCH_PAD: length 205.1
  TOP w0.14: v1(127.1,7.1) 127.1,7.24 127.71,7.85 128.01,7.85 128.2,7.66 RN6505.4
  L4 w0.127: v1(189.5,18.39) 189.92,18.39 190.7,17.61 190.7,12.37 187.05,8.72 141.87,8.72 138.45,5.3 136.01,5.3 135.64,4.94 134.56,4.94 133.86,5.64 132.2,5.64 130.27,7.57 127.63,7.57 127.15,7.1 v1(127.1,7.1) ; v1(129.57,78.19) 129.57,78.17 129.76,77.98 129.77,77.98 131.8,75.94 131.8,74.22 131.97,74.05 131.97,64.92 133.12,63.77 133.12,62.39 133.8,61.72 133.8,58.23 133.9,58.13 133.9,52.45 143.13,43.22 166.85,43.22 169.96,40.1 171.48,40.1 172.25,40.88 178.58,40.88 179.28,41.58 179.99,41.58 180.25,41.84 180.25,42.35 181.33,43.43 181.76,43.43 182.31,43.98 183.06,43.98 184.48,42.56 188.24,42.56 188.58,42.9 189.44,42.9 v1(189.76,43.22)
  L6 w0.114: v1(189.5,18.39) 189.5,18.41 189.78,18.69 189.78,23.98 189.29,24.46 189.29,25.9 189.29,38.83 189.14,38.97 189.14,42.6 v1(189.76,43.22)
  BOTTOM w0.14: 128.35,7.66 128.98,7.66 129.41,7.22 129.41,5.95 130.05,5.32 131.19,5.32 131.46,5.59 Q6503.1 ; 128.35,7.66 127.71,7.66 127.15,7.1 v1(127.1,7.1) 127.1,7.24 126.61,7.73 125.79,7.73 EC6504.1 125.41,7.35 R6518.1 ; 128.35,7.66 v2(128.35,7.43) ; v1(129.57,78.19) 129.57,78.17 129.21,77.81 CPU1.U6
I2C0_SDA: length 10.7
  BOTTOM w0.089: 135.1,80.91 135.1,80.55 134.65,80.1 131.83,80.1 131.71,80.15 131.51,80.15 131.42,80.11 131.15,80.11 131.06,80.15 130.52,80.15 130.31,80.22 CPU1.M4
  BOTTOM w0.14: 135.1,80.91 135.88,81.68 v2(136.37,81.68) 136.91,81.68 137.93,82.7 137.93,83.08 138.34,83.5 RN2007.2
I2C0_SDA_TCH_PAD: length 199.5
  TOP w0.14: v1(127.1,7.88) 127.34,8.12 128.01,8.12 128.2,8.31 RN6505.3
  L4 w0.127: v1(128.93,78.14) 129.34,77.73 129.67,77.73 131.56,75.84 131.56,74.12 131.73,73.95 131.73,64.82 132.88,63.67 132.88,62.29 133.56,61.62 133.56,58.13 133.65,58.03 133.65,52.35 143.03,42.97 166.75,42.97 169.86,39.86 171.58,39.86 172.35,40.64 178.68,40.64 179.38,41.34 180.09,41.34 180.49,41.74 180.49,42.25 181.43,43.19 181.86,43.19 182.41,43.74 182.96,43.74 184.38,42.31 188.34,42.31 188.68,42.66 189.52,42.66 v1(189.76,42.41) ; v1(189.74,17.77) 189.79,17.82 190.15,17.82 190.46,17.51 190.46,12.47 186.95,8.96 141.77,8.96 138.35,5.54 135.91,5.54 135.54,5.18 134.66,5.18 133.96,5.88 132.3,5.88 130.37,7.81 127.65,7.81 127.58,7.88 v1(127.1,7.88)
  L6 w0.114: v1(189.74,17.77) 189.99,18.02 189.99,24.07 189.5,24.55 189.5,25.99 189.5,38.92 189.36,39.06 189.36,42.01 v1(189.76,42.41)
  BOTTOM w0.14: Q6503.4 130.16,8.42 129.71,7.97 127.19,7.97 v1(127.1,7.88) 126.87,8.11 126.62,8.11 ; 126.62,8.11 125.67,8.11 EC6502.1 125.41,8.24 R6519.1 ; 126.62,8.11 v2(126.62,8.34) ; v1(128.93,78.14) 128.91,78.12 128.91,78.02 CPU1.U7
I2C1_SCL: length 8.5
  TOP w0.14: v1(134.37,79.49) 134.08,79.77 133.56,79.77 133.32,79.53 133.32,78.76 133.43,78.65 133.43,78.25 132.97,77.79 v2(132.56,77.79) 132.41,77.94 RN2008.2
  BOTTOM w0.089: v1(134.37,79.49) 134.21,79.64 134.18,79.67 134.11,79.75 131.88,79.75 131.8,79.66 131.71,79.63 131.51,79.63 131.42,79.66 131.18,79.66 CPU1.N2
I2C1_SCL_R: length 68.7
  TOP w0.14: 139.06,9.42 139.54,9.42 140.15,8.81 140.87,8.81 140.88,8.79 170.69,8.79 171.43,9.53 172.01,10.12 174.46,10.12 174.93,9.64 176.83,9.64 177.4,10.21 TPAD1.3 ; 139.06,9.42 137.5,9.42 137.19,9.11 132.29,9.11 132.09,8.9 132.09,8.26 132.25,8.1 132.41,8.1 v1(132.74,8.43) ; 139.06,9.42 AFTP6237.1
  L6 w0.114: v1(132.74,8.43) 132.4,8.1 129.47,8.1 127.65,6.27 122.06,6.27 121.81,6.53 121.81,7.11 121.89,7.19 122.39,7.19 v1(122.58,7)
  BOTTOM w0.14: Q6503.6 131.99,8.14 132.44,8.14 v1(132.74,8.43) 132.86,8.31 RN6502.4 ; R6518.2 123.32,7.66 123.05,7.66 122.58,7.2 v1(122.58,7) 122.23,7.35 R6515.2
I2C1_SDA: length 8.4
  BOTTOM w0.089: v2(135.56,80.76) 135.56,80.71 134.77,79.93 131.81,79.93 131.77,79.89 CPU1.N1
  BOTTOM w0.14: v2(135.56,80.76) 136.07,81.27 137.09,81.27 138.66,82.84 RN2007.1
I2C1_SDA_R: length 70.9
  TOP w0.14: AFTP6240.1 140.97,9.08 ; 140.97,9.08 140.99,9.06 170.58,9.06 171.9,10.38 172.07,10.38 172.07,10.38 172.12,10.38 174.57,10.38 175.04,9.9 176.21,9.9 176.4,10.09 TPAD1.2 ; 140.97,9.08 140.96,9.07 140.27,9.07 139.65,9.69 137.39,9.69 137.08,9.38 132.18,9.38 131.82,9.02 131.82,7.99 131.98,7.83 132.45,7.83 v1(132.74,7.54)
  L6 w0.114: v1(132.74,7.54) 132.4,7.88 129.56,7.88 127.74,6.06 121.97,6.06 121.59,6.44 121.59,7.2 121.8,7.41 122.16,7.41 v1(122.58,7.83)
  BOTTOM w0.14: R6511.2 121.79,7.93 122.49,7.93 v1(122.58,7.83) 122.68,7.93 123.32,7.93 R6519.2 ; RN6502.3 132.86,7.66 v1(132.74,7.54) 132.74,7.6 132.58,7.76 130.58,7.76 130.16,7.34 Q6503.3
I_ADP: length 4.1
  TOP w0.102: v2(206.5,18.73) 207,19.23 C2435.1 R2421.2 207.92,19.59 KBC24.110
I_BATT: length 300.7
  TOP w0.203: v1(209.63,22.72) 209.51,22.61 KBC24.114
  TOP w0.254: v1(168.02,32.88) 167.7,32.88 167.58,33.01 166.94,33.01 166.87,32.93 157.03,32.93 149.49,40.47 146.35,40.47 124.52,40.47 118.83,34.78 118.57,34.78 118.57,34.78 57.59,34.78 56.93,35.44 56.75,35.44 56.52,35.68 v1(56.52,36.05) ; R2498.2 89.89,109.43 v1(89.79,109.54)
  L3 w0.254: v1(168.02,32.88) 168.76,32.88 169.65,31.99 184.82,31.99 184.85,31.96 188.87,31.96 189.24,32.33 190.25,32.33 190.91,31.66 190.91,29.65 191.38,29.19 192.65,29.19 194.9,26.93 v1(196.14,26.93) ; v1(77.34,69.45) 76.56,70.24 76.56,78.19 77.05,78.69 77.46,79.09 77.46,81.32 75.16,83.62 75.16,85.08 76.86,86.78 80.82,86.78 81.63,85.96 82.68,85.96 87.02,90.3 87.02,91.33 88.27,92.58 88.27,101.62 89.94,103.3 89.94,105.47 89.56,105.85 89.56,107.45 89.92,107.81 89.92,109.23 89.89,109.25 89.89,109.28 89.79,109.39 v1(89.79,109.54)
  L4 w0.254: v1(65.91,51.29) 63.5,48.88 63.5,46.09 63.63,45.96 63.63,45.45 63.8,45.27 63.8,42.23 62.89,41.31 61.8,41.31 56.78,36.29 56.75,36.29 v1(56.52,36.05) ; v1(203.84,10.78) 203.96,10.65 210.03,10.65 211.35,11.97 v1(213.94,11.97)
  L6 w0.254: v1(203.84,10.78) 203.84,10.86 203.31,11.39 200.24,11.39 199.33,12.31 199.33,12.81 198.8,13.33 198.28,13.33 197.78,13.83 196.79,14.82 196.79,15.24 197.38,15.83 197.38,25.69 v1(196.14,26.93)
  BOTTOM w0.254: v1(203.84,10.78) 203.84,10.65 202.74,9.56 201.75,9.56 201.26,10.06 R2423.2 201.19,10.01 C2441.1 ; v1(209.63,22.72) 209.88,22.46 209.99,22.46 211.91,20.54 211.91,19.62 213.33,18.2 213.33,17.99 213.94,17.38 v1(213.94,11.97) ; v1(77.34,69.45) 76.8,68.92 76.8,67.06 74.42,64.67 74.42,55.27 73.11,53.96 72.05,53.96 71.75,53.66 71.75,53.04 70.01,51.29 v2(66.98,51.29) v1(65.91,51.29)
I_SYS: length 8.9
  TOP w0.102: KBC24.113 209.11,19.88 209.52,19.47 209.52,18.6 208.56,17.64 207.47,17.64 206.93,17.1 v2(206.88,17.1) 206.48,17.51 C2427.1 R2425.2 R2497.2
ICSP_CLK_R: length 5.5
  TOP w0.14: DB3.2 283.3,43.66 283.2,43.56 281.69,43.56 ; R2463.1 278.96,43.17 280.42,43.17 280.81,43.56 281.69,43.56 ; 281.69,43.56 v2(281.69,43.72)
ICSP_CLOCK: length 110.6
  TOP w0.14: KBC24.101 204.32,22.05 204.37,22.1 204.37,22.24 204.38,22.25 204.38,22.91 v1(204.31,22.98) ; 276.15,39.74 276.15,42.25 277.01,43.11 277.5,43.11 R2463.2 ; 276.15,39.74 276.15,30.39 275.51,29.75 275.51,27.72 v1(275.34,27.54) ; 276.15,39.74 v2(275.97,39.74)
  L4 w0.127: v1(204.31,22.98) 204.32,22.99 204.32,23.08 204.54,23.3 204.59,23.3 205.03,23.74 207.3,23.74 207.59,23.44 209.9,23.44 212.12,21.23 213.58,21.23 218.38,16.43 218.45,16.43 218.52,16.36 218.52,15.58 222.31,11.8 225.53,11.8 226.47,12.74 233.69,12.74 234.32,12.1 235.2,12.1 235.95,12.86 235.95,13.17 235.95,13.48 239.96,17.49 242.62,17.49 243.33,18.2 243.33,19.16 247.24,23.07 247.24,24.68 248.53,25.97 250.28,25.97 251.68,24.57 255.08,24.57 255.31,24.8 255.31,25.84 258.14,28.67 259.53,28.67 259.71,28.5 260.15,28.5 261.09,27.56 265.16,27.56 266.03,28.42 269.05,28.42 271.58,25.89 274.96,25.89 275.51,26.44 275.51,27.37 v1(275.34,27.54)
ICSP_CLR: length 113.8
  TOP w0.102: v1(209.22,27.54) 209.04,27.54 208.64,27.14 206.88,27.14 206.09,26.34 KBC24.87 ; v1(278.13,39.86) 278,39.86 v2(277.62,39.48) 277.04,38.9 277.04,27.75 v1(277.24,27.54)
  L3 w0.102: v1(247.93,15.86) 248.49,15.86 254.58,21.96 255.52,21.96 255.91,22.34 259.89,22.34 260.78,23.23 262.23,23.23 263.58,24.57 263.6,24.57 263.83,24.8 263.83,25.13 265.62,26.92 268.88,26.92 268.89,26.91 276.61,26.91 v1(277.24,27.54)
  L6 w0.102: v1(247.93,15.86) 244.73,12.66 243.25,12.66 242.62,12.02 240.92,12.02 240.84,12.1 240.36,12.1 239.67,11.41 232.51,11.41 230.78,9.69 230.78,9 230.53,8.75 229.84,8.75 229.46,8.37 226.59,8.37 226.22,8.74 225.74,8.74 225.36,9.11 225.36,10.5 224.86,11 219.8,11 218.64,12.15 218.63,12.15 218.01,12.78 218.01,12.79 215.54,15.25 214.52,15.25 213.89,15.88 213.89,16.66 212.83,17.73 212.83,18.31 211.91,19.23 211.43,19.23 210.81,19.85 210.81,20.66 211.08,20.93 211.08,23.27 209.48,24.87 209.48,27.17 209.22,27.44 v1(209.22,27.54)
  BOTTOM w0.102: v1(278.13,39.86) 278.83,40.56 R2414.1 R2465.2
ICSP_CLR_R: length 5.2
  TOP w0.102: DB3.6 282.74,41.66 282.58,41.82 281.99,41.82 281.56,41.39 v2(280.39,41.39) 279.65,41.39 v1(279.53,41.51)
  BOTTOM w0.102: R2465.1 v1(279.53,41.51)
ICSP_DATA: length 110.1
  TOP w0.14: 276.42,40.88 276.42,30.28 275.78,29.64 275.78,27.73 v1(275.97,27.54) ; 276.42,40.88 v2(276.61,40.88) ; 276.42,40.88 276.42,42.14 277.12,42.84 277.5,42.84 R2464.2 ; v1(205.02,22.97) 205.01,22.97 204.93,22.97 204.65,22.69 204.65,22.25 204.72,22.18 KBC24.102
  L4 w0.127: v1(205.02,22.97) 205,22.98 205,23.37 205.13,23.5 207.2,23.5 207.49,23.2 209.8,23.2 212.02,20.99 213.48,20.99 218.28,16.19 218.28,15.48 222.21,11.55 225.63,11.55 226.57,12.49 233.59,12.49 234.22,11.86 235.3,11.86 236.19,12.76 236.19,13.27 236.19,13.38 240.06,17.24 242.72,17.24 243.57,18.1 243.57,19.06 247.48,22.97 247.48,24.58 248.63,25.73 250.18,25.73 251.58,24.33 255.18,24.33 255.55,24.7 255.55,25.74 258.24,28.43 259.43,28.43 259.61,28.26 260.05,28.26 260.99,27.32 265.26,27.32 266.13,28.18 268.95,28.18 271.48,25.64 275.06,25.64 275.76,26.34 275.76,27.33 v1(275.97,27.54)
ICSP_DATA_R: length 5.6
  TOP w0.14: DB3.3 283.32,43.16 283.18,43.29 280.92,43.29 280.53,42.9 280.26,42.9 ; 280.26,42.9 279.07,42.9 R2464.1 ; 280.26,42.9 v2(280.26,42.71)
ILIM_HI:
  vias: v1(27.05,53.43) v2(26.04,53.71)
ILIM_SEL: length 2.7
  TOP w0.102: U3401.4 29.11,57.12 29.31,57.33 v2(29.31,57.34) 29.51,57.54 29.51,58.01 R3405.2
INT#_ITE8010: length 2.6
  TOP w0.102: U9601.7 71.88,73.27 71.88,71.83 R2422.2 71.79,71.74 v2(70.82,71.74)
INT_TP#: length 171.3
  TOP w0.102: R2431.2 216.85,40.43 v1(217.42,41.01) ; v1(138.68,6.84) 139.06,7.22 AFTP6241.1 140.11,8.39 170.92,8.39 172.15,9.63 174.37,9.63 174.77,9.24 178.62,9.24 179.4,10.02 TPAD1.5 179.4,11.62 180.46,12.67 181.23,12.67 182,13.45 183.39,13.45 184.18,12.66 186.2,12.66 186.63,13.09 186.63,16.13 v1(188.56,18.06)
  L4 w0.102: v1(217.42,41.01) 216.61,41.82 213.89,41.82 213.03,40.95 213.03,40.95 212.78,40.7 212.42,40.7 212.01,41.11 206.73,41.11 206.43,40.8 195,40.8 193.4,39.2 189.17,39.2 188.96,39.41 v1(188.62,39.41)
  L6 w0.102: v1(188.62,39.41) 188.65,39.38 188.65,38.96 188.93,38.68 188.93,37.9 188.93,24.31 189.28,23.96 189.28,18.78 v1(188.56,18.06)
  BOTTOM w0.102: RN6501.2 139.06,4.81 139.32,5.07 139.32,6.21 v1(138.68,6.84) ; v1(188.62,39.41) 186.89,41.13 185.36,41.13 184.97,40.74 184.34,40.74 183.87,40.27 183.52,39.91 183.16,39.91 183.01,40.07 182.57,40.07 182.25,40.39 179.73,40.39 179.53,40.19 175.65,40.19 173.14,42.7 173.14,42.71 172.69,43.15 172.27,43.15 171.68,43.74 168.06,43.74 167.74,43.42 167.08,43.42 166.91,43.25 147.24,43.25 140.02,50.47 R410.1 140.08,50.72 D401.K
IR_CAMERA_DET#: length 101.7
  TOP w0.102: D5501.A 79.5,99.93 78.87,100.57 77.29,100.57 v1(77.17,100.44)
  L3 w0.102: v1(80.44,80.53) 80.47,80.5 80.47,79.06 81.25,78.27 86.66,78.27 94.02,70.91 106.59,70.91 106.61,70.9 108.97,70.9 109.03,70.84 116.79,70.84 117.3,71.35 119.77,71.35 120.13,70.99 125.12,70.99 125.58,70.53 125.58,68.57 126.15,67.99 127.14,67.99 127.39,67.74 127.39,63.53 128.69,62.23 v1(129.42,62.23) ; v1(75.18,80.38) 75.11,80.38 72.87,82.62 72.87,89.01 v1(73.79,89.93) 74.18,90.32 74.18,94.35 76.37,96.54 76.37,99.18 77.17,99.98 v1(77.17,100.44)
  BOTTOM w0.102: v1(73.79,89.93) 73.63,89.77 EC5504.1 72.29,90.57 72.29,90.97 71.83,91.42 R2051.2 72.15,91.81 72.9,91.81 73.43,92.34 R5540.2 ; v1(75.18,80.38) 75.31,80.5 v2(77.93,80.5) 80.42,80.5 v1(80.44,80.53) ; v1(129.42,62.23) 128.58,63.08 128.58,63.51 128.31,63.77 128.12,63.77 127.96,63.93 127.96,64.96 128.17,65.16 CPU1.AY7
IR_CAMERA_DET#_R: length 13.4
  TOP w0.102: v1(76.5,100.42) 77.22,99.71 D5501.K
  L3 w0.102: v1(73.61,93.28) 73.61,94.24 76.16,96.8 76.16,100.07 v1(76.5,100.42)
  BOTTOM w0.102: IRCCD1.4 71.59,92.4 71.65,92.47 v2(71.68,92.47) 71.81,92.34 R5540.1 72.67,92.34 v1(73.61,93.28)
IT8010_WRST#: length 5.1
  TOP w0.14: v2(68.81,74.94) 69.41,74.94 v1(69.47,75) 69.62,74.85 U9601.4
  BOTTOM w0.14: C9603.1 R9610.1 68.33,73.65 69.47,74.79 v1(69.47,75)
ITP_PMODE: length 92.1
  TOP w0.102: R9933.1 58.55,87.3 58.55,86.98 58.14,86.57 57.75,86.57 v1(57.32,87) 57.02,87.3 v2(57.02,87.49)
  L4 w0.102: v1(59.72,85.26) 61.42,83.55 67.97,83.55 69.19,82.33 83.88,82.33 88.46,86.92 94.47,86.92 96.9,89.35 96.9,89.56 102.12,94.78 106.55,94.78 107.43,93.9 107.43,91.14 106.87,90.59 106.87,89.64 107.22,89.29 107.71,89.29 109.25,90.83 109.65,90.83 109.67,90.84 115.07,90.84 117.16,88.76 118.75,88.76 120.4,87.11 124.44,87.11 127.15,84.4 v1(127.95,84.4)
  L6 w0.102: v1(59.72,85.26) 59.07,85.26 v1(57.32,87)
  BOTTOM w0.102: CPU1.E8 127.45,84.14 127.7,84.39 127.94,84.39 v1(127.95,84.4) ; R9932.2 58.41,84.92 58.74,85.26 v1(59.72,85.26)
JACK_PLUG: length 16.1
  TOP w0.254: v1(20.95,21.45) 20.95,20.43 R2923.1
  BOTTOM w0.254: v1(20.95,21.45) v2(20.32,20.81) 19.56,20.05 19.56,18.53 18.78,17.75 18.78,16.96 ED2902.1 18.04,16.22 17.35,16.22 17.3,16.16 17.26,16.16 16.76,15.66 15.01,15.66 14.36,16.31 14.3,16.45 14.3,17.05 13.44,17.92 12.57,17.92 11.6,16.94 HPMIC1.5
JACK_PLUG_DET: length 12.4
  TOP w0.254: v1(15.37,17.64) 15.27,17.54 R2901.1
  BOTTOM w0.254: HPMIC1.6 10.86,18.81 13.41,18.81 14.26,17.96 14.26,17.94 14.47,17.74 v2(14.53,17.74) 14.53,17.71 15.58,16.67 ED2902.2 16.54,17.12 16.03,17.64 v1(15.37,17.64)
JDREF: length 3.2
  TOP w0.102: HDA27.15 20.44,13.22 20.19,13.47 20.19,13.96 v2(19.58,14.56) 19.46,14.69 R2707.1
JET_SVC: length 1.6
  TOP w0.102: v1(184.05,83.32) 184.05,82.8 R7919.2
  BOTTOM w0.102: v1(184.05,83.32) 183.72,82.99 GPU1.P8
JET_SVD: length 3.9
  BOTTOM w0.102: GPU1.N1 187.89,83.77 189.67,83.77 189.91,84.01 v2(190.15,84.01) 190.15,84.01 190.83,84.69 R7920.2
JGND:
  vias: v3(50.8,108.7) v3(50.8,107.68) v3(51.31,106.79) v3(51.82,107.68) v3(52.32,106.79)
JTAG_TCK_VGA: length 7.9
  BOTTOM w0.102: TP7911.1 191.9,88.63 190.98,87.72 190.98,86.85 190.91,86.78 190.91,86.56 189.21,84.87 187.63,84.87 187.56,84.89 187.25,85.2 GPU1.L3
JTAG_TDI_VGA: length 5.7
  BOTTOM w0.089: 187.25,84.87 186.8,84.87 186.74,84.93 186.72,84.93 186.44,85.2 GPU1.L5
  BOTTOM w0.102: 187.25,84.87 187.39,84.73 187.6,84.67 189.33,84.67 190.75,86.09 TP7908.1
JTAG_TDO_VGA: length 3
  TOP w0.102: v1(188.59,86.18) 188.34,85.92 TP7913.1
  BOTTOM w0.102: GPU1.K4 186.6,86 187.01,86.41 188.09,86.41 188.32,86.18 v1(188.59,86.18)
JTAG_TMS_VGA: length 5.8
  BOTTOM w0.102: TP7912.1 190.78,88.15 190.78,86.94 190.7,86.86 190.7,86.65 189.26,85.2 GPU1.L1
JTAG_TRST#_VGA: length 8.5
  BOTTOM w0.089: 189.09,84.19 187.56,84.19 187.45,84.08 187.19,84.08 186.89,84.37 186.89,84.49 186.66,84.73 186.12,84.73 185.65,85.2 GPU1.L6
  BOTTOM w0.102: TP7907.1 191.29,85.48 190.75,85.48 189.46,84.19 189.09,84.19
KB_BL_CTRL#: length 9
  TOP w0.508: Q6501.D 186.71,57.26 186.36,56.91 186.36,54.47 AFTP6247.1 186.73,52.65 KBLIT1.4
KB_DET#: length 128.8
  TOP w0.102: KB1.30 196.93,15.9 196.55,16.28 196.55,17.01 196.24,17.32 193.86,17.32 187.62,23.56 186.99,23.56 186.88,23.45 v1(186.23,23.45) 186.04,23.45 185.55,23.94 185.04,23.94 184.84,23.73 AFTP6202.1 ; v1(130.06,60.45) 130.07,60.44 134.72,60.44 135.97,59.19 135.99,59.15 136.19,58.95 136.19,58.23 136.12,58.15 136.12,52.59 137.2,51.51 137.27,51.51 137.56,51.23 RN2001.1
  L4 w0.102: v1(130.06,60.45) 130.06,59.33 132.3,57.1 132.3,51.97 143.05,41.21 166.56,41.21 169.16,38.61 177.94,38.61 179.73,40.39 180.28,40.39 181.8,41.92 182.61,41.92 v1(182.79,42.1)
  L6 w0.102: v1(186.23,23.45) 184.55,25.12 184.55,26.09 184.66,26.2 184.66,27.24 184.37,27.53 184.37,37.37 183.46,38.27 183.46,41.42 v1(182.79,42.1)
  BOTTOM w0.102: CPU1.BB7 128.43,64.09 129.87,62.64 129.87,60.64 v1(130.06,60.45)
KB_LED_BL_DET: length 77.5
  TOP w0.102: v1(150.97,70.95) 150.78,70.95 150.48,71.25 v2(149.47,71.25) 149.47,71.09 148.69,70.32 144.83,70.32 143.99,69.48 140.11,69.48 139.95,69.33 138.2,69.33 v1(137.79,69.73)
  L3 w0.102: v1(125.71,76.06) 125.76,76.01 131.32,76.01 131.52,76.21 134.59,76.21 138.48,72.33 138.48,70.41 v1(137.79,69.73)
  L4 w0.102: v1(181.51,55.96) 180.26,55.96 178.97,57.25 178.97,60.31 178.08,61.2 168.53,61.2 163.7,66.03 163.7,68.54 161.82,70.42 154.59,70.42 154.11,70.9 153.21,70.9 152.82,70.51 151.41,70.51 v1(150.97,70.95)
  BOTTOM w0.102: v1(181.51,55.96) 181.51,54.86 181.8,54.57 R6507.1 182.64,53.76 R6503.1 ; CPU1.W8 127.91,76.46 127.51,76.06 v1(125.71,76.06)
KB_LED_DET_C: length 8
  TOP w0.102: v1(184.2,54.42) 183.77,53.98 183.77,53.43 AFTP6246.1 183.72,52.03 185.75,50 KBLIT1.2
  BOTTOM w0.102: R6503.2 183.53,54.26 C6502.1 184.06,54.28 v1(184.2,54.42)
KBC_BEEP_R: length 4.2
  BOTTOM w0.254: D2701.1 22.49,18.95 23.75,17.69 v2(23.83,17.69) 24.06,17.46 RN2701.4
KBC_PWRBTN#: length 2.4
  TOP w0.102: R6403.1 217.68,18.08 R2432.1 218.63,18.59 v2(218.82,18.4)
KBC_PWRBTN#_C: length 161.8
  TOP w0.127: v1(218.57,16.88) 218.12,17.32 R6403.2 ; v1(273.3,31.35) 273.18,31.23 272.29,31.23 271.02,29.96 270.26,29.96 270.13,29.83 268.22,29.83 267.72,30.34 AFTP6101.1 267.33,32.62 267.71,33 PWR1.2
  L4 w0.127: v1(273.3,31.35) 273.94,31.99 273.94,34.28 271.78,36.43 268.35,36.43 267.22,35.3 249.89,35.3 248.39,33.81 246.42,33.81 245.04,35.19 243.51,35.19 242.61,36.09 232.69,36.09 230.52,38.26 230.52,40.5 228.65,42.37 228.11,42.37 226.04,44.44 223.57,44.44 218.23,49.78 216.33,49.78 215.56,50.55 215.56,53.07 v1(215.39,53.24)
  L6 w0.127: v1(218.57,16.88) 221.12,14.32 224.88,14.32 227.89,11.31 229.34,11.31 229.93,11.91 239.3,11.91 240.24,12.85 241.23,12.85 250.14,21.76 250.14,23.75 253.13,26.74 264.38,26.74 267.46,29.83 271.37,29.83 272.9,31.35 v1(273.3,31.35)
  BOTTOM w0.127: EC6401.1 274.19,31.54 G6401.2 ; EC6401.1 ED6401.1 275.72,30.91 G6402.2 ; EC6401.1 273.62,31.67 v1(273.3,31.35) ; v1(215.39,53.24) 215.44,53.29 215.44,53.5 215.73,53.79 PWSW2.4 PWSW2.3
KSI0: length 32.9
  TOP w0.102: KBC24.98 203.11,21.91 202.89,22.13 198.6,22.13 198.43,22.3 KB1.22 196.56,22.3 194.26,24.6 192.07,24.6 191.77,24.9 191.77,25 191.19,25.59 191.15,25.59 188.05,28.69 185.89,28.69 185.87,28.66 185.61,28.66 185.58,28.69 176.53,28.69 AFTP6228.1 175.14,27.93 175.01,28.06 RN2412.8
KSI1: length 45
  TOP w0.102: KB1.24 196.21,20.7 193.79,23.12 193.14,23.12 v1(192.91,23.35) 192.71,23.35 187.78,28.28 186.06,28.28 185.45,27.67 AFTP6227.1 179.2,27.67 178.54,27.01 174.32,27.01 RN2412.6 ; KBC24.99 203.51,22.29 203.51,22.3 203.51,22.93 204.03,23.45 204.03,24.8 v1(204.34,25.11)
  L3 w0.102: v1(204.34,25.11) 204.06,25.11 203.5,25.66 202.81,25.66 200.74,23.59 200.74,23.22 199.77,22.26 195.12,22.26 194.03,23.35 v1(192.91,23.35)
KSI2: length 54.5
  TOP w0.102: v1(214.43,24.85) 214.54,24.74 KBC24.6 ; KB1.26 195.39,19.1 193.57,20.91 193.57,21.88 v1(193.68,21.98) 193.47,21.98 193.27,22.18 192.78,22.18 192.53,22.44 192.53,22.84 192.28,23.09 192.28,23.18 187.58,27.87 186.23,27.87 185.61,27.25 181.85,27.25 180.24,25.64 AFTP6218.1 179.07,25.64 178.71,25.99 177.14,25.99 176.53,25.39 174.34,25.39 RN2411.8
  L3 w0.102: v1(193.68,21.98) 193.8,21.85 199.94,21.85 202.64,24.56 203.25,24.56 203.34,24.47 204.61,24.47 205.09,24.95 206.16,24.95 206.66,24.45 207.02,24.45 207.76,25.18 210.39,25.18 210.72,24.85 v1(214.43,24.85)
KSI3: length 52.9
  TOP w0.102: v1(214.27,25.74) 214.84,25.17 215.33,25.17 215.36,25.14 KBC24.7 ; RN2412.7 177.29,27.41 AFTP6234.1 178.33,28.46 185.95,28.46 185.98,28.48 187.91,28.48 191.57,24.83 191.57,24.82 192.24,24.14 v1(192.74,24.14) 193.4,24.14 196.04,21.5 KB1.23
  L3 w0.102: v1(214.27,25.74) 213.74,25.21 210.65,25.21 210.47,25.39 208.17,25.39 207.69,25.87 202.73,25.87 200.16,23.3 195.05,23.3 194.08,24.27 192.86,24.27 v1(192.74,24.14)
KSI4: length 38.4
  TOP w0.102: RN2411.7 174.32,24.72 176.75,24.72 AFTP6230.1 178.03,25.28 180.17,25.28 181.9,27.01 187.88,27.01 192.33,22.57 192.33,22.35 192.46,22.23 192.46,21.78 193.37,20.86 193.37,20.83 195.3,18.9 195.34,18.9 195.93,18.3 KB1.27 198.47,18.3 199.08,18.91 202.4,18.91 203.01,19.52 204.83,19.52 205.52,20.21 KBC24.104
KSI5: length 48.6
  TOP w0.102: KBC24.105 205.92,23.4 206.83,24.32 206.83,24.87 v1(206.84,24.88) ; RN2412.5 175.27,26.26 AFTP6214.1 176.2,26.2 180.51,26.2 181.77,27.45 185.52,27.45 186.15,28.08 187.7,28.08 192.48,23.29 192.48,23.17 192.96,22.69 v1(192.96,22.62) 193.12,22.77 193.85,22.77 196.72,19.9 KB1.25
  L3 w0.102: v1(206.84,24.88) 206.56,25.16 205,25.16 204.52,24.67 204.16,24.67 203.38,25.46 202.89,25.46 200.94,23.51 200.94,23.14 199.86,22.06 194.54,22.06 193.98,22.62 v1(192.96,22.62)
KSI6: length 38
  TOP w0.102: KBC24.107 206.72,20.14 206.07,19.49 205.1,19.49 204.93,19.31 203.09,19.31 202.48,18.7 199.96,18.7 198.75,17.5 KB1.28 197.08,17.97 194.78,17.97 190.9,21.84 188.17,24.57 176.89,24.57 176.84,24.52 176.42,24.52 AFTP6222.1 175.51,24.12 RN2411.6
KSI7: length 39.8
  TOP w0.102: KBC24.108 207.12,20.23 206.17,19.29 205.21,19.29 205.03,19.11 203.24,19.11 202.82,18.69 202.82,17.64 202.79,17.61 202.79,17.59 202.54,17.33 202.51,17.33 202.34,17.16 202.01,17.16 201.55,16.7 KB1.29 197.22,16.7 196.26,17.67 193.8,17.67 193.37,18.09 193.37,18.61 187.61,24.37 178.31,24.37 AFTP6221.1 177.41,23.47 RN2411.5
KSO0: length 59.3
  TOP w0.102: KBC24.2 214.96,23.14 213.92,24.18 213.92,25.48 213.84,25.56 213.84,25.92 214.17,26.25 214.17,26.76 213.79,27.14 213.23,27.14 212.95,27.42 212.95,28.36 212.93,28.38 212.93,28.46 212.17,29.22 212.17,29.63 212.34,29.81 v1(212.34,30.08) ; KB1.13 196.72,29.5 193.95,32.27 193.15,32.27 v1(192.91,32.51) 192.89,32.51 192.88,32.51 192.5,32.51 191.54,33.47 190.61,33.47 190.39,33.69 188.95,33.69 187.3,32.04 184.93,32.04 183,33.97 176.1,33.97 AFTP6207.1 174.76,34.64 RN2404.5
  L3 w0.102: v1(212.34,30.08) 211.62,29.36 203.71,29.36 202.95,30.11 201.98,30.11 200.33,31.76 199.47,31.76 198.7,31 196.01,31 194.72,32.29 193.1,32.29 192.91,32.49 v1(192.91,32.51)
KSO1: length 52
  TOP w0.102: v1(213.36,28.56) 213.74,28.56 214.36,27.94 KBC24.14 ; RN2409.7 179.19,33 AFTP6206.1 181.28,33.39 181.46,33.56 182.83,33.56 185.44,30.96 186.3,30.96 186.5,30.95 186.83,30.95 187.04,31.15 192.25,31.15 192.41,31 192.92,31 v1(192.96,30.95) 193.04,31.02 193.75,31.02 194.01,30.77 194.54,30.77 196.47,28.84 196.47,28.43 197,27.9 KB1.15
  L3 w0.102: v1(192.96,30.95) 193.01,31 195.15,31 195.76,30.39 198.96,30.39 199.72,31.15 200.08,31.15 202.59,28.64 213.28,28.64 v1(213.36,28.56)
KSO2: length 52.5
  TOP w0.102: KB1.14 197.1,28.7 193.94,31.85 v1(192.94,31.85) 192.09,31.85 191.47,32.47 188.02,32.47 187.38,31.84 184.85,31.84 182.91,33.77 177.93,33.77 AFTP6226.1 177.53,33.65 176.28,33.65 175.92,33.28 175.62,33.28 175.25,33.65 RN2409.8 ; v1(212.6,29.45) 213.38,29.45 214.5,28.33 214.88,28.33 214.89,28.33 215.39,28.33 215.39,28.33 215.65,28.33 215.66,28.34 KBC24.15
  L3 w0.102: v1(212.6,29.45) 212.3,29.15 203.55,29.15 202.79,29.91 201.9,29.91 200.25,31.56 199.55,31.56 198.79,30.8 195.93,30.8 194.88,31.84 192.96,31.84 v1(192.94,31.85)
KSO3: length 51.4
  TOP w0.102: KBC24.16 216.65,28.73 215.76,28.73 215.56,28.53 215.31,28.53 214.93,28.53 214.02,29.45 v1(214,29.45) ; RN2409.6 175,32.5 AFTP6208.1 176.09,32.05 183.95,32.05 185.26,30.74 186.55,30.74 186.92,30.74 187.12,30.95 191.16,30.95 191.81,30.3 v1(193.84,30.3) 193.91,30.23 193.91,29.91 196.71,27.1 KB1.16
  L3 w0.102: v1(214,29.45) 214,28.58 213.54,28.13 212.29,28.13 211.99,28.43 201.94,28.43 200.23,30.13 194.07,30.13 193.91,30.3 v1(193.84,30.3)
KSO4: length 62
  TOP w0.102: v1(213.74,26.5) 213.51,26.5 211.91,28.1 211.91,33.06 213.51,34.66 KBC24.37 ; RN2410.6 175.35,29.71 175.58,29.47 175.92,29.47 176.15,29.71 177.67,29.71 AFTP6224.1 179.2,29.7 179.43,29.93 179.84,29.93 180.68,29.09 188.37,29.09 191.2,26.26 192.03,26.26 v1(192.07,26.22) 192.07,25.82 192.61,25.28 192.76,25.28 193.04,25 194.43,25 195.53,23.9 KB1.20
  L3 w0.102: v1(213.74,26.5) 212.42,26.5 211.76,25.84 211.56,25.84 211.51,25.79 208.34,25.79 207.86,26.27 202.01,26.27 200.13,24.39 194.72,24.39 193.83,25.28 192.61,25.28 192.07,25.82 v1(192.07,26.22)
KSO5: length 60.7
  TOP w0.102: RN2410.5 179.06,29.06 AFTP6215.1 180.26,28.89 188.14,28.89 191.24,25.79 191.39,25.79 192.1,25.08 v1(192.2,25.08) 192.66,25.08 192.94,24.8 194.34,24.8 196.04,23.1 KB1.21 ; v1(213.18,25.77) 212.72,26.22 212.72,27 211.71,28.02 211.71,33.14 213.11,34.55 KBC24.38
  L3 w0.102: v1(213.18,25.77) 213.06,25.64 211.65,25.64 211.6,25.59 208.25,25.59 207.77,26.07 202.64,26.07 200.76,24.19 194.61,24.19 193.73,25.08 v1(192.2,25.08)
KSO6: length 58.1
  TOP w0.102: KB1.18 196.96,25.5 196.5,25.96 194.42,25.96 v1(192.34,28.04) 190.53,28.04 189.08,29.5 185.47,29.5 183.49,31.48 AFTP6223.1 178.95,30.86 RN2410.8 ; KBC24.39 212.71,35.97 212.91,35.78 212.91,34.63 211.51,33.23 211.51,27.93 212.03,27.41 v1(212.03,26.72)
  L3 w0.102: v1(212.03,26.72) 211.24,26.72 211.13,26.6 210.77,26.6 210.67,26.71 209.32,26.71 208.84,26.22 208.48,26.22 208.02,26.69 200.31,26.69 200.19,26.81 198.47,26.81 197.97,26.3 194.04,26.3 192.41,27.94 192.41,27.98 v1(192.34,28.04)
KSO7: length 56.8
  TOP w0.102: v1(210.19,26.27) 210.36,26.45 210.36,28.93 208.33,30.96 208.33,35.93 208.32,35.94 KBC24.50 ; RN2410.7 175.14,30.21 175.51,29.83 AFTP6213.1 176.07,30.13 184.27,30.13 185.11,29.3 188.9,29.3 190.75,27.44 192.33,27.44 192.77,27 v1(192.77,26.46) 192.79,26.46 194.05,25.21 194.51,25.21 195.02,24.7 KB1.19
  L3 w0.102: v1(210.19,26.27) 209.18,26.27 208.92,26.02 208.4,26.02 207.94,26.48 201.5,26.48 199.62,24.6 195.14,24.6 193.27,26.46 v1(192.77,26.46)
KSO8: length 57
  TOP w0.102: v1(210.95,27.04) 210.59,27.39 210.59,27.84 210.57,27.87 210.57,31.35 209.37,32.55 209.37,34.2 210.04,34.86 210.04,35.92 209.91,36.04 KBC24.46 ; RN2409.5 175.15,31.85 175.62,31.38 175.92,31.38 176.39,31.85 177.43,31.85 AFTP6231.1 177.9,31.84 183.79,31.84 185.08,30.54 186.66,30.54 186.92,30.29 188.9,30.29 190.51,28.68 v1(192.34,28.68) 192.34,28.66 192.77,28.22 192.77,28.13 194.6,26.3 KB1.17
  L3 w0.102: v1(210.95,27.04) 209.18,27.04 209.13,27.09 204.15,27.09 203.95,26.89 200.4,26.89 200.28,27.01 198.38,27.01 197.87,26.5 194.13,26.5 192.77,27.86 192.77,28.25 v1(192.34,28.68)
KSO9: length 32.2
  TOP w0.102: v1(198.88,33.51) 198.88,33.64 198.22,34.3 KB1.7 196.99,34.3 196.65,34.64 196.65,35.38 195.07,36.96 194.08,36.96 193.29,37.75 176.07,37.75 AFTP6219.1 ; KBC24.68 v1(202.44,33.94)
  L3 w0.102: v1(202.44,33.94) 199.31,33.94 v1(198.88,33.51)
  BOTTOM w0.102: R2450.1 201.36,34.66 R2449.2 202.44,34.34 v1(202.44,33.94)
KSO10: length 30.8
  TOP w0.102: KBC24.72 200.18,32.34 199.64,32.88 199.64,34.28 198.02,35.9 KB1.5 196.71,35.9 195.21,37.4 194.26,37.4 193.5,38.16 181.76,38.16 180.47,39.46 179.43,39.46 179.2,39.23 AFTP6232.1 177.66,39.24 175.73,39.24 175.72,39.23 175.36,39.23 175.35,39.24 RN2403.8
KSO11: length 31.5
  TOP w0.102: KBC24.74 199.71,31.54 199.31,31.94 199.31,33.97 198.18,35.1 KB1.6 197.22,35.1 195.12,37.2 194.16,37.2 193.4,37.96 181.68,37.96 181.47,38.16 180.52,38.16 AFTP6220.1 179.07,38.59 RN2403.7
